# Allegro board LA-F211P R10-0105.brd (continued)
## Nets (continued)
Pads without a net: DL1 2; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JCAM1 4 5; JCR1 14; JDGPU1 8 9; JEDP1 37; JIO1 C11 D12 M5 N9 N10 P11 Q3 R11; JKB1 9 18; JNGFF2 6 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 59; JSPI2 2 3 4 9; PD107 2; PD109 2; PQ147 3 4 5; PR1113 1; PR1114 1; PU102 1; PU300 3; PU501 13; PU600 4; PU601 4; PU602 4; PU603 4; PU700 10 12; PU1000 10 12; PU1800 14 18 49; PU1900 6 17; PU1901 6 17; PU2000 6 17; PU2201 6 17; PU2301 1; PU2302 1; PU2303 1; PU2304 10 12; RP3 7; RP6 3 6; SW4 2 3; U15 1 9; U18 11; UC1 A7 A10 A12 A15 A17 A20 A22 A24 A26 A42 AA11 AA13 AA14 AB7 AB9 AB11 AB12 AB13 AB14 AD7 AD8 AD10 AD11 AD14 AE8 AE9 AE11 AE12 AE14 AF2 AF3 AF5 AF6 AG7 AG8 AG10 AG11 AG14 AH1 AH2 AH4 AH5 AH8 AH9 AH11 AH12 AH14 AJ2 AJ3 AJ5 AJ6 AK14 AL1 AL2 AL4 AL5 AL14 AN14 AP13 AP14 AT13 AT14 AU13 AU14 AV13 AV14 AW13 AW14 AY13 AY14 B7 B10 B11 B12 B13 B15 B16 B17 B18 B20 B21 B22 B23 B24 B25 B26 B43 BB13 BB14 BC13 BC16 BC17 BC18 BC19 BC20 BC21 BC22 BC23 BC24 BC25 BC26 BC27 BC28 BC29 BC30 BC31 BC32 BC33 BC34 BC35 BE13 BE14 BE15 BE17 BE19 BE21 BE23 BE25 BE27 BE29 BE31 BE33 BE35 BE36 BE37 BG13 BG15 BG17 BG18 BG19 BG20 BG21 BG22 BG23 BG24 BG25 BG26 BG27 BG28 BG29 BG30 BG31 BG32 BG33 BG34 BG36 BG37 BH13 BH14 BH15 BH17 BH19 BH21 BH23 BH25 BH27 BH29 BH31 BH33 BH35 BJ15 BJ16 BJ17 BJ18 BJ19 BJ20 BJ21 BJ22 BJ23 BJ24 BJ25 BJ26 BJ27 BJ28 BJ29 BJ30 BJ31 BJ33 BJ34 BJ35 BK13 BK14 BL2 BL4 BL13 BL15 BL17 BL19 BL21 BL23 BL25 BL27 BL29 BL31 BL33 BL35 BM1 BM2 BM4 BM5 BM7 BM8 BM9 BM10 BM11 BM15 BM16 BM17 BM18 BM19 BM20 BM21 BM22 BM23 BM24 BM25 BM26 BM27 BM28 BM29 BM30 BM31 BM32 BM33 BM34 BM35 BP10 BV8 BV10 BV11 BW1 BW2 BW3 BY1 BY2 BY3 C4 C5 C11 C13 C16 C18 C21 C23 C25 CA7 CA8 CA10 CA11 CF7 CF10 CF11 CG2 CG3 CG5 CJ7 CJ8 CJ9 CJ10 CJ11 CL1 CL2 CL3 CL4 CL5 CL7 CL8 CL9 CL10 CL11 CM1 CM2 CM3 CM4 CM5 D4 D5 D7 D10 D12 D15 D17 D20 D22 D24 D26 DC23 DC24 DC25 DD24 DD25 DE1 DE25 DG1 DH2 DH3 DH4 E3 E5 E6 E7 E9 E10 E11 E12 E13 E15 E16 E17 E18 E20 E21 E22 E23 E24 E25 E26 F6 F9 F11 F13 F16 F18 F21 F23 F25 G2 G7 G17 G20 G22 G24 G26 H3 H4 H6 H11 H12 H13 H14 H16 H17 H18 H20 H21 H22 H23 H24 H25 H26 H28 H29 H30 H31 H32 H34 H35 H36 J17 J20 J22 J24 J26 J29 J31 J34 J36 K7 K11 K13 K14 K16 K17 K18 K20 K21 K22 K23 K24 K25 K26 K28 K29 K30 K31 K32 K34 K35 K36 K44 K45 L2 L3 L4 L6 L8 L9 L11 L12 L13 L14 L16 L38 L39 L40 M5 M7 M8 M11 M13 M14 M16 M38 M39 N2 N3 N6 N38 N39 N42 N43 P2 P4 P8 P9 P11 P12 P13 P14 P38 P39 R6 R7 R8 R11 R13 R14 T38 T39 T42 U2 U11 U12 U13 U14 V2 V11 V13 V14 W4 W11 W12 W13 W14; UC6 1; UC9 1; UD1 T7; UD2 T7; UD3 T7; UD4 T7; UD5 T7; UD6 T7; UD7 T7; UD8 T7; UE2 2 5 6 7 10 11 12 13 15 25 26 28 30 31; UE7 1; UE13 1; UH4 A9 A21 A23 AA1 AA2 AA44 AA45 AB2 AB3 AB13 AB33 AB35 AB44 AC2 AC3 AC43 AD2 AD3 AE17 AF17 AG14 AG15 AG44 AH43 AH44 AJ11 AJ13 AJ42 AJ44 AL27 AM43 AM44 AN17 AN24 AN29 AN36 AN41 AN42 AN43 AR15 AR17 AR19 AR22 AR27 AT43 AV15 AW35 AY44 B10 B14 B15 B19 B20 B21 B22 B23 B24 BA4 BA35 BB17 BB36 BB39 BC8 BC35 BC36 BD1 BD23 BD34 BD35 BD39 BE2 BE34 C13 C14 C15 C19 C20 C23 C24 D3 D5 D7 D8 D13 E6 E17 E20 E22 E45 F2 F45 G13 G17 G19 G22 G37 G44 G45 H13 H40 H42 H43 H44 J45 K13 K15 K17 K22 K24 K37 K44 L5 L7 L17 L22 L24 L37 L39 L44 M45 N2 N3 N29 N31 N38 N39 N42 N43 N44 P1 P2 P3 P24 P27 P29 P31 P44 R2 R3 R4 R11 R13 R24 R27 R35 R36 R41 R42 R43 T44 T45 U2 U3 U13 U36 U39 U42 V1 V2 V44 W7 W13 W39 Y5; UH6 9; UPD1 B6 B7 F10 G8 G10 H4 H5 H8 K5; UR1 31; US5 6 7 14; US6 6 7 14; UT2 A23 B23 E18 J1 J2 L1 L2 N1 N2 R1 R2 V18 W19 Y19; UZ6 3

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 908 vias
v2: diameter 0.254, hole 0.102, TOP to IN1, 742 vias
v3: diameter 0.254, hole 0.102, IN3 to BOTTOM, 1022 vias
v4: diameter 0.254, hole 0.102, IN1 to GND2, 881 vias
v5: diameter 0.406, hole 0.203, GND2 to GND3, 3485 vias
v6: diameter 0.254, hole 0.102, GND3 to BOTTOM, 2482 vias
v7: diameter 0.254, hole 0.102, TOP to GND2, 2203 vias
v8: diameter 0.254, hole 0.102, GND3 to IN3, 1399 vias
v9: diameter 0.457, hole 0.203, TOP to BOTTOM, 2310 vias
v10: diameter 0.508, hole 0.254, TOP to BOTTOM, 31 vias
v11: diameter 0.254, hole 0.102, TOP to GND1, 943 vias
v12: diameter 0.254, hole 0.102, GND1 to IN1, 420 vias
v13: diameter 0.254, hole 0.102, IN3 to GND4, 1014 vias
v14: diameter 0.254, hole 0.102, GND4 to BOTTOM, 1714 vias
v15: diameter 0.254, hole 0.102, GND3 to GND4, 209 vias
v16: diameter 0.406, hole 0.203, TOP to BOTTOM, 124 vias
v17: diameter 0.254, hole 0.102, GND1 to GND2, 518 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2V_DDR_OT: length 1.3
  BOTTOM w0.203: PR802.2 82.18,96.04 PU800.11
1.2V_DDR_PG: length 161.7
  TOP w0.127: v2(28.85,24.77) 29.69,24.77 30.92,23.54 30.92,20.05 30.24,19.36 30.24,17.77 30.53,17.48 30.53,16.86 29.5,15.83 v1(29.5,14.02) RE180.2
  IN1 w0.064: v2(28.85,24.77) 28.85,26.02 27.39,27.47 27.11,27.47 22.01,32.58 22.01,42.06 21.59,42.48 21.59,43.23 21.03,43.8 21.03,45.9 21.54,46.41 21.89,46.41 22.3,46.82 22.3,49.28 21.79,49.79 21.79,54.09 22.7,55.01 22.7,56.85 27.59,61.73 33.78,61.73 33.96,61.91 37.87,61.91 38.55,62.59 38.55,63.3 38.99,63.74 38.99,68.13 39.15,68.3 39.15,70.88 40.07,71.8 40.07,74.29 40.37,74.59 40.37,80.62 41.03,81.28 41.03,86.43 41.07,86.47 41.07,90.37 41.49,90.78 41.49,96.92 42.81,98.25 48.91,98.25 50.32,99.66 58.64,99.66 60.09,98.21 66.83,98.21 68.88,96.17 69.45,96.17 69.85,95.78 71.54,95.78 73.26,97.5 76.21,97.5 76.91,98.19 76.91,98.33 77.07,98.49 v4(77.43,98.49)
  GND2 w0.102: v4(77.43,98.49) 77.67,98.25 v5(77.67,98.1)
  GND3 w0.102: v5(77.67,98.1) v8(77.67,97.77)
  IN3 w0.064: v3(80.26,95.54) 80.26,96.55 79.04,97.77 v8(77.67,97.77) 76.9,97.77 74.67,95.54 74.67,92.89 74.8,92.77 v3(74.8,91.34)
  BOTTOM w0.127: PR806.1 73.49,90.77 73.99,91.27 74.72,91.27 v3(74.8,91.34)
  BOTTOM w0.203: PU800.12 v3(80.26,95.54)
1.2V_DDRP_FB: length 6.9
  TOP w0.203: v9(82.9,95.01) 82.01,95.01 81.58,95.45 PR804.1 81.84,95.91 PC802.2 81.83,96.58 PR803.2
  BOTTOM w0.127: v9(82.9,95.01) v1(83.99,95.01)
  BOTTOM w0.203: PU800.13 81.54,95.04 81.76,94.82 82.71,94.82 v9(82.9,95.01)
1.2V_DDRP_LX: length 2.6
  TOP w0.127: PR801.1 79.47,100.56 v1(78.97,101.07)
  TOP w0.508: v9(78.9,98.95) 78.9,99.29 PR801.1
1.2V_DDRP_VIN: length 2.7
  TOP w0.127: PC808.1 81.47,91.97 v1(81.53,92.03)
  TOP w0.508: PC808.1 80.63,92.46 v9(80.43,92.67) 80.51,92.67 80.95,93.1 PC809.1
1.05V_VMMP_ALW_VIN:
  vias: v1(20.35,18.75)
1.8V_PRIM_PWRGD: length 4.9
  TOP w0.127: RE245.1 45.69,5.61 v1(45.25,6.05) 45.25,6.8 45.58,7.14 45.58,7.27 45.97,7.65 45.97,8.97 UE3.L7
1.8VALW_VIN:
  vias: v1(70.58,77.62)
1.8VALWP_FB: length 4.4
  BOTTOM w0.203: PR1504.2 67.56,82.35 67.56,81.81 67.51,81.76 PU1500.1 ; PR1504.2 67.46,82.43 66.44,81.41 66.44,80.99 PC1502.2 ; PR1504.2 67.48,83.13 PR1505.1
1.8VALWP_LX: length 1.1
  BOTTOM w0.127: 68.02,74.21 68.68,73.55 v1(68.81,73.55)
  vias: v3(66.65,74.76) v3(67.03,74.76) v3(67.28,75.65) v3(67.28,75.27) v3(67.28,75.01) v3(67.54,75.65) v3(67.54,75.27) v3(67.54,75.01) v3(68.12,78.8) v3(68.17,78.47) v3(68.32,79.43) v3(68.35,79.08) v3(68.47,78.75) v3(68.5,78.36) v3(68.65,79.3) v3(68.7,78.97) v3(68.75,78.57)
1.8VALWP_ON: length 4.4
  BOTTOM w0.203: PU1500.2 67.96,81.56 68.49,82.09 68.49,83 PC1500.1 68.88,83.39 PR1502.1 69.74,83.43 PR1500.2
1.8VALWP_PG: length 156.5
  TOP w0.127: v7(70.71,27.27) v16(71.15,26.83) 71.41,26.58 71.41,25.61 72.53,24.49 72.53,22.17 71.29,20.94 71.29,17.57 70.8,17.07 70.8,13.44 67.54,10.18 66.39,10.18 62.55,6.34 61.16,6.34 v2(60.88,6.06) ; v7(45.69,3.87) RE245.2
  IN1 w0.064: v7(45.69,3.87) 46.62,3.87 48.38,5.63 48.38,7.35 49.05,8.02 50.73,8.02 51.65,7.11 54.16,7.11 54.6,6.67 55,6.67 55.07,6.74 55.95,6.74 56.31,6.37 60.56,6.37 v2(60.88,6.06)
  GND2 w0.102: v7(45.69,3.87) 45.37,4.18 v5(45.37,4.27) ; v7(70.71,27.27) v5(70.09,27.27)
  IN2 w0.074: v5(58.26,72.41) 58.26,72.28 56.01,70.03 56.01,66.91 52.39,63.29 52.39,62.59 51.01,61.2 51.01,55.31 54.92,51.39 54.92,44.83 53.69,43.6 53.69,35.43 55.32,33.79 55.32,32.06 60.14,27.24 70.05,27.24 v5(70.09,27.27)
  GND3 w0.102: v8(45.04,4.27) v5(45.37,4.27) ; v8(58.26,72.83) v5(58.26,72.41)
  IN3 w0.064: v6(68.59,81.32) 68.55,81.36 65.96,81.36 60.65,76.05 60.65,73.89 59.58,72.83 v8(58.26,72.83) ; v8(45.04,4.27) 45.04,4.46 44.26,5.24 43.38,5.24 43.08,5.55 40.92,5.55 39.81,6.66 39.81,6.81 38.6,8.03 36.44,8.03 35.77,8.7 33.35,8.7 32.88,9.18 31.34,9.18 30.27,10.24 30.27,12.24 27.96,14.55 27.96,14.97 26.45,16.48 v3(26.45,16.78)
  BOTTOM w0.127: PR1507.1 69.86,82.24 RE295.1 69.4,82.14 v6(68.59,81.32) ; LED_PRI.1 25.74,17.49 v3(26.45,16.78)
1VALW_PG: length 120.1
  IN2 w0.074: v5(71.65,82.25) 71.65,82.56 71.01,83.19 70.22,83.19 66.19,87.23 66.19,92.88 65.27,93.79 65.06,93.79 61.36,97.49 60.15,97.49 58.81,98.83 58.81,99.78 58.6,99.99 57.97,99.99 53.66,104.3 36.98,104.3 35.75,105.53 32.28,105.53 30.11,103.36 30.11,102.45 29.16,101.5 28.33,101.5 26.92,100.09 26.92,98.49 25.13,96.71 22.98,96.71 20.79,94.52 20.79,90.35 18.57,88.13 18.57,79.43 19.62,78.38 19.62,72.57 17.47,70.42 17.47,66.72 15.53,64.77 15.53,63.68 12.96,61.12 v5(12.96,54.12)
  GND3 w0.102: v6(12.3,54.12) v5(12.96,54.12) ; v5(71.65,82.25) 71.65,82.33 v6(71.95,82.63)
  BOTTOM w0.127: RE295.2 69.52,82.94 71.65,82.94 v6(71.95,82.63) 72.66,82.63 v1(72.96,82.34)
2.5V_MEM_PG: length 160
  TOP w0.127: v2(76.23,97.24) 76.08,97.08 v1(76.08,96.22) 76.08,95.74 76.53,95.29 78.41,95.29 78.57,95.46 78.57,96.21 78.71,96.35 PR813.1
  IN1 w0.064: v2(84.35,111.26) 83.66,110.57 81.12,110.57 77.92,107.37 77.92,98.57 76.59,97.24 v2(76.23,97.24) 73.2,97.24 71.6,95.64 69.67,95.64 69,94.97 68.18,94.97 67.61,95.54 67.61,95.86 65.99,97.49 58.95,97.49 58.49,97.95 53.11,97.95 52.44,97.29 43.26,97.29 42.48,96.51 42.48,91.98 43.33,91.13 43.33,86.31 44.4,85.24 44.4,71.9 41.91,69.41 41.91,64.67 40.1,62.86 40.1,62.33 38.4,60.63 37.52,60.63 35.6,58.71 34.83,58.71 33.85,57.73 32.89,57.73 32.74,57.88 32.74,57.97 32.39,58.31 30.76,58.31 28.94,56.49 28.94,55.61 28.04,54.72 28.04,53.56 25.79,51.3 25.79,50.02 25.14,49.37 25.14,44.57 24.51,43.93 24.51,36.97 24.88,36.59 24.88,35.56 27.36,33.08 28.97,33.08 31.3,30.75 31.3,27.86 31.85,27.31 31.85,21.59 30.23,19.98 30.23,19.98 28.01,17.76 v4(27.39,17.76)
  GND2 w0.102: v5(26.95,17.86) 27.06,17.76 v4(27.39,17.76)
  GND3 w0.102: v6(27.02,18.4) 27.02,17.94 26.95,17.87 v5(26.95,17.86)
3.3V_CAM_EN#: length 182.9
  TOP w0.127: v2(70.33,95.33) 70.68,95.33 71.18,94.84 71.18,93.26 v1(70.96,93.05) 70.96,92.36 73.21,90.11 83.92,90.11 84.67,89.36 89.01,89.36 89.37,89.72 91.51,89.72 91.87,89.36 134.85,89.36 137.19,87.02 v2(137.19,86.41) ; v2(148.56,100.74) 148.56,100.06 RZ50.1
  IN1 w0.064: v2(70.33,95.33) 69.62,95.33 69.09,94.8 67.91,94.8 65.69,97.03 63.81,97.03 63.36,96.58 53.38,96.58 50.47,93.66 49.29,93.66 48.6,92.97 48.6,92.01 46.21,89.62 46.21,87.62 46.46,87.37 46.46,85.2 45.8,84.54 45.8,71.91 42.9,69.01 42.9,64.25 41.08,62.44 41.08,61.92 37.63,58.46 37.34,58.46 33.68,54.81 32.77,54.81 31.26,53.3 31.26,52.77 30.99,52.51 30.38,52.51 29.78,51.91 29.78,51.11 29.5,50.83 29.23,50.83 28.72,50.32 28.72,49.58 28.21,49.06 28.21,48.09 27.77,47.65 27.77,47.01 28.17,46.62 28.17,45.39 27.7,44.93 27.7,43.72 27.34,43.36 27.34,42.76 27.02,42.45 v4(27.02,42.25) ; v2(137.19,86.41) 143.39,92.6 143.39,97.17 143.86,97.65 143.86,99.47 144.74,100.35 146.52,100.35 146.91,100.74 v2(148.56,100.74)
  GND2 w0.102: v4(27.02,42.25) 26.76,41.98 v5(26.76,41.97)
  GND3 w0.102: v5(26.76,41.97) 26.51,41.72 v6(26.47,41.72)
3.3V_MSATA_EN: length 5.3
  BOTTOM w0.076: v1(22.58,49.17) 23.09,48.66 23.34,48.66 23.48,48.52 24.36,48.52 24.46,48.41 25.74,48.41 25.75,48.4 26.04,48.4 26.18,48.54 UH4.BD27
  BOTTOM w0.127: v1(22.58,49.17) 22.32,49.42 RH193.1
3.3V_TS_EN: length 75.1
  TOP w0.127: v7(58.37,99.27) 58.71,99.27 v1(58.77,99.2) 58.82,99.15 v2(58.82,95.76)
  IN1 w0.064: v2(58.82,95.76) 56.06,95.76 55.53,95.24 54.88,95.24 54.14,94.5 53.72,94.5 53.27,94.05 53.27,93.62 51.49,91.84 51.49,91.5 48.62,88.63 48.62,86.05 47.53,84.96 47.53,71.2 44.66,68.33 44.66,63.25 43.1,61.69 43.1,60.76 39.15,56.81 38.85,56.81 38.73,56.7 38.73,55.62 38.41,55.29 38.41,54.58 38.02,54.2 37.12,54.2 36.65,53.72 36.65,53.02 36.3,52.67 35.82,52.67 35.58,52.43 35.58,51.75 35.05,51.22 34.67,51.22 33.9,50.45 33.07,50.45 32.1,49.48 31.69,49.48 v4(31.62,49.41)
  GND2 w0.102: v5(58.37,99.65) v7(58.37,99.27) ; v5(31.29,49.41) v4(31.62,49.41)
  GND3 w0.102: v5(31.29,49.41) 31.26,49.41 31.17,49.31 v6(30.92,49.31) ; v5(58.37,99.65) 58.37,99.98 v6(58.34,100.01)
  BOTTOM w0.127: v6(58.34,100.01) 58.84,100.5 58.84,102.95 57.71,104.08 57.71,105.06 RZ13.1 56.79,104.88 UZ4.3
3VALW_EN: length 4.4
  BOTTOM w0.203: PR606.1 14.07,22.31 14.2,22.18 ; 14.2,22.18 13.88,21.86 v1(13.19,21.86) 12.54,22.51 12.54,22.69 12.28,22.95 PU600.11 ; 14.2,22.18 PR604.2
3VALW_LX: length 4.2
  TOP w0.127: PR602.1 v1(8.48,24.21)
  TOP w0.508: v9(10,25.36) PR602.1
  BOTTOM w0.203: PU600.7 10.16,25.07 v9(10,25.36)
3VALW_VIN:
  vias: v1(12.04,20.02) v9(11.43,20.15) v9(11.4,19.08) v9(11.71,19.59)
3VD_EN: length 2.8
  TOP w0.203: PR625.1 63.79,106.15 63.68,106.04 PU603.11
  TOP w0.254: PR623.2 63.17,106.3 63.43,106.57 PR625.1
3VD_LX:
  vias: v1(69.88,103.65) v9(69.06,107.21) v9(69.06,106.64) v9(69.06,106.06) v9(69.06,105.49) v9(69.06,104.92) v9(69.06,104.35) v9(69.06,103.18) v9(69.08,103.76) v9(69.62,103.05) v9(69.69,107.21) v9(69.69,106.64) v9(70.2,103.05) v9(70.27,106.64) v9(70.81,103.05) v9(70.96,106.64)
3VD_VIN:
  vias: v1(58.53,103.91) v9(62.14,104.22) v9(62.52,104.73)
5VALW_EN: length 5.5
  BOTTOM w0.127: PR612.1 61.53,80.05 61.95,80.48 v1(61.95,81.75)
  BOTTOM w0.203: PR612.1 61.14,79.79 PR611.2 60.62,79.81 58.77,79.81 58.56,80.03 PU601.11
5VALW_LX: length 2.5
  TOP w0.127: v1(58.01,80.92) PR609.1
  TOP w0.508: v9(55.72,81.36) 56.17,80.92 PR609.1
5VALW_VIN:
  vias: v1(57.76,77.3)
5VD_EN: length 4
  BOTTOM w0.254: PU602.11 125.7,25.98 126.84,27.13 PR618.1 127,27.86 127.54,28.4 PR617.2
5VD_LX: length 1.5
  TOP w0.127: v1(124.37,21.16) 124.06,21.47 v9(124.06,22.57)
  vias: v9(124.06,23.15)
5VD_VIN:
  vias: v9(127.19,24.97)
+0.6V_A_VREFDQ: length 0.7
  GND2 w0.254: v7(131.04,78.44) v5(131.28,78.68)
  GND3 w0.254: v5(131.28,78.68) 131.21,78.62 131.21,78.51 v6(131.1,78.4)
+0.6V_B_VREFDQ: length 5.6
  BOTTOM w0.127: RD228.1 135.47,77.56 v1(135.8,77.23)
  BOTTOM w0.254: UC1.DG13 132.16,77.98 132.81,77.98 132.94,77.86 134.18,77.86 134.59,78.26 CD324.1 134.6,78.44 RD228.1
+0.6V_DDR_B_VREFDQ: length 108.9
  TOP w0.254: CD320.1 103.69,105.82 v7(103.36,105.49)
  TOP w0.305: UD6.M1 102.78,105.49 v7(103.36,105.49) ; UD5.M1 113.17,105.49 114.79,105.49 CD321.1
  TOP w0.508: CD321.1 RD227.1 RD226.2 116.91,105.44 v7(117.29,105.06)
  IN1 w0.508: v4(141.78,101.36) 142.78,100.36 142.78,97.41 143.02,97.17 143.02,93.18 142.99,93.15 v4(142.88,93.15) ; v4(143.74,89.85) 143.74,82.33 145.78,80.28 v4(145.78,77.87)
  GND2 w0.254: v5(103.96,105.44) 103.91,105.49 v7(103.36,105.49)
  GND2 w0.305: v7(117.29,105.06) v5(117.29,104.7)
  GND2 w0.508: v4(143.74,89.85) 143.74,89.92 143.23,90.43 v5(143.21,90.43) ; v5(142.99,92.68) 142.88,92.78 v4(142.88,93.15) ; v4(145.78,77.87) 145.17,77.26 v5(145.17,77.13) ; v5(140.76,101.15) 140.98,101.36 v4(141.78,101.36)
  IN2 w0.508: v5(140.76,101.15) 140.1,101.15 137.74,98.79 131.52,98.79 131.25,99.06 128.3,99.06 127.94,98.7 127.92,98.7 127.17,97.95 123.19,97.95 122.86,97.62 121.15,97.62 119.17,99.6 119.17,102.76 117.29,104.64 v5(117.29,104.7) 115.85,104.7 112.47,101.33 111.45,101.33 110.72,102.06 107.58,102.06 106.92,102.72 106.92,104.46 105.94,105.44 v5(103.96,105.44) 101.67,103.16 100.68,103.16 100.05,102.52 96.77,102.52 96.28,103.02 v5(96.28,104.69)
  GND3 w0.254: v5(96.28,104.69) 96.28,104.79 v6(95.98,105.09)
  GND3 w0.305: v6(104.38,106.03) 103.96,105.61 v5(103.96,105.44)
  GND3 w0.508: v6(144.45,77.2) 145.11,77.2 v5(145.17,77.13) ; v5(143.21,90.43) 142.99,90.65 v8(142.99,90.95) ; v5(142.99,92.68) v8(142.99,92.16)
  IN3 w0.508: v8(142.99,90.95) v8(142.99,92.16)
  BOTTOM w0.305: CD322.1 94.61,105.29 94.81,105.09 v6(95.98,105.09)
  BOTTOM w0.356: UD7.M1 105.44,106.03 v6(104.38,106.03)
  BOTTOM w0.508: v6(144.45,77.2) 143.56,77.2 142.82,77.94 v1(137.95,77.94) 136.89,77.94 RD228.2
+0.6V_DDR_VREFCA: length 57.3
  TOP w0.305: v7(130.29,105.73) 128.92,105.73 UD2.M1 ; UD1.M1 139.07,105.49 v7(140.65,105.49)
  TOP w0.508: v7(142.54,96.77) RD162.1 142.54,94.98 RD161.2
  GND2 w0.305: v5(129.85,106.13) 130.25,105.73 v7(130.29,105.73) ; v5(140.67,105.11) 140.67,105.48 v7(140.65,105.49)
  GND2 w0.508: v7(142.54,96.77) v5(143.02,96.77)
  IN2 w0.508: v5(143.02,96.77) 143.02,103.31 141.22,105.11 v5(140.67,105.11) 138.74,103.18 137.47,103.18 136.69,102.39 132.53,102.39 131.33,103.6 131.01,103.6 130.43,104.18 130.43,105.56 v5(129.85,106.13) 128.77,105.06 128.77,104.39 127.45,103.07 127.23,103.07 126.65,102.49 124.18,102.49 123.57,101.89 121.89,101.89 121.55,102.23 121.55,102.95 120.16,104.34 120.16,104.65 v5(118.26,106.56)
  GND3 w0.305: v6(130.29,106.57) v5(129.85,106.13) ; v6(117.67,106.56) v5(118.26,106.56)
  BOTTOM w0.305: UD3.M1 131.92,105.44 131.7,105.44 130.57,106.57 v6(130.29,106.57) ; CD316.1 119.76,104.78 120.8,104.78 121.11,105.09 UD4.M1
  BOTTOM w0.508: CD316.1 118.58,104.82 v1(118.55,104.84) 118.07,105.32 118.07,105.68 118,105.75 118,105.77 117.67,106.09 v6(117.67,106.56)
+0.6V_VREFCA: length 25.2
  TOP w0.508: v2(141.51,89.71) v1(140.98,89.71) 140.02,89.71 CD291.1
  IN1 w0.508: v4(143.93,93) 143.93,92.43 141.51,90.01 v2(141.51,89.71) 141.34,89.71 138.98,87.35 v4(138.98,86.13)
  GND2 w0.508: v4(143.93,93) 143.93,93.39 v5(144.07,93.53) ; v5(139.02,85.64) 139.02,86.1 v4(138.98,86.13) ; v7(142.53,94.05) v5(142.95,94.47)
  IN2 w0.508: v5(144.07,93.53) 143.12,94.47 v5(142.95,94.47) ; 134.46,79.2 134.46,81.24 133.83,81.87 133.83,84.03 135.44,85.64 v5(139.02,85.64)
  GND3 w0.254: v5(130.65,78.67) 130.65,78.62 130.45,78.41 v6(130.45,78.4)
+0.6VS: length 34.6
  GND2 w0.305: v5(136.53,109.89) v4(136.53,110.29) ; v4(130.55,110.39) 130.5,110.45 v5(130.2,110.45) ; v5(131.71,109.9) v4(131.71,110.28) ; v5(134.74,109.91) v4(134.74,110.29) ; v5(132.33,109.91) v4(132.33,110.29) ; v5(134.12,109.92) v4(134.12,110.31) ; v17(142.87,111.04) 143.23,111.04 143.54,110.72 v5(143.54,110.7) ; v5(142.95,107.85) 142.87,107.78 142.6,107.78 v7(142.53,107.7) ; v5(143.13,107.27) 143.42,107.56 v7(143.42,107.7)
  GND3 w0.254: v5(143.13,107.27) 143.38,107.52 v6(143.42,107.52)
  GND3 w0.305: v6(129.84,110.45) v5(130.2,110.45) ; v6(143.14,108.35) 143.14,108.22 142.95,108.03 v5(142.95,107.85) ; v6(136.53,110.32) v5(136.53,109.89) ; v6(132.33,110.32) v5(132.33,109.91) ; v6(131.71,110.32) v5(131.71,109.9) ; v6(134.74,110.32) v5(134.74,109.91) ; v6(134.12,110.32) v5(134.12,109.92)
  GND3 w0.508: v6(144.08,110.31) 144.01,110.37 143.87,110.37 v5(143.54,110.7)
  IN3 w1.016: 88.87,110.19 84.27,110.19 80.87,106.79 80.87,104.96 79.07,103.16 79.07,102.24 77.82,101 77.82,99.56 74.01,95.75 74.01,94.76
  BOTTOM w0.305: v9(138.55,109.78) 138.36,109.98 RD171.2 RD166.2
  BOTTOM w0.356: v9(91.92,109.94) 92.04,109.82 RD216.2
  vias: v3(73.81,93.62) v3(73.81,93.3) v3(74.1,93.63) v3(74.1,93.31) v9(90.01,109.94) v9(91.41,110.45) v9(143.7,108.89) v16(91.44,107.05)
+0.6VSP:
  vias: v3(74.96,93.49) v3(75.28,93.49) v3(75.28,93.17) v3(75.6,93.49) v3(75.6,93.17) v6(77.06,96.22) v6(77.06,95.9) v6(77.31,96.41) v6(77.7,96.41) v6(78.08,96.41)
+0.95VSP: length 32.5
  TOP w0.254: PC1012.1 107.12,26.55 PR1004.1 109.37,26.55 110.13,27.31 110.13,29.81 109.46,30.49 107.79,30.49 104.54,33.74 v1(104.54,34.12) 104.54,36.9 105.31,37.66 105.31,39.87 106.02,40.58 106.02,44.75 105.22,45.55 99.79,45.55 99.35,45.1 PC1009.1
  vias: v9(100.11,43.39) v9(100.11,42.81) v9(100.11,42.23) v9(100.38,44.74) v9(100.38,44.18) v9(100.94,44.73) v9(100.96,44.17) v9(101.5,44.74) v9(101.52,44.16) v9(102.12,44.74) v9(102.13,44.17) v9(102.61,44.45)
+1.2V_DDR: length 415.6
  TOP w0.254: UD1.L9 v6(131.87,103.89) ; UD5.L1 v6(113.17,103.89) ; UD2.L1 v4(128.58,103.98) ; UD6.R1 v14(102.78,107.89) ; UD2.R1 v6(128.67,107.89) ; UD5.J2 UD5.J1 v7(113.28,102.69) ; v6(138.67,104.29) v7(139.07,103.89) ; v6(102.38,102.69) v6(101.58,102.69) ; UD5.R1 v6(113.17,107.89) ; UD1.R1 v6(139.07,107.89)
  TOP w0.508: v9(136.89,94.91) 137.54,94.27 CD369.1 ; CD310.1 132.71,94.42 v9(132.31,94.82) ; RD160.1 141.11,96.77 141.08,96.74 v7(140.75,96.74)
  IN1 w0.508: v4(91.49,107.37) 87.35,107.37 84.96,109.76 81.48,109.76 80.13,108.41 v4(80.13,108.26)
  GND2 w0.254: v6(128.27,98.69) v5(128.51,98.46) ; v5(96.54,100.06) v6(96.78,100.29) ; v5(102.62,83.4) 102.62,83.43 v7(102.87,83.67) ; v5(103.12,80.93) 103.03,80.84 v7(103.03,80.35) ; v7(97.18,83.42) 97.19,83.4 v5(97.59,83.4) ; v4(123.47,101.09) v5(123.79,100.77) ; v7(105.38,83.7) 105.38,83.62 105.16,83.4 v5(105.14,83.4) ; v7(113.28,102.69) 113.28,102.88 v5(113.06,103.09) ; v5(118.46,79.51) 118.46,79.53 118.56,79.63 118.56,80.05 v7(118.34,80.28) ; v6(128.27,96.29) 128.42,96.14 v5(128.42,95.83) ; v5(103.86,78.85) 103.83,78.87 103.3,78.87 v7(103.16,79.01) ; v5(102.7,102.98) 102.97,102.71 v7(102.97,102.61) ; v4(121.62,103.92) 121.62,103.74 v5(121.76,103.6) ; v7(117.07,80.16) 117.57,79.65 v5(117.57,79.51) ; v5(110.14,81.49) 110.02,81.62 v7(109.83,81.62) ; v4(128.27,97.89) v5(128.51,97.66) ; v6(128.27,102.69) v5(128.51,102.46) ; v4(95.98,108.29) 95.74,108.06 95.62,108.06 v5(95.6,108.08) ; v4(123.47,99.49) v5(123.71,99.26) ; v4(111.17,97.09) v5(111.57,96.69) ; v5(25.35,42.53) 25.37,42.5 v7(25.83,42.5) ; v5(117.71,83.4) v7(117.46,83.15) ; v7(112.57,79.14) 112.68,79.14 v5(113.05,79.51) ; v4(121.87,97.09) v5(122.11,96.86) ; v4(126.67,97.09) v5(126.91,96.86) ; v5(116.82,82.94) 116.82,83 116.96,83.14 v7(116.96,83.27) ; v4(127.47,99.49) v5(127.71,99.26) ; v6(95.98,96.29) v5(95.74,96.06) ; v4(106.37,108.29) v5(106.14,108.06) ; v7(115.29,80.28) v5(115.54,80.03) ; v6(127.47,100.29) v5(127.71,100.06) ; v6(121.87,96.29) v5(122.11,96.06) ; v7(94.67,106.1) v5(95.11,106.1) ; v7(102.14,79.2) 102.31,79.37 v5(102.31,79.53) ; v6(95.98,98.69) 95.84,98.69 95.63,98.48 95.63,98.46 ; v4(111.97,99.49) v5(111.57,99.09) ; v14(102.78,107.89) v5(103.01,107.66) ; v6(95.98,101.09) v5(95.74,100.86) ; v6(127.47,102.69) v5(127.71,102.46) ; v6(128.27,101.09) v5(128.51,100.86)
  GND2 w0.305: v5(95.6,108.08) 95.58,108.06 95.26,108.06 v7(95.21,108.1) ; v6(131.87,103.89) v5(132.13,104.15) ; v5(95.11,103.78) 95.27,103.94 v7(95.75,103.94) ; v5(109.85,99.75) v7(109.85,99.4) ; v5(128.5,96.81) 128.27,96.58 v6(128.27,96.29) ; v5(141.25,96.74) v7(140.75,96.74) ; v5(128.79,103.52) 128.58,103.73 v4(128.58,103.98) ; v4(107.97,99.49) 107.95,99.49 v5(107.56,99.88) 107.17,100.27 v6(107.17,100.29) ; v7(122.45,99.15) 122.51,99.22 v5(122.91,99.22) ; v5(130.59,102.22) 130.36,101.99 v7(130.3,101.99) ; v5(139.04,104.28) 139.07,104.25 v7(139.07,103.89) ; v7(130.27,97.26) 130.27,97.4 v5(130.02,97.66) ; v7(113.56,96.78) 113.51,96.78 113.47,96.82 v5(113.04,96.82) ; v5(103.43,101.63) v7(102.99,101.63) ; v5(101.34,100.06) v6(101.58,100.29) ; v7(95.4,102.67) 95.61,102.46 v5(95.65,102.46) ; v5(136.72,99.49) v7(136.32,99.49) ; v7(136.48,101.38) 136.7,101.16 v5(136.7,101.09) ; v5(100.54,99.26) v7(100.2,99.26) ; v5(120.49,83.17) v7(120.49,82.84) ; v6(113.17,103.89) 113.42,104.14 v5(113.42,104.2) ; v6(106.37,98.69) 106.07,98.39 v5(106.07,98.3) ; v5(126.44,101.33) v7(126.07,101.33) ; v5(105.36,98.81) 105.36,98.66 v7(105.15,98.46) ; v7(96.11,98.3) 95.78,98.3 v5(95.63,98.46) ; v5(122.11,98.46) v4(121.87,98.69) ; v7(96.98,99.14) 96.86,99.26 v5(96.54,99.26) ; v7(96.08,97.5) 95.9,97.5 v5(95.74,97.66) ; v5(102.64,100.78) 102.88,101.01 v7(102.88,101.09) ; v7(105.25,103.97) 105.38,103.84 v5(105.56,103.84) ; v6(121.87,102.69) v5(122.11,102.46) ; v5(113.59,107.91) 113.19,107.91 v6(113.17,107.89) ; v5(122.21,100.75) v4(121.87,101.09) ; v7(95.43,107.49) 95.66,107.26 v5(95.74,107.26) ; v5(132.81,99.75) 133.07,100.01 v6(133.07,100.29) v5(132.74,100.62) ; v5(97.94,97.21) v7(98.29,97.21) ; v5(138.12,102.44) 137.87,102.69 v6(137.87,102.69) ; v5(131.82,107.65) v7(131.44,108.03) ; v5(138.92,102.46) 138.69,102.69 v6(138.67,102.69) ; v5(123.82,97.09) v7(124.16,97.09) ; v5(138.81,97.45) 138.67,97.59 v7(138.67,97.89) ; v5(119.83,108.41) 120.19,108.41 v7(120.3,108.52) ; v5(102.44,95.82) 102.44,96.23 v6(102.38,96.29) 102.06,96.61 v5(102.06,96.77) ; v5(129.03,107.89) v6(128.67,107.89) ; v6(132.27,101.09) v5(131.92,101.09) ; v5(139.44,107.89) v6(139.07,107.89) ; v5(100.54,100.86) 100.54,100.87 v7(100.26,101.16) ; v5(103.5,96.53) 103.76,96.27 v7(103.76,96.2) ; v6(122.67,102.69) v5(122.91,102.46) ; v5(131.92,97.89) v7(131.92,98.23) ; v6(138.67,101.09) v5(139.04,101.09) ; v5(106.17,103.07) 105.9,102.8 v7(105.9,102.74) ; v6(133.07,102.69) v5(132.74,103.02) ; v4(112.16,95.51) v5(112.59,95.51) ; v5(126.34,99.47) v7(126,99.47) ; v6(137.87,100.29) v5(137.54,100.29) ; v6(138.67,98.69) v5(139.01,98.69) ; v5(122.91,100.06) v6(122.67,100.29)
  GND2 w0.381: v7(112.57,80.16) v5(113.32,80.16) ; v5(91.75,107.79) 91.75,107.64 v4(91.49,107.37)
  GND2 w0.508: v5(80.08,107.85) 80.13,107.91 v4(80.13,108.26)
  IN2 w0.254: v5(56.56,99.88) 56.56,100.02 53.49,103.09 48.43,103.09 42.23,96.9 40.03,96.9 39.48,97.44 38.96,97.44 38.43,97.97 38.43,98.85 37.65,99.62 36.32,99.62 34.22,101.72 32.77,101.72 32.1,101.06 32.1,98.38 29.69,95.97 26.81,95.97 26.26,95.42 23.51,95.42 22.1,94 22.1,89.82 19.86,87.58 19.86,84.99 20.78,84.07 21.86,84.07 22.77,83.15 22.77,81.69 20.91,79.83 20.91,72.04 19.04,70.17 19.04,64.45 16.57,61.97 15.98,61.97 14.97,60.96 14.97,59.85 16.71,58.11 21.61,58.11 23.68,56.04 23.68,54.9 24.12,54.46 24.12,50.89 24.6,50.41 24.6,43.27 v5(25.35,42.53)
  GND3 w0.254: v6(97.58,97.09) 97.83,97.09 v5(97.94,97.21) ; v6(96.78,100.29) v5(96.54,100.06) ; v14(116.38,82.51) v5(116.15,82.74) ; v5(95.65,102.46) 95.75,102.46 v6(95.98,102.69) ; v14(109.93,83.17) v5(110.17,83.4) ; v14(110.89,81.21) 111.13,81.44 v5(111.22,81.44) ; v9(103.22,103.76) 103.1,103.89 v6(102.78,103.89) ; v5(102.44,95.82) 102.44,95.91 102.38,95.97 v6(102.38,96.29) ; v6(95.98,97.89) v5(95.74,97.66) ; v14(118.21,79.26) v5(118.46,79.51) ; v14(116.59,83.17) v5(116.82,82.94) ; v14(109.06,79.26) v5(109.3,79.49) ; v14(97.36,83.17) v5(97.59,83.4) ; v6(95.98,98.69) 95.74,98.46 v5(95.63,98.46) ; v14(117.29,79.26) 117.54,79.51 v5(117.57,79.51) ; v14(112.72,79.26) 112.8,79.26 v5(113.05,79.51) ; v5(56.56,99.88) v8(56.92,99.88) ; v6(101.58,100.29) v5(101.34,100.06) ; v5(102.7,102.98) 102.42,102.69 v6(102.38,102.69) ; v6(96.78,99.49) v5(96.54,99.26) ; v14(109.93,83.82) v5(110.17,84.05) ; v14(113.64,79.91) 113.56,79.91 v5(113.32,80.16) ; v6(102.38,101.09) 102.64,100.83 v5(102.64,100.78) ; v6(107.17,100.29) 107.56,99.9 v5(107.56,99.88) 107.56,99.82 107.23,99.49 v6(107.17,99.49) ; v6(106.37,97.89) 106.37,98 v5(106.07,98.3) 106.37,98.61 v6(106.37,98.69) ; v14(102.39,83.17) v5(102.62,83.4) ; v5(112.25,101.91) 112.28,101.94 112.28,102.02 112.37,102.12 v14(112.37,102.29) ; v14(111.65,102.28) 111.71,102.23 111.71,101.93 v5(111.71,101.93) ; v14(102.78,107.89) v5(103.01,107.66) ; v14(98.25,83.17) v5(98.48,83.4) ; v14(105.79,83.17) v5(106.02,83.4) ; v14(98.09,79.26) v5(97.63,79.49) ; v14(97.18,79.26) v5(96.94,79.49) ; v6(100.78,99.49) v5(100.54,99.26) ; v6(102.38,97.09) v5(102.06,96.77) ; v6(95.98,107.49) v5(95.74,107.26) ; v14(110.82,83.82) v5(111.05,84.05) ; v14(104.9,83.17) v5(105.14,83.4) ; v6(95.98,101.09) v5(95.74,100.86) ; v6(100.78,101.09) v5(100.54,100.86) ; v6(101.58,102.69) v5(101.34,102.46) ; v6(95.98,96.29) v5(95.74,96.06) ; v14(117.48,83.17) v5(117.71,83.4) ; v14(101.5,83.17) v5(101.73,83.4)
  GND3 w0.305: v6(132.27,107.49) 131.98,107.49 v5(131.82,107.65) ; v6(123.47,97.09) v5(123.82,97.09) ; v5(113.59,107.91) 113.19,107.91 v6(113.17,107.89) ; v6(118.48,105.95) 118.46,105.95 118.46,105.94 118.54,105.86 v5(118.54,105.21) ; v6(132.27,101.09) v5(131.92,101.09) ; v6(113.17,103.89) 113.42,104.14 v5(113.42,104.2) ; v6(130.4,97.4) 130.27,97.4 v5(130.02,97.66) ; v6(103.12,96.53) v5(103.5,96.53) ; v6(119.99,83.17) v5(120.49,83.17) v6(120.88,83.17) ; v6(95.58,103.89) 95.22,103.89 v5(95.11,103.78) ; v6(105.61,108.06) 106.14,108.06 v5(106.14,108.06) ; v6(133.07,99.49) 133.07,99.5 v5(132.81,99.75) ; v6(121.47,103.89) v5(121.76,103.6) ; v6(128.27,96.29) 128.44,96.12 128.44,95.85 v5(128.42,95.83) ; v6(103.78,101.63) v5(103.43,101.63) ; v6(138.67,101.09) v5(139.04,101.09) ; v6(138.67,104.29) 138.67,104.28 v5(139.04,104.28) ; v5(106.17,103.07) 106.17,102.92 v6(105.94,102.69) ; v5(122.91,99.22) 122.91,99.24 122.67,99.48 v6(122.67,99.49) ; v5(138.92,102.46) 138.69,102.69 v6(138.67,102.69) ; v6(132.27,97.89) v5(131.92,97.89) ; v5(138.12,102.44) 137.87,102.69 v6(137.87,102.69) ; v6(112.95,95.51) v5(112.59,95.51) ; v5(126.34,99.47) 126.36,99.49 v6(126.67,99.49) ; v6(105.97,103.89) 105.58,103.89 105.56,103.87 v5(105.56,103.84) ; v6(112.77,97.09) 113.04,96.82 v5(113.04,96.82) ; v6(121.87,97.89) 121.87,98.22 v5(122.11,98.46) ; v6(137.07,99.49) v5(136.72,99.49) ; v5(105.36,98.81) 105.36,98.09 v6(105.38,98.06) ; v6(127.47,102.69) v5(127.71,102.46) ; v5(138.81,97.45) 138.67,97.3 v6(138.67,97.09) ; v6(128.27,102.69) v5(128.51,102.46) ; v6(128.27,98.69) v5(128.51,98.46) ; v5(119.83,108.41) 119.43,108.41 v6(119.33,108.31) ; v5(128.5,96.81) 128.5,96.83 128.27,97.05 v6(128.27,97.09) ; v6(127.47,100.29) v5(127.71,100.06) ; v6(122.67,100.29) v5(122.91,100.06) ; v6(137.07,101.09) v5(136.7,101.09) ; v6(110.21,99.75) v5(109.85,99.75) ; v6(113.7,110.37) v5(113.7,109.99) ; v6(138.67,98.69) v5(139.01,98.69) ; v6(131.87,103.89) v5(132.13,104.15) ; v6(121.87,102.69) v5(122.11,102.46) ; v6(133.87,97.09) v5(134.24,97.09) ; v6(128.67,107.89) v5(129.03,107.89) ; v6(122.67,102.69) v5(122.91,102.46) ; v6(137.87,100.29) v5(137.54,100.29) ; v6(128.27,101.09) v5(128.51,100.86) ; v5(132.74,100.62) 132.77,100.59 132.77,100.58 133.06,100.29 v6(133.07,100.29) ; v5(126.44,101.33) 126.67,101.09 v6(126.67,101.09) ; v5(128.79,103.52) 128.67,103.64 v6(128.67,103.89) ; v6(121.87,96.29) v5(122.11,96.06) ; v6(130.27,102.43) 130.37,102.43 v5(130.59,102.22) ; v6(139.07,107.89) v5(139.44,107.89) ; v6(133.07,102.69) v5(132.74,103.02)
  GND3 w0.508: v5(80.08,107.85) 80.31,108.08 v6(80.31,108.29)
  IN3 w0.254: v6(80.31,108.29) 80.28,108.29 78.38,106.39 78.38,103.87 78.08,103.57 78.08,102.71 76.41,101.05 69.76,101.05 67.91,99.2 58.44,99.2 57.76,99.88 v8(56.92,99.88)
  BOTTOM w0.254: v4(121.87,101.09) v6(122.67,100.29) v6(122.67,99.49) v4(121.87,98.69) v6(121.87,97.89) 122.27,97.49 ; v6(128.67,103.89) 128.67,103.09 v6(128.27,102.69) v6(127.47,102.69) ; v6(128.67,103.89) 128.76,103.89 129.38,103.27 129.38,102.84 129.79,102.43 v6(130.27,102.43) 130.96,102.43 132.27,101.12 v6(132.27,101.09) v6(133.07,100.29) 133.11,100.26 133.11,99.53 v6(133.07,99.49) UD1.D9 v6(132.27,97.89) ; v6(128.67,103.89) 128.28,104.29 UD2.L1 ; v6(97.58,97.09) 97.58,97.27 97.35,97.49 96.38,97.49 v6(95.98,97.89) ; v6(102.38,96.29) 102.89,96.29 v6(103.12,96.53) 102.56,97.09 v6(102.38,97.09) ; v6(95.98,97.89) v6(95.98,98.69) v6(96.78,99.49) 96.77,99.5 96.77,100.29 v6(96.78,100.29) v6(95.98,101.09) ; v6(95.98,97.89) 95.53,97.44 95.53,96.96 95.98,96.51 v6(95.98,96.29) ; v6(133.07,102.69) UD1.J9 ; v6(137.07,101.09) 137.07,101.29 137.47,101.69 137.47,102.1 137.87,102.5 v6(137.87,102.69) 137.89,102.71 138.65,102.71 v6(138.67,102.69) 138.83,102.69 139.07,102.94 139.07,103.89 v6(138.67,104.29) ; CD304.1 130.29,95.36 129.35,96.29 v6(128.27,96.29) v6(128.27,97.09) ; 122.27,97.49 122.27,96.66 121.9,96.29 v6(121.87,96.29) ; 122.27,97.49 123.07,97.49 v6(123.47,97.09) ; v6(113.17,103.89) 113.17,103.09 UD5.J1 ; v14(112.37,102.29) UD5.J1 ; UD5.J1 111.98,102.69 ; v9(136.89,94.91) 137.29,94.91 UD1.A1 v6(138.67,97.09) 138.97,97.09 139.18,97.3 139.18,98.18 v6(138.67,98.69) 138.67,98.69 138.27,99.09 138.27,99.89 v6(137.87,100.29) v6(138.67,101.09) ; v6(128.27,101.09) v6(127.47,100.29) ; v6(127.47,100.29) v6(126.67,101.09) ; v6(127.47,100.29) v6(126.67,99.49) 126.68,99.49 127.08,99.09 127.87,99.09 v6(128.27,98.69) 128.87,98.69 129.65,97.91 CD317.1 ; UD7.B3 107.57,96.69 106.83,96.69 106.43,96.29 UD5.A9 105.3,96.29 104.83,95.83 CD356.1 ; UD7.G7 111.57,101.49 111.57,102.2 v14(111.65,102.28) 111.66,102.31 111.98,102.62 111.98,102.69 ; UD4.T9 v6(128.67,107.89) ; v6(121.87,102.69) v6(122.67,102.69) ; UD5.D1 112.74,98.69 112.34,99.09 v5(111.57,99.09) UD7.E7 UD5.F2 UD5.G1 ; v6(80.31,108.29) 80.31,108.98 UC6.5 ; v6(112.77,97.09) UD5.A1 ; UD6.L9 v6(95.58,103.89) ; UD2.L9 v6(121.47,103.89) ; v14(98.25,83.17) v14(97.36,83.17) ; v14(102.39,83.17) v14(101.5,83.17) ; UD8.T9 v14(102.78,107.89) ; UD6.L1 v6(102.78,103.89) ; v14(104.9,83.17) v14(105.79,83.17) ; v6(133.87,97.09) 133.87,96.99 133.57,96.69 132.67,96.69 UD1.A9 132.27,94.86 v9(132.31,94.82) ; UD5.J8 UD5.J9 ; 111.98,102.69 UD5.J2 ; UD1.L9 v6(131.87,103.89) ; CD355.1 104.82,101.81 105.15,101.49 105.98,101.49 UD5.G9 v6(107.17,100.29) v6(107.17,99.49) v6(106.37,98.69) ; v6(106.37,98.69) 106.01,98.69 v6(105.38,98.06) ; v6(106.37,98.69) v6(106.37,97.89) ; v6(100.78,99.49) v6(101.58,100.29) ; v6(101.58,100.29) v6(100.78,101.09) 101.18,101.49 101.18,102.06 101.58,102.46 v6(101.58,102.69) v6(102.38,102.69) 102.88,102.19 103.22,102.19 ; v6(101.58,100.29) v6(102.38,101.09) 103.27,101.09 103.78,101.61 ; 103.22,102.19 v6(103.78,101.63) ; 103.22,102.19 v9(103.22,103.76) ; v14(109.93,83.82) 110.01,83.9 110.74,83.9 v14(110.82,83.82) ; UD3.T9 v6(139.07,107.89) ; UD7.T9 v6(113.17,107.89) ; v6(105.94,102.69) 105.92,102.71 105.92,103.84 v6(105.97,103.89) UD5.L9
  BOTTOM w0.305: v9(108.48,97.26) 108.31,97.09 UD7.B3 ; CD306.1 120.57,98.46 120.81,98.69 v4(121.87,98.69) ; CD356.1 104.2,95.83 v5(103.5,96.53) v6(103.12,96.53) ; v6(137.07,101.09) v6(137.87,100.29) v6(137.07,99.49) ; UD7.E7 110.47,99.49 v6(110.21,99.75) ; v6(138.67,101.09) 139.73,101.09 CD384.1 ; UD1.D9 131.49,98.69 130.7,97.91 CD317.1 130.27,97.66 130.4,97.53 v6(130.4,97.4) ; UD6.J8 v6(95.98,102.69) ; v6(118.48,105.95) 118.94,105.49 RD193.1 ; v9(110.65,101.25) 111.01,101.25 UD7.G7 UD5.F2 ; v6(112.95,95.51) 113.99,95.51 114.33,95.85 CD367.1 114.4,96.29 UD5.A1 ; UD1.A9 131.8,96.29 130.9,95.38 CD304.1 ; UD5.J9 v6(105.94,102.69) ; CD295.1 139.51,95.78 139,96.29 UD1.A1 ; CD308.1 CD299.1 v9(136.89,94.91) ; v4(121.87,101.09) 120.96,101.09 120.52,100.65 CD313.1 ; v6(105.61,108.06) 106.17,107.49 UD7.R1 ; CD334.1 113.01,98.46 UD5.D1 ; v6(119.33,108.31) 119.67,108.65 CD311.1 CD387.1 120.46,107.99 120.96,107.49 UD4.R1 ; UD5.G1 114.76,101.09 CD335.1 ; CD315.1 CD309.1 131.94,94.46 v9(132.31,94.82) ; v6(113.17,103.89) UD5.L1
  BOTTOM w0.356: RD202.1 114.89,102.66 114.4,102.17 113.3,102.17 UD5.J1
  BOTTOM w0.381: v6(105.38,98.06) 105.19,97.87 CD325.1 103.2,97.87 UD6.D1 ; 103.78,101.61 v6(103.78,101.63) 103.96,101.81 CD355.1 ; CD335.1 116.01,101.1 116.46,100.65 116.46,98.63 115.82,98 ; CD399.1 94.73,109.8 v9(94.74,109.78) CD360.1 ; CD346.1 v9(101.61,110.38)
  BOTTOM w0.508: CD334.1 115.36,98.46 115.82,98 115.82,96.83 CD367.1 ; CD306.1 119.77,98.48 CD313.1
  vias: v7(96.62,79.65) v7(96.62,79.33) v7(96.62,79.01) v7(96.94,79.01) v8(91.26,89.03) v8(91.89,89.03) v8(92.56,89.05) v9(91.51,102.96) v9(91.53,102.38) v9(91.53,101.75) v9(91.53,101.16) v9(91.78,103.48) v9(92.07,102.96) v9(92.08,102.38) v9(92.08,101.75) v9(92.08,101.16) v9(92.64,102.38) v9(92.64,101.75) v9(92.64,101.16) v9(93.23,102.38) v9(93.23,101.8) v16(106.47,81.93)
+1.2V_DDRP: length 29.9
  TOP w0.457: PR803.1 80.88,97.48 PC802.1 82.76,97.48 83,97.72 83.3,98.14 v1(84.2,99.04) v9(89.3,99.04)
  IN3 w1.016: 77.25,94.19 77.25,93.87 76.5,93.12 76.5,91.01 77.31,90.2 79.57,90.2 81.44,92.07 81.44,94.89 87.4,100.84
  vias: v3(76.93,94.89) v3(77.19,95.08) v9(88.38,101.11) v9(88.95,101.1)
+1.2V_VCCPLL_OC: length 76.2
  TOP w0.127: RH216.1 108.3,77.64 v16(107.91,77.25)
  TOP w0.508: CH232.1 v7(109.32,78.26) CH233.1 108.4,78.26 RH216.1 ; 129.54,79.23 v7(133.19,79.23) ; v7(109.01,84.7) 126.31,84.7 128.88,82.14 128.88,79.09 ; RZ44.2 116.67,94.94 CZ32.1 116.11,94.19 116.62,93.68 117.15,93.68 v7(117.34,93.49)
  GND2 w0.305: v5(117.83,93.73) 117.59,93.73 v7(117.34,93.49)
  GND2 w0.381: v7(109.32,78.26) v5(109.65,78.26)
  GND2 w0.508: v7(109.01,84.7) v5(109.45,84.7) ; v5(133.4,79.74) 133.4,79.43 v7(133.19,79.23) ; v5(127.71,78.58) 128.33,78.58 v7(128.61,78.3)
  IN2 w0.508: v5(109.65,78.26) 108.6,79.31 108.6,81.33 109.45,82.17 v5(109.45,84.7)
  GND3 w0.254: v6(127.9,78.25) 127.71,78.44 v5(127.71,78.58) 127.68,78.61 v6(127.35,78.61)
  GND3 w0.305: v6(109.06,78.61) 109.41,78.26 109.47,78.26 ; 109.47,78.26 v5(109.65,78.26) ; 109.47,78.26 v6(109.06,77.86)
  GND3 w0.381: v5(117.83,93.73) 117.53,93.44 v6(117.53,92.99)
  GND3 w0.508: v6(133.37,80.17) 133.4,80.14 v5(133.4,79.74)
  BOTTOM w0.508: v6(133.37,80.17) 132.94,80.6 132.94,82.35 133.88,83.29 133.88,90.71 133,91.59 125.15,91.59 124.02,92.72 117.81,92.72 v6(117.53,92.99)
+1.8V_3.3V_ALW_VTR3: length 15.3
  TOP w0.254: v9(34.54,9.2) 34.54,9.77 v1(34.45,9.86) 33.92,10.39 33.92,10.58 33.66,10.84 RE183.2
  TOP w0.305: UE3.N5 44,7.74 v9(44,7.22)
  IN3 w0.254: v9(34.54,9.2) 35.8,9.2 36.6,8.4 39.66,8.4 40.66,7.4 42.78,7.4 v9(44,6.18)
  BOTTOM w0.254: v9(34.54,9.2) 34.64,9.3 RE263.2 ; v9(44,7.22) CE55.1 v9(44,6.18)
+1.8VALW: length 409
  TOP w0.254: CH238.1 58.23,24.22 58.76,23.69 v2(58.76,22.95)
  TOP w0.381: CH238.1 58.23,24.68 58.71,25.16 59.66,25.16 60.08,25.58 v7(60.08,27.11) ; v9(28.61,23.93) 28.43,24.11 27.84,24.11 QC123.2 27.37,23.87 RC102.1 ; RC384.1 27.87,51.59 26.77,52.69 25.8,52.69 25.19,53.3 v16(21.12,53.3) 20.29,54.12 17.46,54.12 v7(16.56,53.22) ; v2(146.17,45.65) 146.53,46.01 PR1101.1 147.29,46.01 PR1133.1 ; v7(61.88,6.67) 61.89,6.67 62.41,6.67 68.32,12.58 68.32,16.76 69.28,17.72 v2(69.28,17.97)
  TOP w0.508: v2(68.68,91.86) 68.68,92.2 R115.1
  IN1 w0.381: v2(58.76,22.95) 58.8,22.99 63.43,22.99 68.46,17.97 v2(69.28,17.97) ; v4(141.45,48.7) 142.03,48.11 143,48.11 145.51,45.6 146.12,45.6 v2(146.17,45.65)
  IN1 w0.508: v2(68.68,91.86) 68.68,91.27 67.62,90.21 66.45,90.21 v4(63.73,87.48)
  GND2 w0.254: v5(64.26,79.41) 64.13,79.53 64.13,79.56 v7(64.03,79.66) ; v7(65.71,79.8) 65.71,79.97 v5(65.55,80.12) ; v7(64.66,79.76) 64.74,79.84 64.74,79.94 64.94,80.14 ; v7(65.64,79.42) 65.36,79.42 v5(65.3,79.36) ; v7(18.97,40.02) 19.21,40.02 v5(19.34,39.9) ; 64.94,80.14 65.17,79.91 v7(65.17,79.76) ; 64.94,80.14 v5(64.94,80.17)
  GND2 w0.381: v5(61.14,6.83) 61.29,6.67 v7(61.88,6.67) ; v4(141.45,48.7) v5(141.12,48.7) ; v5(60.29,27.58) 60.08,27.37 v7(60.08,27.11)
  GND2 w0.508: v4(63.73,87.48) 64,87.2 v5(64.06,87.2) ; v7(16.56,53.22) 16.38,53.04 v5(16.05,53.04)
  IN2 w0.381: v5(141.12,48.7) 141.12,45.79 138.53,43.2 138.53,37.99 135.65,35.11 135.65,31.62 133.42,29.39 123.84,29.39 123.57,29.66 114.97,29.66 114.8,29.49 109.5,29.49 107.36,31.63 106.66,31.63 106.09,32.2 100.25,32.2 99.33,31.28 96.38,31.28 95.76,30.66 85.82,30.66 85.27,30.1 69.32,30.1 66.79,27.58 v5(60.29,27.58) 59.74,28.13 59.74,39.87 57.58,42.02 57.58,46.77 55.81,48.54 55.81,51.76 51.98,55.59 51.98,60.8 53.45,62.27 54.64,62.27 56.93,64.56 56.93,67.99 60.4,71.46 61.01,71.46 63.37,73.82 63.37,79.81 63.73,80.17 v5(64.94,80.17)
  IN2 w0.508: v5(50.8,104.94) 50.52,104.67 37.13,104.67 35.9,105.89 32.13,105.89 29.74,103.51 29.74,102.61 29.01,101.87 28.18,101.87 26.55,100.24 26.55,98.65 24.98,97.08 22.82,97.08 20.42,94.68 20.42,90.5 18.2,88.28 18.2,79.28 19.25,78.23 19.25,72.73 16.26,69.74 13.2,69.74 11.63,68.16 11.63,61.45 12.6,60.48 12.6,55.47 12.26,55.14 12.26,53.88 13.1,53.04 16.05,53.04 v5(16.05,53.04) 16.05,49.85 16.82,49.08 16.82,44.82 17.93,43.72 17.93,41.92 18.26,41.59 18.79,41.59 19.34,41.04 v5(19.34,39.9) 19.34,37.12 19.71,36.75 20.84,36.75 21.33,36.25 21.33,32.52 28.61,25.24 v9(28.61,23.93) ; v5(51.71,103.7) 53.74,103.7 57.59,99.85 57.59,99.54 60,97.13 61.21,97.13 63.14,95.19 63.14,93.94 64.63,92.45 64.63,90.46 63.32,89.14 63.32,87.94 v5(64.06,87.2)
  GND3 w0.381: v5(61.14,6.83) v8(60.66,6.83)
  GND3 w0.508: v5(51.71,103.7) v8(51.3,103.7) ; v5(50.8,104.94) 50.83,104.91 v8(51.3,104.91)
  IN3 w0.381: v8(60.66,6.83) 59.07,6.83 54.1,11.8 v3(54.1,13.47)
  IN3 w0.508: v8(51.3,103.7) v8(51.3,104.91)
  BOTTOM w0.381: RE263.1 CE54.1 33.92,11.22 33.82,11.32 33.82,14.07 32.29,15.6 32.29,19.46 31.31,20.43 31.31,21.34 28.72,23.93 v9(28.61,23.93)
  vias: v9(64.86,85.4) v9(65.41,85.4)
+1.8VALWP: length 4.1
  BOTTOM w0.203: 64.35,79.34 65.39,80.39 PC1502.1 65.43,80.88 65.43,81.44 66.42,82.43 PR1504.1
  vias: v1(63.66,75.9) v9(64.82,76.49) v9(64.82,75.57) v9(65.17,76.03) v9(65.35,75.39)
+1V_MPHY: length 4.1
  GND2 w0.203: v17(39.79,46.46) 39.63,46.31 v5(39.47,46.31)
  GND2 w0.254: v7(39.93,46.77) 39.93,47.02 v5(39.54,47.4) ; v7(40.08,47.63) 39.49,48.22 v5(39.47,48.22) ; v5(39.53,45.86) v6(39.81,45.58) v7(39.81,45.46)
  GND3 w0.152: v6(39.81,47.91) 39.53,48.19 39.49,48.19 v5(39.47,48.22) ; v6(39.81,47.13) v5(39.54,47.4) ; v6(39.81,45.58) v5(39.53,45.86) ; v5(39.47,46.31) 39.76,46.31 v6(39.81,46.36)
  vias: v1(38.07,46.88) v5(39.47,46.85)
+1V_MPHY_MPHYPLL: length 14.8
  TOP w0.508: RH202.2 v1(41.31,50.25) 41.31,51.56 v2(44.09,54.34)
  IN1 w0.508: v4(44.85,57.94) 44.4,57.49 44.4,54.64 v2(44.09,54.34)
  GND2 w0.508: v4(44.85,57.94) v5(45.18,57.94)
  IN2 w0.508: v5(46.93,57.69) 46.36,58.25 45.49,58.25 v5(45.18,57.94)
  GND3 w0.508: v6(46.67,57.17) 46.67,57.43 v5(46.93,57.69)
+1V_PCH: length 30.3
  TOP w0.508: RH641.2 33.37,45.93 v7(32.94,46.36) 32.94,46.86 v1(32.57,47.23) 32.57,48.57 31.38,49.77 30.04,49.77 RH201.1 ; RH205.1 40.17,33.55 v9(39.72,34)
  GND2 w0.356: v7(32.94,46.36) 32.9,46.32 v5(32.9,46.03)
  IN2 w0.508: 36.45,42.68 36.45,38.72 36.04,38.31 34.95,38.31 33.83,37.19 33.83,36.61 36.44,34 v9(39.72,34)
  GND3 w0.152: v6(40.52,44.59) v5(40.28,44.82) ; v6(41.73,43.41) v5(41.5,43.64) ; v6(36.04,42.55) v5(35.81,42.79) ; v6(40.52,43.41) v5(40.28,43.64) ; v6(39.81,44.81) v5(39.57,45.04) ; v6(36.71,43.26) v5(36.47,43.49)
  GND3 w0.254: v6(32.9,45.69) v5(32.9,46.03) ; v6(39.03,43.26) v5(38.8,43.49)
  BOTTOM w0.381: RH100.1 43.35,32.59 43.05,32.29 41.37,32.29 39.72,33.94 v9(39.72,34)
+1V_PCH_AZPLL: length 3.9
  TOP w0.127: v1(31.91,45.68) 31.58,45.34 v7(31.58,44.59)
  TOP w0.381: LH1.2 31.58,44.03 v7(31.58,44.59)
  GND2 w0.381: v5(31.72,44.2) 31.58,44.34 v7(31.58,44.59)
  GND3 w0.254: v6(32.2,44.2) v5(31.72,44.2)
  BOTTOM w0.254: v7(31.58,44.59) 31.58,44.54 31.92,44.2 v6(32.2,44.2)
+1V_PCH_CLK5: length 0.9
  TOP w0.508: CH92.1 v9(42.9,35.26)
  vias: v1(42.01,34.75)
+1V_PCH_PRIM: length 5.4
  GND3 w0.254: v6(37.48,47.91) v5(37.25,48.14) ; v6(38.26,47.13) v5(38.02,47.37) ; v6(33.61,47.13) v5(33.38,47.37) ; v5(33.38,46.59) 33.75,46.59 v6(33.91,46.74) ; v6(33.62,45.59) v5(33.38,45.82) ; v6(37.48,48.68) v5(37.25,48.92) ; v6(35.93,46.36) v5(35.7,46.59) ; v6(35.93,47.91) v5(35.7,48.14) ; v6(33.61,44.81) v5(33.38,45.04) ; v6(36.71,47.91) v5(36.47,48.14) ; v6(36.71,48.68) v5(36.47,48.92) ; v6(37.48,46.36) v5(37.25,46.59) ; v6(36.71,46.36) v5(36.47,46.59) ; v6(38.26,46.36) v5(38.02,46.59)
  BOTTOM w0.127: UH4.AJ23 v6(33.91,46.74)
  vias: v1(36.48,43.83) v5(34.86,43.35) v5(35.23,43.57) v5(35.24,43.15) v7(34.8,43) v7(34.88,43.72) v7(35.58,43.74) v7(35.57,43.41) v7(35.89,47.77) v7(36.25,47.76) v7(36.62,47.78) v7(36.93,47.77)
+1V_PCH_USBPLL: length 1.3
  BOTTOM w0.254: v9(33.08,37.79) 33.49,37.79 UH4.AJ5 ; v9(32.25,37.9) 32.26,37.9 UH4.AL5
  vias: v1(34.52,36.98)
+1V_VCCDSW: length 4.1
  TOP w0.127: v1(26.01,49.42) 26.77,49.42 26.88,49.31 v6(27.87,49.31)
  TOP w0.356: RH201.2 28.65,50.18 27.87,49.4 v6(27.87,49.31)
  GND2 w0.254: v6(27.87,49.31) 27.87,49.31 v5(28.19,48.99)
  GND3 w0.254: v5(28.19,48.99) 27.87,49.31 v6(27.87,49.31)
+1VALW: length 11.6
  TOP w0.508: v2(111.27,29.35) 111.27,26.61 111.23,26.56
  IN1 w0.508: v4(105.63,29.93) 105.25,29.55 105.25,29.11 105.76,28.61 106.51,28.61 107.35,29.44 111.18,29.44 v2(111.27,29.35)
  GND2 w0.508: v4(105.63,29.93) 105.05,30.51 v5(104.68,30.51)
  vias: v9(14.96,34.07) v9(14.98,36.91) v9(14.98,36.34) v9(14.98,35.77) v9(14.98,35.2) v9(14.98,34.63) v9(15.55,36.91) v9(15.55,36.34) v9(15.55,35.77) v9(15.55,35.2) v9(15.55,34.63) v9(15.57,34.07) v9(80.34,25.46) v9(80.92,25.46) v9(81.51,25.46) v11(35.51,38.5) v11(35.5,38.05) v11(35.76,38.28) v16(41.12,39.9)
+1VALWP: length 20.8
  IN3 w0.254: v3(10.32,35.13) 12.06,35.13 13.38,36.45 13.38,37.25 15.27,39.14 15.27,47.55 14.83,48 13.84,48 13.61,48.23 13.61,49.69 v3(13.89,49.97)
  BOTTOM w0.203: PC706.1 PR702.1
  BOTTOM w0.254: v3(13.89,49.97) 14.3,50.37 PR702.1
  vias: v1(11.46,33.61)
+2.5V_MEM: length 70.2
  TOP w0.254: UD5.B1 113.18,96.68 113.18,95.81 112.59,95.23 112.59,94.54 112.82,94.32 112.82,93.96
  TOP w0.305: CD279.1 130.73,107.96 131.19,107.49 UD1.R9 ; UD5.R9 105.37,107.49 CD359.1 ; UD2.B1 128.39,97.09 128.93,96.55 128.93,95.05 129.32,94.66 v7(129.32,93.94) ; CD281.1 140.27,97.09 UD1.B1 ; CD283.1 119.21,107.22 CD382.1 ; CD283.1 CD282.1 118.73,108.08 CD284.1 117.61,108.07 v9(117.57,108.11) 117.53,108.07 CD391.1 CD366.1 ; CD283.1 121.6,107.22 UD2.R9
  TOP w0.356: UD6.R9 95.98,107.37 95.66,107.05 95.06,107.05 94.66,107.45 v9(94.66,108.08) ; v7(130.27,108.58) CD279.1 ; v7(103.86,93.94) 103.86,94.37 103.3,94.93 103.3,96.68 102.89,97.09 v4(102.38,97.09)
  TOP w0.381: v7(113.76,95) 113.76,94.72 113,93.96 112.82,93.96 CD314.1 ; v7(140.75,99.08) 140.83,99 CD379.1 140.8,98.33 CD281.1 ; CD333.1 CD394.1
  TOP w0.508: v7(104.38,109.35) CD359.1 ; CD333.1 93.94,109.42 CD331.1 94.61,108.03 v9(94.66,108.08)
  GND2 w0.254: v5(104.86,108.59) 104.86,108.87 v7(104.38,109.35) ; v4(102.38,97.09) 102.69,97.4 v5(102.69,97.41)
  GND2 w0.305: v7(129.32,93.94) v5(129.66,93.94) ; v7(140.75,99.08) v5(140.38,99.08) ; v7(130.27,108.58) 130.27,108.44 v5(129.92,108.08) ; v5(104.15,94.15) 103.93,93.94 v7(103.86,93.94) ; v7(113.76,95) v5(113.43,95)
  GND3 w0.254: v6(103.07,97.41) v5(102.69,97.41)
  GND3 w0.305: v6(138.5,108.82) 138.5,109.12 v5(138.45,109.18) ; v6(129.74,107.8) 129.74,107.91 v5(129.92,108.08) ; v5(95.65,96.78) 95.96,97.09 v6(95.98,97.09) ; v5(104.86,108.59) 104.86,107.94 v6(104.95,107.85)
  BOTTOM w0.254: UD7.B1 106.14,96.86 103.63,96.86 v6(103.07,97.41)
  BOTTOM w0.305: CD305.1 120.27,97.09 UD4.B1 ; UD8.R9 102.99,107.49 103.27,107.22 CD345.1 ; v6(138.5,108.82) 138.99,108.82 139.57,108.24 139.57,107.8 139.26,107.49 UD3.R9 ; UD3.B1 131.89,97.09 v9(131.75,97.24) 131.06,97.24 130.76,96.93 CD385.1 ; UD4.R9 128.55,107.22 129.16,107.22 v6(129.74,107.8) ; CD377.1 113.53,107.22 113.26,107.49 UD7.R9
  BOTTOM w0.381: CD327.1 v9(106.36,110.38)
  BOTTOM w0.508: v9(123.92,95.13) 121.43,95.13 120.93,95.64 120.93,96.07 120.38,96.61 CD305.1 ; CD256.1 117.76,107.92 v9(117.57,108.11) ; v6(104.95,107.85) 104.67,107.85 104.37,107.55 CD345.1 ; v9(116.8,108.96) CD347.1 116.04,108.97 CD370.1 CD377.1
  vias: v5(85.38,109.05) v5(85.89,109.06) v5(86.04,102.98) v5(86.04,102.52) v7(85.82,103.5) v7(86.24,103.5) v8(85.38,108.65) v8(85.72,108.65) v8(86.19,103.78) v8(86.19,103.46) v9(127.1,110.57) v16(85.55,103.04)
+3.3V_1.8V_ESPI: length 35.6
  TOP w0.381: RC386.2 25.18,51.34 24.5,52.03 v1(24.04,52.03) 23.62,51.61 20.72,51.61 20.34,51.22 RH134.2 20.34,48.67 20.74,48.28 21.33,48.28 21.55,48.06 21.99,48.06 22.37,47.68 22.37,47.12 21.99,46.74 20,46.74 19.66,46.4 19.66,45.5 19.41,45.26 v9(18.45,45.26)
  GND2 w0.305: v7(19.3,43.01) 19.3,43.22 v5(19.4,43.33) ; v7(21.18,42.94) v5(21.18,43.31)
  IN2 w0.508: v5(20.57,41.53) 21.18,42.14 v5(21.18,43.31) 21.18,43.97 v5(20.6,44.56) ; v5(20.6,44.56) 20.6,45.54 v5(21.01,45.95) ; v5(20.6,44.56) 20.06,44.56 19.45,43.95 ; v5(19.4,43.33) 19.45,43.38 19.45,43.95 ; v9(18.45,45.26) 18.45,44.95 19.45,43.95
  GND3 w0.305: v6(21.01,44.91) 21,44.91 20.65,44.56 v5(20.6,44.56) 21,44.15 v6(21.01,44.15) ; v6(21.01,45.61) v5(21.01,45.95) ; v5(20.57,41.53) 20.27,41.53 v6(20.24,41.56)
  IN3 w0.381: v3(23.04,46.36) 21.54,46.36 21.01,45.84 v6(21.01,45.61)
  BOTTOM w0.254: v6(21.01,45.61) RH594.2
  BOTTOM w0.305: RH625.2 20.32,41.48 v6(20.24,41.56) ; v9(18.45,45.26) 17.46,45.26 RH129.2
  BOTTOM w0.356: RH593.2 v9(18.45,45.26)
+3.3V_1.8V_PGPPA: length 3
  TOP w0.127: RC386.1 26.2,50.43 v1(25.88,50.76)
  TOP w0.381: RC386.1 v6(27.87,50.43)
  GND2 w0.107: v5(27.58,50.73) v6(27.87,50.43)
  GND3 w0.127: v6(27.87,50.43) v5(27.58,50.73)
+3.3V_EC5105: length 72.4
  TOP w0.254: RE227.2 RE228.2 37.4,20.9 37.61,21.11 38.12,21.11 38.42,20.82 38.42,20.47 38.76,20.13 38.76,20.12 39.24,19.64 v2(40.03,19.64) ; RE276.2 RE277.2 43.66,20.12 RE107.2 v2(43.02,20.19) ; RE270.2 RE269.2 53.73,4.47 53.72,4.46 53.72,4.08 53.82,3.98 53.82,3.55 53.69,3.42 52.88,3.42 52.61,3.68 52.61,4.04 RE127.2 ; RE270.2 RE119.2 ; RE270.2 53.79,5.29 54.39,4.68 55.12,4.68 55.6,5.16 55.6,7.32 55.29,7.63 RE278.2 55.97,8.34 v1(56.35,8.72) 56.35,9.23 56.87,9.75 v2(56.87,9.92) ; UE3.G8 v9(46.75,12.99) ; v9(47.56,8.21) 47.53,8.21 UE3.M9 ; v2(40.55,4.11) RE112.2 ; RE124.2 RE108.2 RE130.2 RE266.2 RE267.2 v7(53.35,13.54) ; UE3.K2 v9(41.15,9.79)
  TOP w0.381: 36.8,15.2 RE133.2 ; 36.8,15.2 36.55,15.45 36.55,17.28 36.7,17.43 36.7,17.84 36.67,17.86 36.67,19.74 36.83,19.89 RE227.2 ; 36.8,15.2 36.29,14.69 36.29,14.13 36.46,13.96 RE109.2 RE265.2 38.35,13.09 v9(39.52,11.92) 39.65,11.79 UE3.H1
  IN1 w0.254: v2(40.55,4.11) 40.78,4.11 41.12,3.77 43,3.77 43.85,4.62 v9(44.33,4.62) ; v2(43.02,20.19) 42.55,20.66 41.04,20.66 v2(40.03,19.64)
  IN1 w0.508: v7(53.35,13.54) 53.35,12.54 54.13,11.76 54.13,11.13 55,10.25 55.97,10.25 56.3,9.92 v2(56.87,9.92) 57.13,9.92 57.87,10.67 59.08,10.67 v2(60.21,9.54)
  GND2 w0.254: v5(45.16,16.01) 45.16,16.2 v7(45.55,16.59)
  GND2 w0.381: v7(53.35,13.54) 52.79,12.99 v5(52.78,12.99)
  GND3 w0.254: v6(45.46,15.86) 45.31,15.86 v5(45.16,16.01)
  GND3 w0.381: v5(52.78,12.99) 52.59,12.99 v6(52.2,12.6)
  BOTTOM w0.305: CE43.1 v9(47.56,8.21)
  BOTTOM w0.508: v6(52.2,12.6) 52,12.4 52,10.19 50.02,8.21 v9(47.56,8.21) ; v9(44.33,4.62) 44.98,5.26 44.98,6.1 45.25,6.37 45.25,7.13 45.56,7.45 45.56,8.72
+3.3V_EC_PLL: length 4.7
  TOP w0.254: v9(39.96,13.8) 40.37,13.39 UE3.F1
  BOTTOM w0.127: v1(40.57,14.23) 40.4,14.23 v9(39.96,13.8)
  BOTTOM w0.381: RE113.1 39.52,13.8 v9(39.96,13.8) 40.01,13.8 40.48,13.33 CE48.1 41.03,13.33 41.44,13.73 CE47.1
+3.3VDX_SSD: length 3.5
  TOP w0.127: v9(91.41,4.84) v16(91.41,5.92) ; v9(91.41,4.84) v16(90.08,4.84) ; v9(91.41,4.84) v16(91.41,3.77)
+3V_LDO: length 314.6
  TOP w0.254: v2(48.27,104.44) 48.12,104.29 PU2303.5 ; v2(48.75,107.17) 48.55,106.97 PU102.5
  TOP w0.356: v2(29.63,70.12) 29.63,72.54 29.37,72.79 PR116.1 28.98,72.9 28.98,73.08 28.81,73.25 27.11,73.25 27.06,73.3 v2(27.02,73.3)
  TOP w0.508: v2(27.09,97.06) 27.09,96.2 PC128.1 ; v7(46.34,66.46) 46.27,66.39 46.27,62.84 47.32,61.79 v16(49.5,61.79) 49.55,61.79 50.02,62.26 PR383.2
  IN1 w0.381: v4(102.59,5.75) 99.06,5.75 98.25,4.94 95.54,4.94 93.95,3.35 92.01,3.35 91.93,3.44 89.39,3.44 89.29,3.53 87.06,3.53 86.96,3.43 84.89,3.43 84.71,3.25 83.81,3.25 83.61,3.45 82.3,3.45 81.63,2.77 73.87,2.77 73.61,3.03 70.42,3.03 70.25,3.21 60.42,3.21 59.75,3.88 56.49,3.88 55.83,3.22 54.34,3.22 53.5,4.06 51.01,4.06 50.83,4.23 50.26,4.23 49.88,3.85 49.88,2.24 49,1.36 36.07,1.36 35.22,2.2 v2(31.51,2.2)
  IN1 w0.508: 27.04,74.06 27.04,73.32 v2(27.02,73.3) ; 27.04,74.06 27.04,77.29 27.19,77.44 27.2,77.44 27.53,77.77 30.02,77.77 30.43,77.36 30.43,75.87 31.72,74.59 v7(32.2,74.59) ; 27.04,74.06 25.56,74.06 24.86,73.36 24.86,72.86 22.94,70.94 18.69,70.94 18.37,71.25 12.37,71.25 12.14,71.48 10.05,71.48 v9(10.03,71.51) ; v2(33.42,63.21) 33.26,63.37 29.64,63.37 28.27,64.75 28.27,67.95 27.73,68.48 27.73,69.55 28.31,70.12 v2(29.63,70.12) ; v4(25.31,91.2) 25.56,91.46 26.84,91.46 30.89,95.51 v2(31.69,95.51) ; v4(44.37,89.62) 44.37,91.03 43.2,92.21 43.2,94.31 v4(43.3,94.42)
  GND2 w0.381: v7(32.2,74.59) 31.83,74.59 v5(31.78,74.54)
  GND2 w0.508: v4(44.37,89.62) v5(44.75,89.62) ; v4(102.59,5.75) 102.72,5.62 v5(102.91,5.62) ; v5(43.3,94.82) v4(43.3,94.42) ; v4(25.31,91.2) 25.18,91.2 v5(24.88,91.51) ; v7(46.34,66.46) 46.3,66.51 v5(46.3,66.93)
  IN2 w0.508: v5(43.3,94.82) 42.05,96.08 39.81,96.08 39.21,96.68 38.5,96.68 v9(37.57,97.61) ; v5(44.75,89.62) 47.66,89.62 49.32,87.95 49.32,83.93 48.77,83.37 48.77,75.14 50.14,73.77 50.14,70.06 49.35,69.27 49.35,68.64 47.65,66.93 v5(46.3,66.93)
  GND3 w0.381: v5(31.78,74.54) v8(31.78,75.02)
  GND3 w0.508: v8(103.23,5.94) v5(102.91,5.62) ; v5(24.88,91.51) 24.88,90.85 v8(24.7,90.67)
  IN3 w0.508: v8(31.78,75.02) 30.64,75.02 29.23,76.43 29.23,83.57 28.89,83.91 27.54,83.91 24.7,86.76 v8(24.7,90.67) ; v9(29.99,2.6) 29.99,2.23 29.47,1.71 17.08,1.71 12.79,6 5.84,6 2.1,9.73 2.1,19.58 3.25,20.72 3.25,26.54 4.57,27.86 4.57,49.23 4.09,49.71 4.09,51.57 4.45,51.93 4.45,53.32 2.08,55.68 2.08,61.62 4.41,63.94 5.48,63.94 8.15,66.61 8.15,69.63 v9(10.03,71.51) ; v8(103.23,5.94) 104.1,5.94 v3(105.06,6.9)
  vias: v2(37.07,101.34) v2(38.11,96.88) v7(30.32,103.99) v7(30.76,103.84) v7(32.14,101.49) v7(34.13,103) v7(35.91,103.92)
