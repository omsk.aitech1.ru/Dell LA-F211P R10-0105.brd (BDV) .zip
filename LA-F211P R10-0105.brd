# Allegro board LA-F211P R10-0105.brd (continued)
## Library data of the parts (continued)
PR113 PR114 PR116 PR141 PR142 PR145 PR147 PR170 PR171 PR173 PR175 PR178 PR179 PR254 PR257 PR263 PR265 PR268 PR270 PR272 PR274 PR509 PR541 PR547 PR612 PR618 PR808 PR902 PR1809 PR2318 PR2321 PR2329 PR2332 PR2333 R1 R277 R530-R532 R1194 R5822 R5829 R5831 R5833 R5835 R5837 R5843 R5845 R5847 R5849 R5853 R5855 R5861 R5862 R5865 R5867-R5870 RC10 RC102 RC395 RC396 RD166-RD193 RD198-RD225 RD238-RD253 RE48 RE265-RE270 RE276-RE279 RE288-RE291 RE293 RE294 RE297 RE299 RE300 RE426 RE427 RE431 RE435 RE437-RE439 RH486 RH488 RH491-RH506 RH517 RH521-RH528 RH530-RH539 RH553 RH554 RH568-RH570 RH572 RH576 RH587 RH588 RH591-RH594 RH596 RH602 RH607 RH608 RH611-RH614 RH617-RH620 RH625-RH628 RH635-RH640 RH643-RH645 RH649-RH652 RH654-RH658 RH660 RP83-RP86 RP90-RP93 RP108 RP109 RP112 RP114 RP115 RP117 RP120-RP127 RP130 RP131 RP143 RP144 RR43 RR44 RT226 RT238 RT239 RT427 RT429-RT431 RV810 RV811 RW2 RZ57 RZ62 = R_0201
PR120 = R0402_0OHM: room: CCG5_PATH_12
PR122 PR125 PR247 = R0201_0OHM: room: CCG5_PATH_12
PR136 = R0402_0OHM: room: CCG5_5V_PATH_12
PR152 PR156 PR202 PR203 = R_0201: room: AC_DISCONNECT
PR153 PR158 PR159 PR161-PR165 PR186 PR187 PR192 PR193 PR195 PR196 PR209 PR212 = R0402_0OHM: room: AC_DISCONNECT
PR157 PR160 = R0201_0OHM: room: AC_DISCONNECT
PR166 PR183 PR185 PR233 PR234 = R_0402: room: CCG5_LPS_12
PR167 PR169 PR182 PR184 = R_0201: room: CCG5_LPS_12
PR168 = R0402_0OHM: room: CCG5_LPS_12
PR188 PR189 PR237-PR242 = R0201_0OHM: room: CCG5_LPS_12
PR216-PR218 = R_0201: room: BATT_CONNECTOR
PR219 PR230 = R_0402: room: BATT_CONNECTOR
PR249 PR255 PR256 PR267 PR269 PR271 PR273 PR512 PR626 PR627 PR629 PR2309 PR2315 PR2316 PR2320 PR2331 PR2334 R1323 R5827 R5828 R5832 R5834 R5841 R5852 R5854 R5863 R5864 RE180 RE274 RE275 RE295 RE296 RE429 RE430 RE433 RE434 RH550 RH561 RH562 RH567 RH600 RH601 RH609 RH610 RH633 RH646 RH647 RH653 RH659 RP78-RP81 RP96-RP98 RP102-RP105 RP128 RP129 RP132 RP133 RT233-RT237 RT242 RT415 RT418-RT426 RZ58 = R0201_0OHM
PR354 = R0805_0OHM
PR367 PR375 PR378 = R_0402: room: 3V_LDO
PR383 = R0805_0OHM: room: 3V_LDO
PR500 = R_1206_4P-D: room: PWR_CHARGER
PR501 PR507 PR524 PR529 PR530 PR538 = R_0402: room: PWR_CHARGER
PR502 PR503 PR505 = R_0603: room: PWR_CHARGER
PR504 PR521 PR522 PR539 = R_0201: room: PWR_CHARGER
PR506 PR508 PR520 = R_1206: room: PWR_CHARGER
PR511 = R_1206_4P-D
PR519 PR550 PR551 PR1301 PR1303 PR1305 R5848 R5850 = R_1206
PR525 PR526 PR536 PR537 = R0201_0OHM: room: PWR_CHARGER
PR527 = R0402_0OHM: room: PWR_CHARGER
PR600 PR604 = R0402_0OHM: room: PWR_3V1
PR601 = R_0603: room: PWR_3V1
PR602 = R_0805: room: PWR_3V1
PR605 = R_0402: room: PWR_3V1
PR606 = R_0201: room: PWR_3V1
PR607 = R_0402: room: PWR_5V1
PR608 = R_0603: room: PWR_5V1
PR609 = R_0805: room: PWR_5V1
PR615 PR801 PR2202 PR2205 R5859 = R_0805
PR621 = R_0805: room: PWR_3V2
PR622 = R_0402: room: PWR_3V2
PR623 = R0402_0OHM: room: PWR_3V2
PR624 = R0201_0OHM: room: PWR_3V2
PR625 = R_0201: room: PWR_3V2
PR700 = R_0805: room: +1VALWP
PR701-PR703 PR705-PR707 = R_0402: room: +1VALWP
PR704 = R_0201: room: +1VALWP
PR810 PR811 = R0402_0OHM: room: PWR_1.2VDDR
PR812 = R_0201: room: PWR_1.2VDDR
PR1000 = R_0805: room: VCCIO
PR1001 PR1003 PR1004 PR1007-PR1009 = R_0402: room: VCCIO
PR1006 = R0402_0OHM: room: VCCIO
PR1100-PR1108 PR1125 PR1126 PR1130 PR1131 PR1133-PR1135 PR1139 = R_0402: room: ISL95859
PR1109 PR1124 PR1127-PR1129 PR1132 PR1136-PR1138 = R0402_0OHM: room: ISL95859
PR1110 PR1141 PR1142 = R_0402: room: PWR_CPU_CONTROLLER
PR1113 PR1114 PR2201 PR2300 R208 R2743 RE436 RH543 RH545 RH546 RH641 RP99 RV808 = R0603_0OHM
PR1140 = R0402_0OHM: room: PWR_CPU_CONTROLLER
PR1200 PR1202 PR1204 = R0402_0OHM: room: PWR_CPU_VCCCORE
PR1201 PR1203 PR1205 = R_1206: room: PWR_CPU_VCCCORE
PR1500 = R0402_0OHM: room: PWR_1.8VALW
PR1502 = R_0201: room: PWR_1.8VALW
PR1503 = R_0603: room: PWR_1.8VALW
PR1504 PR1505 = R_0402: room: PWR_1.8VALW
PR1810 PR1813 PR1815 PR1816 PR1820 PR1823 PR1840 PR1842 PR1856 PR1870 PR1877 PR1878 = R0402_0OHM: room: PWM_GPU_CONTROLLER
PR1812 PR1814 PR1817-PR1819 PR1821 PR1822 PR1824-PR1829 PR1843 PR1844 PR1846 PR1848 PR1850 PR1851 PR1853-PR1855 PR1857-PR1859 PR1871 PR1872 PR1875 PR1876 PR1879 = R_0402: room: PWM_GPU_CONTROLLER
PR1841 PR1845 PR1847 PR1849 = R_0603: room: PWM_GPU_CONTROLLER
PR1900 PR1901 PR1903 PR1904 PR2000 PR2001 = R_0603: room: PWM_VDDC
PR1902 PR1905 PR2002 = R_0805: room: PWM_VDDC
PT100 PT101 = TPC12: room: CCG5_PATH_12
PT500 = TPC12: room: PWR_CHARGER
PT501 PT502 T748 T749 T766 T778-T781 T801 T802 T810 T812-T829 T831-T834 TP_CFG1-TP_CFG3 TP_CFG8-TP_CFG19 TP_ITP_PMODE TP_JTAG_TCK TP_JTAG_TDI TP_JTAG_TMS TP_PROC_PRDYN TP_PROC_TRSTN XDP_SPI_IO2 = TPC12
PU78 PU503 UZ22 = MC74VHC1G08DFT2G_SC70-5
PU100 PU101 = AS331KTR-G1_SOT23-5
PU102 PU2301-PU2303 = 74AUP1G04GW_TSSOP5
PU300 = RT9069-33GB_SOT23-5: room: 3V_LDO
PU501 = ISL88738HRTZ-T_TQFN32_4X4-S: room: PWR_CHARGER
PU600 PU603 = NB680GD-Z_QFN12_2X3
PU601 PU602 = NB679AGD-Z_QFN12_2X3
PU700 = SY8286RAC_QFN20_3X3: room: +1VALWP
PU800 = NB685GQ-Z_QFN16_3X3: room: PWR_1.2VDDR
PU900 = SYV659LQWC_QFN7_1P5X1P5: room: PWM_+1.05_VMM
PU1000 PU2304 = SY8286RAC_QFN20_3X3
PU1100 = MP2949AGQKT-0022-Z_TQFN48_6X6-S
PU1200-PU1202 = MP86901-CGLT-Z_TQFN21_3X4: room: ETY-ROOM
PU1300 PU1301 = MP86901-CGLT-Z_TQFN21_3X4: room: PWR_CPU_VCCGT
PU1302 = MP86901-BGLT-Z_TQFN21_3X4: room: PWR_CPU_VCCSA
PU1500 = SYV659LQWC_QFN7_1P5X1P5
PU1800 = NCP81022MNTXG_QFN52_6X6-S: room: PWM_GPU_CONTROLLER
PU1900 PU1901 PU2000 = NCP302045MNTXG_PQFN33_5X5
PU2200 = NCP81151MNTBG_DFN8_2X2: room: PWM_VDD12
PU2201 = NCP302045MNTXG_PQFN33_5X5: room: PWM_VDDC
PU2300 = RT9059GQW_WDFN10_3X3
PU4255 = SY8868QMC_QFN10_2X2
Q3-Q6 QC123-QC126 QP1-QP4 QV10 = L2N7002WT1G_SC-70-3
QC1 QC2 QC6 QC7 QE27 = DMN65D8LDW-7_SOT363-6
QC3 QE28 = MMBT3904WT1G_SC70-3
QE12 QE14 QE16 QE20-QE23 = MMBT3904WT1G_SC70-3: room: KBC
QE13 = LNTA7002NT1G_SC-89-3: room: KBC
QE25 = DMN66D0LDW-7_SOT363-6: room: +1.8VA
QE30-QE32 QH1 QH2 QV11 = DMN66D0LDW-7_SOT363-6
QR1 = L2N7002WT1G_SC-70-3: room: CARD READER
QRTC = LP2301ALT1G_SOT23-3
QRTC1 = DMN65D8LW-7_SOT323-3
QV8 = SI3457CDV-T1-GE3_TSOP6: room: EDP+TS
QV9 = L2N7002WT1G_SC-70-3: room: EDP+TS
QV12 QZ10 = FDMC6675BZ_MLP8-5
QV13 QZ11 = 2N7002KTB_SOT523-3
QZ9 = DMG2301U-7_SOT23-3: room: CCD+SENSOR
R93 R95 = R0603_0OHM: room: OTHER
R115 R116 = R_0402: room: +1.8VA
R130 = R_0201: room: NB LID
R164 = R_0402: room: DP_MUX1
R165 R166 RE264 RT10 RT11 RT13 RT14 RT19 RT20 RT25-RT27 RT29-RT47 RT80-RT84 RT100 = R_0201: room: ETY-ROOM
R222 = R0402_0OHM: room: FP
R370 R373 R1090 R1206 R1207 = R_0402: room: 2ND ACCELEROMETER
R1314 = R_0603: room: CCD+SENSOR
R1319 = R0603_0OHM: room: +VPP_2.5V
R1320 = R_0201: room: +VPP_2.5V
R1321 R1322 = R_0402: room: +VPP_2.5V
RC9 RC21 RC44 RH36 RH42 RH43 RH45 RH50 RH51 RH54 RH56-RH58 RH60 RH61 RH64 RH218-RH227 = R_0201: room: CPU
RC11 RC13 RC16 RC35 = R_0201: room: CMC
RC183 RC184 RV783-RV788 = R_0402: room: EDP+TS
RC384 RC386 = R0402_0OHM: room: AUDIO_CODEC
RD17-RD20 RD59 = R_0402: room: NGFF SSD
RD58 = R0402_0OHM: room: NGFF SSD
RE1-RE3 = R_0402: room: FAN1
RE6-RE8 = R_0402: room: FAN2
RE10 RE14 RE17-RE19 RE21 RE23 RE27 RE29 RE31 = R_0402: room: TPM
RE11 = R_0603: room: TPM
RE12 RE22 = R0402_0OHM: room: TPM
RE15 = R0603_0OHM: room: TPM
RE105 RE107-RE109 RE111 RE112 RE119 RE124 RE127 RE130 RE133 RE137 RE142 RE155-RE162 RE164 RE183 RE184 RE201-RE206 RE215 RE219 RE227 RE228 RE244 RE247 = R_0201: room: KBC
RE106 RE248 RE263 = R0402_0OHM: room: KBC
RE113 RE115 RE125 RE126 RE147 RE153 RE154 RE172 RE193 RE194 RE199 RE251 = R_0402: room: KBC
RE132 RE177 RE178 RE185 RE209 RE222 RE245 RE252 = R0201_0OHM: room: KBC
RE150 = R_0201: room: TABLET LID
RE187 RT24 RT72 = R_0201: room: AUDIO_CODEC
RE200 = R0201_0OHM: room: TOUCH
RE259 RE260 = R0201_0OHM: room: EC5085
RH35 RH37 RH38 RH44 RH46-RH49 RH52 RH59 RH62 RH63 RH74 RH77 RH78 RH81 RH216 RH466 RH467 RZ26 RZ28 RZ29 RZ36 RZ39-RZ42 = R_0402: room: CPU
RH55 = R0201_0OHM: room: CPU
RH75 RH76 RH79 RH80 RH228 RH465 RZ23 RZ30 RZ37 = R0402_0OHM: room: CPU
RH90-RH93 RH96-RH98 RH100-RH104 RH106 RH107 RH112 RH113 RH124 RH126 RH128 RH130 RH132 RH133 RH136 RH139-RH142 RH148 RH151-RH154 RH159-RH163 RH166 RH167 RH174-RH182 RH189-RH199 RH214 RH215 = R_0201: room: PCH
RH94 RH99 RH105 RH109-RH111 RH114-RH116 RH118 RH123 RH125 RH129 RH131 RH134 RH135 RH155 RH156 RH158 RH168 RH169 RH201 = R_0402: room: PCH
RH95 RH137 RH138 RH164 RH165 RH212 RH213 RH468 RH469 = R0201_0OHM: room: PCH
RH117 RH157 = R0402_0OHM: room: PCH
RH122 RH202-RH205 = R0603_0OHM: room: PCH
RL1-RL5 = R_0402: room: BATTERY LED
RP1-RP6 = RP_0804_8P4R: room: PCH
RP29 RP32 RP66-RP69 = R_0402: room: TBT_CCG5
RP30 RP31 RP71 RP73 = R_0201: room: TBT_CCG5
RP88 = RP_0804_8P4R
RPE7 = RP_0804_8P4R: room: KBC
RR1-RR7 = R0402_0OHM: room: CARD READER
RR8-RR10 = R_0402: room: CARD READER
RR15-RR17 RR40 = R0201_0OHM: room: EDP+TS
RR20 RR21 RR34 RR35 = R0201_0OHM: room: SENSOR
RR38 = R_0201: room: EDP+TS
RT3-RT7 RT9 = R_0402: room: TBT
RT16 = R0201_0OHM: room: TBT
RT17 RT69 RT91-RT94 = R_0201: room: AR
RT18 RT21 = R_0201: room: GRAPHICS
RT23 = R_0402: room: GRAPHICS
RT28 = R_0402: room: ETY-ROOM
RT49 RT50 = R0603_0OHM: room: ETY-ROOM
RT71 = R0201_0OHM: room: ETY-ROOM
RV789-RV798 RV800 = R0402_0OHM: room: EDP+TS
RZ7 = R0603_0OHM: room: 3V_5V_DC_DC
RZ8 = R_0805: room: 3V_5V_DC_DC
RZ10 = R0603_0OHM: room: PCH_DC_DC
RZ11 RZ14 = R0603_0OHM: room: CAMERA_CR_DC_DC
RZ13 = R_0402: room: CAMERA_CR_DC_DC
RZ16 = R0402_0OHM: room: HDD_DC_DC
RZ17 RZ20 = R_0402: room: HDD_DC_DC
RZ18 = R_0805: room: HDD_DC_DC
RZ19 = R0603_0OHM: room: EDP_DC_DC
RZ21 = R_0402: room: EDP_DC_DC
RZ22 RZ38 RZ44 = R0603_0OHM: room: CPU_DC_DC
RZ43 = R0402_0OHM: room: CPU_DC_DC
RZ45 = R_0402: room: CPU_DC_DC
RZ49 = R0402_0OHM: room: CCD+SENSOR
RZ50 = R_0402: room: CCD+SENSOR
SW1 = SW_SSAL120100_3P: room: PCH
SW3 = SW_NTC311-EA1T-A160T_4P: room: BATTERY LED
SW4 = SW_SKRBAAE010_4P
SW5 = SW_MSS3-Q-T-R_3P
T49 T52-T55 T59-T62 T67 = TPC12: room: PCH
T79 = TPC12: room: KBC
T117-T119 T551 T556 T724-T727 = TPC12: room: CPU
U14 = TPS22966DPUR_SON14_2X3: room: +3VS_AUDIO
U15 = G9661-25ADJRE1U_TDFN10_3X3: room: ETY-ROOM
U18 = LNG2DMTR_LGA12_2X2: room: 2ND ACCELEROMETER
U20 = APX8131AI-TRG_SOT23-3: room: NB LID
U736 UZ23 UZ24 = APE8937GN2_DFN8_2X2
U4253 U4254 = TS5A3159ADCKR_SC70-6
UC1 = KABYLAKE-G_BGA_2270P-T: room: CPU
UC4 UC5 = 74AUP1G02GW_TSSOP5
UC6 = 74AUP1G07GW_TSSOP5: room: CPU
UC8 = W25Q80DVZPIG_WSON8
UC9 UE7 = 74AUP1G07GW_TSSOP5
UC10 = 74AUP1G86GW_TSSOP5
UD1-UD8 = K4A8G165WB-BCPB_FBGA_96P
UE2 = NPCT650JAAYX_QFN32_5X5-S: room: TPM
UE3 = MEC5105_WFBGA_169P: room: KBC
UE12 = APX8131AI-TRG_SOT23-3: room: TABLET LID
UE13 = 74AUP1G07GW_TSSOP5: room: KBC
UH4 = SKY-S-PCH_BGA_837P-T: room: PCH
UH5 UH7 = MC74VHC1G08DFT2G_SC70-5: room: PCH
UH6 = W25Q256FVEIG_WSON8: room: PCH
UP1 UP2 = TPS61099YFFR_DSBGA_6P
UPD1 = CYPD5256-96BZXI_BGA_96P: room: TBT_CCG5
UR1 = RTS5242-GR_QFN32_4X4-S: room: CARD READER
US5 = DPS1113FIA-13_QFN18_4X4: room: TBT_PD
US6 = DPS1113FIA-13_QFN18_4X4
UT2 = AR-4C_BGA_337P-T: room: AR
UT3 = W25Q80DVZPIG_WSON8: room: AR
UV14 = MC74VHC1G09DFT2G_SC70-5
UZ2 = APE8937GN2_DFN8_2X2: room: 3V_5V_DC_DC
UZ3 = APE8937GN2_DFN8_2X2: room: PCH_DC_DC
UZ4 = APE8937GN2_DFN8_2X2: room: CAMERA_CR_DC_DC
UZ5 = APE8937GN2_DFN8_2X2: room: HDD_DC_DC
UZ6 = SY6288C20AAC_SOT23-5: room: EDP_DC_DC
UZ7 UZ14 = TPS22961DNYR_WSON8: room: CPU_DC_DC
UZ8 UZ10 UZ11 UZ15-UZ17 = MC74VHC1G08DFT2G_SC70-5: room: CPU
UZ18 = APE8937GN2_DFN8_2X2: room: CPU_DC_DC
YC1 = X_7XA0000600_4P
YE2 = Y_X1A000141000200_2P: room: KBC
YH1 = Y_CM31532768DZFT_2P: room: PCH
YH2 = Y_X3G024000DC1H_4P: room: PCH
YT1 = Y_7M25000016_4P: room: ETY-ROOM

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002KDW_SOT363-6
  oval 0.356x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.6) 5(0.65,1.6) 6(0,1.6)
2N7002KTB_SOT523-3
  oval 0.406x0.457 smd: 1(0,0) 2(-0.5,-1.35) 3(0.5,-1.35)
74AUP1G02GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AUP1G04GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AUP1G86GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50271-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(3.8,-2.9) 4(-2.55,-2.9)
ACES_50506-01841-P01_18P-NPM
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50506-02041-P01_20P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 0.991x2.007 smd: 21(-2.1,-3.05) 22(11.6,-3.05)
ACES_50521-0084N-P01_8P
  oval 0.305x1.092 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0)
  rect 0.406x0.787 smd: 9(1,-2.65) 10(-4.5,-2.65)
ACES_50521-01041-P01_10P
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.5) 12(5.5,-2.5)
ACES_50521-01041-P01_10P-NPM
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.5) 12(5.5,-2.5)
ACES_50696-0260M-P01_26P
  oval 0.305x0.991 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0)
  rect 0.406x0.787 smd: 27(-1,-2.6) 28(13.5,-2.6)
AON6232A_DFN5X6-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
AON6380_DFN5X6-8-5
  oval 0.508x0.838 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.15x1.15 smd: 5(1.905,3.69)
AON6962_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.63)
AON7405_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
APE8937GN2_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.6x0.889 smd: 9(0.75,1.1)
APX8131AI-TRG_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AR-4C_BGA_337P-T
  round 0.254 smd: A1(0,0) A23(-10.12,0) AA2(-0.46,9.2) AA22(-9.66,9.2) AB2(-0.46,9.66) AB3(-0.92,9.66) AB4(-1.38,9.66) AB5(-1.84,9.66) AB6(-2.3,9.66) AB7(-2.76,9.66) AB8(-3.22,9.66) AB9(-3.68,9.66) AB10(-4.14,9.66) AB11(-4.6,9.66) AB12(-5.06,9.66) AB13(-5.52,9.66) AB14(-5.98,9.66) AB15(-6.44,9.66) AB16(-6.9,9.66) AB17(-7.36,9.66) AB18(-7.82,9.66) AB19(-8.28,9.66) AB20(-8.74,9.66) AB21(-9.2,9.66) AB22(-9.66,9.66) AC1(0,10.12) AC23(-10.12,10.12) B2(-0.46,0.46) B3(-0.92,0.46) B4(-1.38,0.46) B5(-1.84,0.46) B6(-2.3,0.46) B7(-2.76,0.46) B8(-3.22,0.46) B9(-3.68,0.46) B10(-4.14,0.46) B11(-4.6,0.46) B12(-5.06,0.46) B13(-5.52,0.46) B14(-5.98,0.46) B15(-6.44,0.46) B16(-6.9,0.46) B17(-7.36,0.46) B18(-7.82,0.46) B19(-8.28,0.46) B20(-8.74,0.46) B21(-9.2,0.46) B22(-9.66,0.46) C2(-0.46,0.92) C22(-9.66,0.92) D2(-0.46,1.38) D4(-1.16,1.16) D5(-1.81,1.16) D6(-2.46,1.16) D8(-3.11,1.16) D9(-3.76,1.16) D11(-4.41,1.16) D12(-5.06,1.16) D13(-5.71,1.16) D15(-6.36,1.16) D16(-7.01,1.16) D18(-7.66,1.16) D19(-8.31,1.16) D20(-8.96,1.16) D22(-9.66,1.38) E2(-0.46,1.84) E4(-1.16,1.81) E5(-1.81,1.81) E6(-2.46,1.81) E8(-3.11,1.81) E9(-3.76,1.81) E11(-4.41,1.81) E12(-5.06,1.81) E13(-5.71,1.81) E15(-6.36,1.81) E16(-7.01,1.81) E18(-7.66,1.81) E19(-8.31,1.81) E20(-8.96,1.81) E22(-9.66,1.84) F2(-0.46,2.3) F4(-1.16,2.46) F5(-1.81,2.46) F6(-2.46,2.46) F8(-3.11,2.46) F9(-3.76,2.46) F11(-4.41,2.46) F12(-5.06,2.46) F13(-5.71,2.46) F15(-6.36,2.46) F16(-7.01,2.46) F18(-7.66,2.46) F19(-8.31,2.46) F20(-8.96,2.46) F22(-9.66,2.3) G2(-0.46,2.76) G22(-9.66,2.76) H2(-0.46,3.22) H4(-1.16,3.11) H5(-1.81,3.11) H6(-2.46,3.11) H8(-3.11,3.11) H9(-3.76,3.11) H11(-4.41,3.11) H12(-5.06,3.11) H13(-5.71,3.11) H15(-6.36,3.11) H16(-7.01,3.11) H18(-7.66,3.11) H19(-8.31,3.11) H20(-8.96,3.11) H22(-9.66,3.22) J2(-0.46,3.68) J4(-1.16,3.76) J5(-1.81,3.76) J6(-2.46,3.76) J8(-3.11,3.76) J9(-3.76,3.76) J11(-4.41,3.76) J12(-5.06,3.76) J13(-5.71,3.76) J15(-6.36,3.76) J16(-7.01,3.76) J18(-7.66,3.76) J19(-8.31,3.76) J20(-8.96,3.76) J22(-9.66,3.68) K2(-0.46,4.14) K22(-9.66,4.14) L2(-0.46,4.6) L4(-1.16,4.41) L5(-1.81,4.41) L6(-2.46,4.41) L8(-3.11,4.41) L9(-3.76,4.41) L11(-4.41,4.41) L12(-5.06,4.41) L13(-5.71,4.41) L15(-6.36,4.41) L16(-7.01,4.41) L18(-7.66,4.41) L19(-8.31,4.41) L20(-8.96,4.41) L22(-9.66,4.6) M2(-0.46,5.06) M4(-1.16,5.06) M5(-1.81,5.06) M6(-2.46,5.06) M8(-3.11,5.06) M9(-3.76,5.06) M11(-4.41,5.06) M12(-5.06,5.06) M13(-5.71,5.06) M15(-6.36,5.06) M16(-7.01,5.06) M18(-7.66,5.06) M19(-8.31,5.06) M20(-8.96,5.06) M22(-9.66,5.06) N2(-0.46,5.52) N4(-1.16,5.71) N5(-1.81,5.71) N6(-2.46,5.71) N8(-3.11,5.71) N9(-3.76,5.71) N11(-4.41,5.71) N12(-5.06,5.71) N13(-5.71,5.71) N15(-6.36,5.71) N16(-7.01,5.71) N18(-7.66,5.71) N19(-8.31,5.71) N20(-8.96,5.71) N22(-9.66,5.52) P2(-0.46,5.98) P22(-9.66,5.98) R2(-0.46,6.44) R4(-1.16,6.36) R5(-1.81,6.36) R6(-2.46,6.36) R8(-3.11,6.36) R9(-3.76,6.36) R11(-4.41,6.36) R12(-5.06,6.36) R13(-5.71,6.36) R15(-6.36,6.36) R16(-7.01,6.36) R18(-7.66,6.36) R19(-8.31,6.36) R20(-8.96,6.36) R22(-9.66,6.44) T2(-0.46,6.9) T4(-1.16,7.01) T5(-1.81,7.01) T6(-2.46,7.01) T8(-3.11,7.01) T9(-3.76,7.01) T11(-4.41,7.01) T12(-5.06,7.01) T13(-5.71,7.01) T15(-6.36,7.01) T16(-7.01,7.01) T18(-7.66,7.01) T19(-8.31,7.01) T20(-8.96,7.01) T22(-9.66,6.9) U2(-0.46,7.36) U22(-9.66,7.36) V2(-0.46,7.82) V4(-1.16,7.66) V5(-1.81,7.66) V6(-2.46,7.66) V8(-3.11,7.66) V9(-3.76,7.66) V11(-4.41,7.66) V12(-5.06,7.66) V13(-5.71,7.66) V15(-6.36,7.66) V16(-7.01,7.66) V18(-7.66,7.66) V19(-8.31,7.66) V20(-8.96,7.66) V22(-9.66,7.82) W2(-0.46,8.28) W4(-1.16,8.31) W5(-1.81,8.31) W6(-2.46,8.31) W8(-3.11,8.31) W9(-3.76,8.31) W11(-4.41,8.31) W12(-5.06,8.31) W13(-5.71,8.31) W15(-6.36,8.31) W16(-7.01,8.31) W18(-7.66,8.31) W19(-8.31,8.31) W20(-8.96,8.31) W22(-9.66,8.28) Y2(-0.46,8.74) Y4(-1.16,8.96) Y5(-1.81,8.96) Y6(-2.46,8.96) Y8(-3.11,8.96) Y9(-3.76,8.96) Y11(-4.41,8.96) Y12(-5.06,8.96) Y13(-5.71,8.96) Y15(-6.36,8.96) Y16(-7.01,8.96) Y18(-7.66,8.96) Y19(-8.31,8.96) Y20(-8.96,8.96) Y22(-9.66,8.74)
  oval 0.178x0.33 smd: A2(-0.46,0) A3(-0.92,0) A4(-1.38,0) A5(-1.84,0) A6(-2.3,0) A7(-2.76,0) A8(-3.22,0) A9(-3.68,0) A10(-4.14,0) A11(-4.6,0) A12(-5.06,0) A13(-5.52,0) A14(-5.98,0) A15(-6.44,0) A16(-6.9,0) A17(-7.36,0) A18(-7.82,0) A19(-8.28,0) A20(-8.74,0) A21(-9.2,0) A22(-9.66,0) AC2(-0.46,10.12) AC3(-0.92,10.12) AC4(-1.38,10.12) AC5(-1.84,10.12) AC6(-2.3,10.12) AC7(-2.76,10.12) AC8(-3.22,10.12) AC9(-3.68,10.12) AC10(-4.14,10.12) AC11(-4.6,10.12) AC12(-5.06,10.12) AC13(-5.52,10.12) AC14(-5.98,10.12) AC15(-6.44,10.12) AC16(-6.9,10.12) AC17(-7.36,10.12) AC18(-7.82,10.12) AC19(-8.28,10.12) AC20(-8.74,10.12) AC21(-9.2,10.12) AC22(-9.66,10.12)
  oval 0.33x0.178 smd: AA1(0,9.2) AA23(-10.12,9.2) AB1(0,9.66) AB23(-10.12,9.66) B1(0,0.46) B23(-10.12,0.46) C1(0,0.92) C23(-10.12,0.92) D1(0,1.38) D23(-10.12,1.38) E1(0,1.84) E23(-10.12,1.84) F1(0,2.3) F23(-10.12,2.3) G1(0,2.76) G23(-10.12,2.76) H1(0,3.22) H23(-10.12,3.22) J1(0,3.68) J23(-10.12,3.68) K1(0,4.14) K23(-10.12,4.14) L1(0,4.6) L23(-10.12,4.6) M1(0,5.06) M23(-10.12,5.06) N1(0,5.52) N23(-10.12,5.52) P1(0,5.98) P23(-10.12,5.98) R1(0,6.44) R23(-10.12,6.44) T1(0,6.9) T23(-10.12,6.9) U1(0,7.36) U23(-10.12,7.36) V1(0,7.82) V23(-10.12,7.82) W1(0,8.28) W23(-10.12,8.28) Y1(0,8.74) Y23(-10.12,8.74)
AS331KTR-G1_SOT23-5
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0,2.6)
AZ4520-01FPR7G_DFN1610P2E2
  rect 0.635x0.991 smd: 1(0,0) 2(1.225,0)
AZ5125-01HPR7G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.5,0)
AZ5125-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54ATB_SOT523-3
  oval 0.406x0.457 smd: 1(0,0) 2(0.5,1.35) 3(-0.5,1.35)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BELLW_80159-3221_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.584 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.778 smd: 1(0,0) 2(2.667,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_EEFSS0D221R
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_X
  rect 1.803x2.896 smd: 1(0,0) 2(6,0)
CHILI_HEI322512A-1R0M-Q8_2P
  rect 0.889x2.794 smd: 1(0,0) 2(2.6,0)
CHILI_MHCD252012A-2R2M-A8S_2P
  rect 0.787x2.007 smd: 1(0,0) 2(2,0)
CHILI_PBY160808T-300Y-N_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
CYPD5256-96BZXI_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
DEREN_40-42507-01001RHF_10P-T
  oval 0.787x1.295 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0) 6(6.25,0) 7(7.5,0) 8(8.75,0) 9(10,0) 10(11.25,0)
  oval 1.041x1.651 hole 0.66x1.245: 11(13,-2.85) 12(13,-6.325) 13(-1.75,-2.85) 14(-1.75,-6.325)
DMG2301U-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DPS1113FIA-13_QFN18_4X4
  oval 0.762x1.295 smd: 1(0,0) 13(3.85,0)
  oval 0.762x0.305 smd: 2(0,-1) 3(0,-1.5) 4(0,-2) 10(3.85,-2) 11(3.85,-1.5) 12(3.85,-1)
  oval 0.305x0.762 smd: 5(0.925,-2.925) 6(1.425,-2.925) 7(1.925,-2.925) 8(2.425,-2.925) 9(2.925,-2.925)
  rect 2.591x2.972 smd: 14(1.925,-0.813)
EMIST_SUL-12A2M_1P
  rect 6.909x1.194 smd: 1(0,0)
ESD101-B1-02ELS_TSSLP-2-4-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
ESD108-B1-CSP0201_WLL-2-1-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
FDMC6675BZ_MLP8-5
  oval 0.432x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.537x0.537 smd: 5(0.975,2.075)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G9661-25ADJRE1U_TDFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.311x1.499 smd: 11(1,1.55)
H_1P0N
  round 0.991 hole 0.991 unplated: (0,0)
H_1P2
  round 1.702 hole 1.194: 1(0,0)
H_1P3X1P8
  oval 1.803x2.311 hole 1.295x1.803: 1(0,0)
H_1P6
  round 2.108 hole 1.6: 1(0,0)
H_2P3-G
  round 2.819 hole 2.311: 1(0,0)
H_2P7N
  round 2.692 hole 2.692 unplated: (0,0)
H_3P3
  round 3.81 hole 3.302: 1(0,0)
H_3P3-G
  round 3.81 hole 3.302: 1(0,0)
H_3P5
  round 4.013 hole 3.505: 1(0,0)
H_3P9N
  round 3.912 hole 3.912 unplated: (0,0)
H_6P0N
  round 5.994 hole 5.994 unplated: (0,0)
ISL88738HRTZ-T_TQFN32_4X4-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
JAE_DX07B024XJ1R1300_24P
  round 0.787 hole 0.787 unplated: (-0.85,-0.66)
  oval 0.94x0.787 hole 0.94x0.787 unplated: (6.35,-0.66)
  oval 1.092x1.956 hole 0.61x1.448: 1(-2.05,-1.535) 2(7.55,-1.535)
  oval 1.092x2.388 hole 0.61x1.6: 3(-3.05,-5.76) 4(8.55,-5.76)
  oval 0.305x1.092 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  round 0.61 hole 0.406: B1(5.55,-1.21) B2(5.15,-2.01) B3(4.35,-2.01) B4(4.1,-1.21) B5(3.55,-2.01) B6(3.15,-1.21) B7(2.35,-1.21) B8(1.95,-2.01) B9(1.4,-1.21) B10(1.15,-2.01) B11(0.35,-2.01) B12(-0.05,-1.21)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JXT_WB247H-006G10M_6P-T
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0)
  rect 1.194x1.803 smd: 7(1.3,-3.875) 8(-6.3,-3.875)
K4A8G165WB-BCPB_FBGA_96P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A7(4.801,0) A8(5.601,0) A9(6.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B7(4.801,-0.8) B8(5.601,-0.8) B9(6.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C7(4.801,-1.6) C8(5.601,-1.6) C9(6.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D7(4.801,-2.4) D8(5.601,-2.4) D9(6.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E7(4.801,-3.2) E8(5.601,-3.2) E9(6.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F7(4.801,-4) F8(5.601,-4) F9(6.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G7(4.801,-4.801) G8(5.601,-4.801) G9(6.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H7(4.801,-5.601) H8(5.601,-5.601) H9(6.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J7(4.801,-6.401) J8(5.601,-6.401) J9(6.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K7(4.801,-7.201) K8(5.601,-7.201) K9(6.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L7(4.801,-8.001) L8(5.601,-8.001) L9(6.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M7(4.801,-8.801) M8(5.601,-8.801) M9(6.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N7(4.801,-9.601) N8(5.601,-9.601) N9(6.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P7(4.801,-10.401) P8(5.601,-10.401) P9(6.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R7(4.801,-11.201) R8(5.601,-11.201) R9(6.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T7(4.801,-12.002) T8(5.601,-12.002) T9(6.401,-12.002)
KABYLAKE-G_BGA_2270P-T
  round 0.406 smd: A3(-1.254,0) A4(-1.971,0) A5(-2.771,0) A43(-27.609,0) A44(-28.422,0) A45(-29.203,0) B2(-0.64,0.66) B3(-1.387,0.703) B4(-2.057,0.647) B44(-28.348,0.701) B45(-29.058,0.703) B46(-29.778,0.553) C1(0,1.267) C2(-0.66,1.311) C3(-1.321,1.353) C45(-29.058,1.402) C46(-29.778,1.334) D1(0,2.013) D2(-0.998,1.919) D46(-29.778,2.097) DE1(0,55.114) DE46(-29.778,55.099) DF1(0,55.838) DF2(-0.828,55.779) DF45(-28.838,55.757) DF46(-29.778,55.81) DG1(0,56.562) DG2(-0.719,56.433) DG44(-28.343,56.471) DG45(-29.054,56.427) DG46(-29.778,56.536) DH2(-0.571,57.128) DH3(-1.295,57.128) DH4(-2.019,57.128) DH43(-27.647,57.128) DH44(-28.46,57.128) DH45(-29.186,57.128) E1(0,2.864)
  round 0.33 smd: A6(-3.508,0) A40(-26.022,0) AA13(-7.813,13.065) AA14(-8.463,13.065) AA15(-9.113,13.065) AB13(-7.813,13.979) AB14(-8.463,13.979) AB15(-9.113,13.979) AD13(-7.813,15.046) AD14(-8.463,15.046) AD15(-9.113,15.046) AE13(-7.813,15.96) AE14(-8.463,15.96) AE15(-9.113,15.96) AG13(-7.813,17.027) AG14(-8.463,17.027) AG15(-9.113,17.027) AH13(-7.813,17.942) AH14(-8.463,17.942) AH15(-9.113,17.942) AK13(-7.813,19.008) AK14(-8.463,19.008) AK15(-9.113,19.008) AL13(-7.813,19.923) AL14(-8.463,19.923) AL15(-9.113,19.923) AN13(-7.813,20.99) AN14(-8.463,20.99) AN15(-9.113,20.99) AP13(-7.813,21.904) AP14(-8.463,21.904) AP15(-9.113,21.904) AT13(-7.813,22.818) AT14(-8.463,22.818) AT15(-9.113,22.818) AU13(-7.813,23.733) AU14(-8.463,23.733) AU15(-9.113,23.733) AV13(-7.813,24.647) AV14(-8.463,24.647) AV15(-9.113,24.647) AW13(-7.813,25.562) AW14(-8.463,25.562) AW15(-9.113,25.562) AY11(-6.512,26.476) AY12(-7.162,26.476) AY13(-7.813,26.476) AY14(-8.463,26.476) AY15(-9.113,26.476) B5(-2.743,0.65) BB11(-6.512,27.39) BB12(-7.162,27.39) BB13(-7.813,27.39) BB14(-8.463,27.39) BB15(-9.113,27.39) BC11(-6.512,28.305) BC12(-7.162,28.305) BC13(-7.813,28.305) BE11(-6.512,29.219) BE12(-7.162,29.219) BE13(-7.813,29.219) BE14(-8.563,29.219) BG11(-6.512,30.134) BG12(-7.162,30.134) BG13(-7.813,30.134) BG14(-8.563,30.134) BH11(-6.512,31.048) BH12(-7.162,31.048) BH13(-7.813,31.048) BH14(-8.563,31.048) BK11(-6.512,31.962) BK12(-7.162,31.962) BK13(-7.813,31.962) BK14(-8.563,31.962) BL11(-6.512,32.877) BL12(-7.162,32.877) BL13(-7.813,32.877) BL14(-8.563,32.877) BM11(-6.512,33.791) BM12(-7.162,33.791) BM13(-7.813,33.791) BM14(-8.563,33.791) BP11(-6.512,34.706) BP12(-7.162,34.706) BP13(-7.813,34.706) BP14(-8.563,34.706) BR11(-6.512,35.62) BR12(-7.162,35.62) BU11(-6.512,36.534) BU12(-7.162,36.534) BV11(-6.512,37.449) BV12(-7.162,37.449) BW11(-6.512,38.363) BW12(-7.162,38.363) C4(-2.057,1.297) CA11(-6.512,39.278) CA12(-7.162,39.278) CB11(-6.512,40.192) CB12(-7.162,40.192) CD11(-6.512,41.106) CD12(-7.162,41.106) CE11(-6.512,42.021) CE12(-7.162,42.021) CF11(-6.512,42.935) CF12(-7.162,42.935) CH11(-6.512,43.85) CH12(-7.162,43.85) CJ11(-6.512,44.764) CJ12(-7.162,44.764) CL11(-6.512,45.678) CL12(-7.162,45.678) CM11(-6.512,46.593) CM12(-7.162,46.593) CN11(-6.512,47.507) CN12(-7.162,47.507) CR11(-6.512,48.422) CR12(-7.162,48.422) CT11(-6.512,49.336) CT12(-7.162,49.336) CV11(-6.512,50.25) CV12(-7.162,50.25) CW11(-6.512,51.165) CW12(-7.162,51.165) CY11(-6.512,52.079) CY12(-7.162,52.079) DB11(-6.512,52.994) DB12(-7.282,52.905) DB13(-7.899,53.227) DB14(-8.813,53.227) DB16(-9.601,53.227) DB17(-10.388,53.227) DB18(-11.175,53.227) DB19(-11.963,53.227) DB20(-12.75,53.227) DB22(-13.538,53.227) DB23(-14.325,53.227) DB24(-15.112,53.227) DB25(-15.9,53.227) DB26(-16.687,53.227) DB27(-17.475,53.227) DB28(-18.262,53.227) DB30(-19.049,53.227) DB31(-19.837,53.227) DB32(-20.624,53.227) DC1(0,53.536) DC46(-29.778,53.676) DE2(-0.65,55.142) DE45(-29.115,55.164) DG4(-2.166,56.484) DG43(-27.685,56.478) DH5(-2.819,57.128) DH6(-3.594,57.128) DH41(-26.073,57.128) F46(-29.778,3.671) H13(-7.813,4.835) H14(-8.463,4.835) H15(-9.113,4.835) K13(-7.813,5.75) K14(-8.463,5.75) K15(-9.113,5.75) L13(-7.813,6.664) L14(-8.463,6.664) L15(-9.113,6.664) M13(-7.813,7.578) M14(-8.463,7.578) M15(-9.113,7.578) P13(-7.813,8.493) P14(-8.463,8.493) P15(-9.113,8.493) R13(-7.813,9.407) R14(-8.463,9.407) R15(-9.113,9.407) U13(-7.813,10.322) U14(-8.463,10.322) U15(-9.113,10.322) V13(-7.813,11.236) V14(-8.463,11.236) V15(-9.113,11.236) W13(-7.813,12.15) W14(-8.463,12.15) W15(-9.113,12.15)
  round 0.305 smd: A7(-4.318,0) A9(-5.105,0) A10(-5.893,0) A11(-6.68,0) A12(-7.468,0) A13(-8.255,0) A15(-9.042,0) A16(-9.83,0) A17(-10.617,0) A18(-11.405,0) A20(-12.192,0) A21(-12.979,0) A22(-13.767,0) A23(-14.554,0) A24(-15.342,0) A25(-16.129,0) A26(-16.916,0) A28(-17.704,0) A29(-18.491,0) A30(-19.279,0) A31(-20.066,0) A32(-20.853,0) A34(-21.641,0) A35(-22.428,0) A36(-23.216,0) A37(-24.003,0) A39(-24.994,0) AA7(-3.911,13.09) AA8(-4.561,13.09) AA9(-5.212,13.065) AA10(-5.862,13.065) AA11(-6.512,13.065) AA12(-7.162,13.065) AB1(0,13.577) AB2(-0.65,13.577) AB3(-1.3,13.577) AB4(-1.951,13.577) AB5(-2.601,13.577) AB6(-3.251,13.577) AB7(-3.911,14.005) AB8(-4.561,14.005) AB9(-5.212,13.979) AB10(-5.862,13.979) AB11(-6.512,13.979) AB12(-7.162,13.979) AB39(-25.226,13.592) AB40(-25.877,13.592) AB41(-26.527,13.592) AB42(-27.177,13.592) AB43(-27.827,13.592) AB44(-28.477,13.592) AB45(-29.128,13.592) AB46(-29.778,13.592) AC1(0,14.618) AC2(-0.65,14.618) AC3(-1.3,14.618) AC4(-1.951,14.618) AC5(-2.601,14.618) AC6(-3.251,14.618) AC39(-25.226,14.38) AC40(-25.877,14.38) AC41(-26.527,14.38) AC42(-27.177,14.38) AC43(-27.827,14.38) AC44(-28.477,14.38) AC45(-29.128,14.38) AC46(-29.778,14.38) AD7(-3.911,15.071) AD8(-4.561,15.071) AD9(-5.212,15.046) AD10(-5.862,15.046) AD11(-6.512,15.046) AD12(-7.162,15.046) AD39(-25.226,15.167) AD40(-25.877,15.167) AD41(-26.527,15.167) AD42(-27.177,15.167) AD43(-27.827,15.167) AD44(-28.477,15.167) AD45(-29.128,15.167) AD46(-29.778,15.167) AE1(0,15.507) AE2(-0.65,15.507) AE3(-1.3,15.507) AE4(-1.951,15.507) AE5(-2.601,15.507) AE6(-3.251,15.507) AE7(-3.911,15.986) AE8(-4.561,15.986) AE9(-5.212,15.96) AE10(-5.862,15.96) AE11(-6.512,15.96) AE12(-7.162,15.96) AE39(-25.226,15.955) AE40(-25.877,15.955) AE41(-26.527,15.955) AE42(-27.177,15.955) AE43(-27.827,15.955) AE44(-28.477,15.955) AE45(-29.128,15.955) AE46(-29.778,15.955) AF1(0,16.549) AF2(-0.65,16.549) AF3(-1.3,16.549) AF4(-1.951,16.549) AF5(-2.601,16.549) AF6(-3.251,16.549) AG7(-3.911,17.053) AG8(-4.561,17.053) AG9(-5.212,17.027) AG10(-5.862,17.027) AG11(-6.512,17.027) AG12(-7.162,17.027) AG39(-25.226,16.742) AG40(-25.877,16.742) AG41(-26.527,16.742) AG42(-27.177,16.742) AG43(-27.827,16.742) AG44(-28.477,16.742) AG45(-29.128,16.742) AG46(-29.778,16.742) AH1(0,17.438) AH2(-0.65,17.438) AH3(-1.3,17.438) AH4(-1.951,17.438) AH5(-2.601,17.438) AH6(-3.251,17.438) AH7(-3.911,17.967) AH8(-4.561,17.967) AH9(-5.212,17.942) AH10(-5.862,17.942) AH11(-6.512,17.942) AH12(-7.162,17.942) AH39(-25.226,17.529) AH40(-25.877,17.529) AH41(-26.527,17.529) AH42(-27.177,17.529) AH43(-27.827,17.529) AH44(-28.477,17.529) AH45(-29.128,17.529) AH46(-29.778,17.529) AJ1(0,18.479) AJ2(-0.65,18.479) AJ3(-1.3,18.479) AJ4(-1.951,18.479) AJ5(-2.601,18.479) AJ6(-3.251,18.479) AJ39(-25.226,18.317) AJ40(-25.877,18.317) AJ41(-26.527,18.317) AJ42(-27.177,18.317) AJ43(-27.827,18.317) AJ44(-28.477,18.317) AJ45(-29.128,18.317) AJ46(-29.778,18.317) AK7(-3.911,19.034) AK8(-4.561,19.034) AK9(-5.212,19.008) AK10(-5.862,19.008) AK11(-6.512,19.008) AK12(-7.162,19.008) AK39(-25.226,19.104) AK40(-25.877,19.104) AK41(-26.527,19.104) AK42(-27.177,19.104) AK43(-27.827,19.104) AK44(-28.477,19.104) AK45(-29.128,19.104) AK46(-29.778,19.104) AL1(0,19.368) AL2(-0.65,19.368) AL3(-1.3,19.368) AL4(-1.951,19.368) AL5(-2.601,19.368) AL6(-3.251,19.368) AL7(-3.911,19.948) AL8(-4.561,19.948) AL9(-5.212,19.923) AL10(-5.862,19.923) AL11(-6.512,19.923) AL12(-7.162,19.923) AL39(-25.226,19.892) AL40(-25.877,19.892) AL41(-26.527,19.892) AL42(-27.177,19.892) AL43(-27.827,19.892) AL44(-28.477,19.892) AL45(-29.128,19.892) AL46(-29.778,19.892) AM1(0,20.41) AM2(-0.65,20.41) AM3(-1.3,20.41) AM4(-1.951,20.41) AM5(-2.601,20.41) AM6(-3.251,20.41) AN7(-3.911,21.015) AN8(-4.561,21.015) AN9(-5.212,20.99) AN10(-5.862,20.99) AN11(-6.512,20.99) AN12(-7.162,20.99) AN39(-25.226,20.679) AN40(-25.877,20.679) AN41(-26.527,20.679) AN42(-27.177,20.679) AN43(-27.827,20.679) AN44(-28.477,20.679) AN45(-29.128,20.679) AN46(-29.778,20.679) AP1(0,21.299) AP2(-0.65,21.299) AP3(-1.3,21.299) AP4(-1.951,21.299) AP5(-2.601,21.299) AP6(-3.251,21.299) AP7(-3.911,21.929) AP8(-4.561,21.929) AP9(-5.212,21.904) AP10(-5.862,21.904) AP11(-6.512,21.904) AP12(-7.162,21.904) AP39(-25.226,21.466) AP40(-25.877,21.466) AP41(-26.527,21.466) AP42(-27.177,21.466) AP43(-27.827,21.466) AP44(-28.477,21.466) AP45(-29.128,21.466) AP46(-29.778,21.466) AR1(0,22.086) AR2(-0.65,22.086) AR3(-1.3,22.086) AR4(-1.951,22.086) AR5(-2.601,22.086) AR6(-3.251,22.086) AR39(-25.226,22.254) AR40(-25.877,22.254) AR41(-26.527,22.254) AR42(-27.177,22.254) AR43(-27.827,22.254) AR44(-28.477,22.254) AR45(-29.128,22.254) AR46(-29.778,22.254) AT1(0,22.975) AT2(-0.65,22.975) AT3(-1.3,22.975) AT4(-1.951,22.975) AT5(-2.601,22.975) AT6(-3.251,22.975) AT7(-3.911,22.844) AT8(-4.561,22.844) AT9(-5.212,22.818) AT10(-5.862,22.818) AT11(-6.512,22.818) AT12(-7.162,22.818) AT39(-25.226,23.041) AT40(-25.877,23.041) AT41(-26.527,23.041) AT42(-27.177,23.041) AT43(-27.827,23.041) AT44(-28.477,23.041) AT45(-29.128,23.041) AT46(-29.778,23.041) AU1(0,23.712) AU2(-0.65,23.712) AU3(-1.3,23.712) AU4(-1.951,23.712) AU5(-2.601,23.712) AU6(-3.251,23.712) AU7(-3.911,23.733) AU8(-4.561,23.733) AU9(-5.212,23.733) AU10(-5.862,23.733) AU11(-6.512,23.733) AU12(-7.162,23.733) AU39(-25.226,23.829) AU40(-25.877,23.829) AU41(-26.527,23.829) AU42(-27.177,23.829) AU43(-27.827,23.829) AU44(-28.477,23.829) AU45(-29.128,23.829) AU46(-29.778,23.829) AV1(0,24.601) AV2(-0.65,24.601) AV3(-1.3,24.601) AV4(-1.951,24.601) AV5(-2.601,24.601) AV6(-3.251,24.601) AV7(-3.911,24.647) AV8(-4.561,24.647) AV9(-5.212,24.647) AV10(-5.862,24.647) AV11(-6.512,24.647) AV12(-7.162,24.647) AV39(-25.226,24.616) AV40(-25.877,24.616) AV41(-26.527,24.616) AV42(-27.177,24.616) AV43(-27.827,24.616) AV44(-28.477,24.616) AV45(-29.128,24.616) AV46(-29.778,24.616) AW1(0,25.49) AW2(-0.65,25.49) AW3(-1.3,25.49) AW4(-1.951,25.49) AW5(-2.601,25.49) AW6(-3.251,25.49) AW7(-3.911,25.562) AW8(-4.561,25.562) AW9(-5.212,25.562) AW10(-5.862,25.562) AW11(-6.512,25.562) AW12(-7.162,25.562) AW39(-25.226,25.403) AW40(-25.877,25.403) AW41(-26.527,25.403) AW42(-27.177,25.403) AW43(-27.827,25.403) AW44(-28.477,25.403) AW45(-29.128,25.403) AW46(-29.778,25.403) AY1(0,26.226) AY2(-0.65,26.226) AY3(-1.3,26.226) AY4(-1.951,26.226) AY5(-2.601,26.226) AY6(-3.251,26.226) AY7(-3.911,26.476) AY8(-4.561,26.476) AY9(-5.212,26.476) AY10(-5.862,26.476) AY39(-25.226,26.191) AY40(-25.877,26.191) AY41(-26.527,26.191) AY42(-27.177,26.191) AY43(-27.827,26.191) AY44(-28.477,26.191) AY45(-29.128,26.191) AY46(-29.778,26.191) B6(-3.531,0.65) B7(-4.318,0.65) B9(-5.105,0.65) B10(-5.893,0.65) B11(-6.68,0.65) B12(-7.468,0.65) B13(-8.255,0.65) B15(-9.042,0.65) B16(-9.83,0.65) B17(-10.617,0.65) B18(-11.405,0.65) B20(-12.192,0.65) B21(-12.979,0.65) B22(-13.767,0.65) B23(-14.554,0.65) B24(-15.342,0.65) B25(-16.129,0.65) B26(-16.916,0.65) B28(-17.704,0.65) B29(-18.491,0.65) B30(-19.279,0.65) B31(-20.066,0.65) B32(-20.853,0.65) B34(-21.641,0.65) B35(-22.428,0.65) B36(-23.216,0.65) B37(-24.003,0.65) B39(-24.79,0.65) B40(-25.578,0.65) B41(-26.365,0.65) B42(-27.153,0.65) B43(-27.827,1.131) BA1(0,27.115) BA2(-0.65,27.115) BA3(-1.3,27.115) BA4(-1.951,27.115) BA5(-2.601,27.115) BA6(-3.251,27.115) BA41(-26.527,26.978) BA42(-27.177,26.978) BA43(-27.827,26.978) BA44(-28.477,26.978) BA45(-29.128,26.978) BA46(-29.778,26.978) BB7(-3.911,27.39) BB8(-4.561,27.39) BB9(-5.212,27.39) BB10(-5.862,27.39) BB39(-25.075,27.352) BB40(-25.726,27.352) BB41(-26.527,27.766) BB42(-27.177,27.766) BB43(-27.827,27.766) BB44(-28.477,27.766) BB45(-29.128,27.766) BB46(-29.778,27.766) BC1(0,28.004) BC2(-0.65,28.004) BC3(-1.3,28.004) BC4(-1.951,28.004) BC5(-2.601,28.004) BC6(-3.251,28.004) BC7(-3.911,28.305) BC8(-4.561,28.305) BC9(-5.212,28.305) BC10(-5.862,28.305) BC39(-25.075,28.166) BC40(-25.726,28.166) BD41(-26.527,28.553) BD42(-27.177,28.553) BD43(-27.827,28.553) BD44(-28.477,28.553) BD45(-29.128,28.553) BD46(-29.778,28.553) BE1(0,28.741) BE2(-0.65,28.741) BE3(-1.3,28.741) BE4(-1.951,28.741) BE5(-2.601,28.741) BE6(-3.251,28.741) BE7(-3.911,29.219) BE8(-4.561,29.219) BE9(-5.212,29.219) BE10(-5.862,29.219) BE15(-9.47,29.181) BE16(-10.12,29.181) BE17(-10.77,29.181) BE18(-11.42,29.181) BE19(-12.071,29.181) BE20(-12.721,29.181) BE21(-13.371,29.181) BE22(-14.021,29.181) BE23(-14.672,29.181) BE24(-15.322,29.181) BE25(-15.972,29.181) BE26(-16.622,29.181) BE27(-17.273,29.181) BE28(-17.923,29.181) BE29(-18.573,29.181) BE30(-19.223,29.181) BE31(-19.873,29.181) BE32(-20.524,29.181) BE33(-21.174,29.181) BE34(-21.824,29.181) BE35(-22.474,29.181) BE36(-23.125,29.181) BE37(-23.775,29.181) BE38(-24.425,29.181) BE39(-25.075,29.181) BE40(-25.726,29.181) BF1(0,29.63) BF2(-0.65,29.63) BF3(-1.3,29.63) BF4(-1.951,29.63) BF5(-2.601,29.63) BF6(-3.251,29.63) BF41(-26.527,29.34) BF42(-27.177,29.34) BF43(-27.827,29.34) BF44(-28.477,29.34) BF45(-29.128,29.34) BF46(-29.778,29.34) BG1(0,30.519) BG2(-0.65,30.519) BG3(-1.3,30.519) BG4(-1.951,30.519) BG5(-2.601,30.519) BG6(-3.251,30.519) BG7(-3.911,30.134) BG8(-4.561,30.134) BG9(-5.212,30.134) BG10(-5.862,30.134) BG15(-9.47,30.095) BG16(-10.12,30.095) BG17(-10.77,30.095) BG18(-11.42,30.095) BG19(-12.071,30.095) BG20(-12.721,30.095) BG21(-13.371,30.095) BG22(-14.021,30.095) BG23(-14.672,30.095) BG24(-15.322,30.095) BG25(-15.972,30.095) BG26(-16.622,30.095) BG27(-17.273,30.095) BG28(-17.923,30.095) BG29(-18.573,30.095) BG30(-19.223,30.095) BG31(-19.873,30.095) BG32(-20.524,30.095) BG33(-21.174,30.095) BG34(-21.824,30.095) BG35(-22.474,30.095) BG36(-23.125,30.095) BG37(-23.775,30.095) BG38(-24.425,30.095) BG39(-25.075,30.095) BG40(-25.726,30.095) BG41(-26.527,30.128) BG42(-27.177,30.128) BG43(-27.827,30.128) BG44(-28.477,30.128) BG45(-29.128,30.128) BG46(-29.778,30.128) BH1(0,31.255) BH2(-0.65,31.255) BH3(-1.3,31.255) BH4(-1.951,31.255) BH5(-2.601,31.255) BH6(-3.251,31.255) BH7(-3.911,31.048) BH8(-4.561,31.048) BH9(-5.212,31.048) BH10(-5.862,31.048) BH15(-9.47,31.01) BH16(-10.12,31.01) BH17(-10.77,31.01) BH18(-11.42,31.01) BH19(-12.071,31.01) BH20(-12.721,31.01) BH21(-13.371,31.01) BH22(-14.021,31.01) BH23(-14.672,31.01) BH24(-15.322,31.01) BH25(-15.972,31.01) BH26(-16.622,31.01) BH27(-17.273,31.01) BH28(-17.923,31.01) BH29(-18.573,31.01) BH30(-19.223,31.01) BH31(-19.873,31.01) BH32(-20.524,31.01) BH33(-21.174,31.01) BH34(-21.824,31.01) BH35(-22.474,31.01) BH36(-23.125,31.01) BH37(-23.775,31.01) BH38(-24.425,31.01) BH39(-25.075,31.01) BH40(-25.726,31.01) BH41(-26.527,30.915) BH42(-27.177,30.915) BH43(-27.827,30.915) BH44(-28.477,30.915) BH45(-29.128,30.915) BH46(-29.778,30.915) BJ15(-9.47,31.924) BJ16(-10.12,31.924) BJ17(-10.77,31.924) BJ18(-11.42,31.924) BJ19(-12.071,31.924) BJ20(-12.721,31.924) BJ21(-13.371,31.924) BJ22(-14.021,31.924) BJ23(-14.672,31.924) BJ24(-15.322,31.924) BJ25(-15.972,31.924) BJ26(-16.622,31.924) BJ27(-17.273,31.924) BJ28(-17.923,31.924) BJ29(-18.573,31.924) BJ30(-19.223,31.924) BJ31(-19.873,31.924) BJ32(-20.524,31.924) BJ33(-21.174,31.924) BJ34(-21.824,31.924) BJ35(-22.474,31.924) BJ36(-23.125,31.924) BJ37(-23.775,31.924) BJ38(-24.425,31.924) BJ39(-25.075,31.924) BJ40(-25.726,31.924) BJ41(-26.527,31.703) BJ42(-27.177,31.703) BJ43(-27.827,31.703) BJ44(-28.477,31.703) BJ45(-29.128,31.703) BJ46(-29.778,31.703) BK1(0,32.144) BK2(-0.65,32.144) BK3(-1.3,32.144) BK4(-1.951,32.144) BK5(-2.601,32.144) BK6(-3.251,32.144) BK7(-3.911,31.962) BK8(-4.561,31.962) BK9(-5.212,31.962) BK10(-5.862,31.962) BK41(-26.527,32.49) BK42(-27.177,32.49) BK43(-27.827,32.49) BK44(-28.477,32.49) BK45(-29.128,32.49) BK46(-29.778,32.49) BL1(0,33.033) BL2(-0.65,33.033) BL3(-1.3,33.033) BL4(-1.951,33.033) BL5(-2.601,33.033) BL6(-3.251,33.033) BL7(-3.911,32.877) BL8(-4.561,32.877) BL9(-5.212,32.877) BL10(-5.862,32.877) BL15(-9.47,32.838) BL16(-10.12,32.838) BL17(-10.77,32.838) BL18(-11.42,32.838) BL19(-12.071,32.838) BL20(-12.721,32.838) BL21(-13.371,32.838) BL22(-14.021,32.838) BL23(-14.672,32.838) BL24(-15.322,32.838) BL25(-15.972,32.838) BL26(-16.622,32.838) BL27(-17.273,32.838) BL28(-17.923,32.838) BL29(-18.573,32.838) BL30(-19.223,32.838) BL31(-19.873,32.838) BL32(-20.524,32.838) BL33(-21.174,32.838) BL34(-21.824,32.838) BL35(-22.474,32.838) BL36(-23.125,32.838) BL37(-23.775,32.838) BL38(-24.425,32.838) BL39(-25.075,32.838) BL40(-25.726,32.838) BM1(0,33.77) BM2(-0.65,33.77) BM3(-1.3,33.77) BM4(-1.951,33.77) BM5(-2.601,33.77) BM6(-3.251,33.77) BM7(-3.911,33.791) BM8(-4.561,33.791) BM9(-5.212,33.791) BM10(-5.862,33.791) BM36(-23.125,33.767) BM37(-23.775,33.767) BM38(-24.425,33.767) BM39(-25.075,33.767) BM40(-25.726,33.767) BM41(-26.527,33.277) BM42(-27.177,33.277) BM43(-27.827,33.277) BM44(-28.477,33.277) BM45(-29.128,33.277) BM46(-29.778,33.277) BN41(-26.527,34.065) BN42(-27.177,34.065) BN43(-27.827,34.065) BN44(-28.477,34.065) BN45(-29.128,34.065) BN46(-29.778,34.065) BP1(0,34.659) BP2(-0.65,34.659) BP3(-1.3,34.659) BP4(-1.951,34.659) BP5(-2.601,34.659) BP6(-3.251,34.659) BP7(-3.911,34.706) BP8(-4.561,34.706) BP9(-5.212,34.706) BP10(-5.862,34.706) BP35(-22.625,34.852) BP36(-23.276,34.852) BP37(-23.926,34.852) BP38(-24.576,34.852) BP39(-25.226,34.852) BP40(-25.877,34.852) BP41(-26.527,34.852) BP42(-27.177,34.852) BP43(-27.827,34.852) BP44(-28.477,34.852) BP45(-29.128,34.852) BP46(-29.778,34.852) BR1(0,35.548) BR2(-0.65,35.548) BR3(-1.3,35.548) BR4(-1.951,35.548) BR5(-2.601,35.548) BR6(-3.251,35.548) BR7(-3.911,35.62) BR8(-4.561,35.62) BR9(-5.212,35.62) BR10(-5.862,35.62) BR35(-22.625,35.64) BR36(-23.276,35.64) BR37(-23.926,35.64) BR38(-24.576,35.64) BR39(-25.226,35.64) BR40(-25.877,35.64) BR41(-26.527,35.64) BR42(-27.177,35.64) BR43(-27.827,35.64) BR44(-28.477,35.64) BR45(-29.128,35.64) BR46(-29.778,35.64) BT1(0,36.285) BT2(-0.65,36.285) BT3(-1.3,36.285) BT4(-1.951,36.285) BT5(-2.601,36.285) BT6(-3.251,36.285) BT35(-22.625,36.427) BT36(-23.276,36.427) BT37(-23.926,36.427) BT38(-24.576,36.427) BT39(-25.226,36.427) BT40(-25.877,36.427) BT41(-26.527,36.427) BT42(-27.177,36.427) BT43(-27.827,36.427) BT44(-28.477,36.427) BT45(-29.128,36.427) BT46(-29.778,36.427) BU7(-3.911,36.534) BU8(-4.561,36.534) BU9(-5.212,36.534) BU10(-5.862,36.534) BV1(0,37.174) BV2(-0.65,37.174) BV3(-1.3,37.174) BV4(-1.951,37.174) BV5(-2.601,37.174) BV6(-3.251,37.174) BV7(-3.911,37.449) BV8(-4.561,37.449) BV9(-5.212,37.449) BV10(-5.862,37.449) BV35(-22.625,37.214) BV36(-23.276,37.214) BV37(-23.926,37.214) BV38(-24.576,37.214) BV39(-25.226,37.214) BV40(-25.877,37.214) BV41(-26.527,37.214) BV42(-27.177,37.214) BV43(-27.827,37.214) BV44(-28.477,37.214) BV45(-29.128,37.214) BV46(-29.778,37.214) BW1(0,38.063) BW2(-0.65,38.063) BW3(-1.3,38.063) BW4(-1.951,38.063) BW5(-2.601,38.063) BW6(-3.251,38.063) BW7(-3.911,38.363) BW8(-4.561,38.363) BW9(-5.212,38.363) BW10(-5.862,38.363) BW35(-22.625,38.002) BW36(-23.276,38.002) BW37(-23.926,38.002) BW38(-24.576,38.002) BW39(-25.226,38.002) BW40(-25.877,38.002) BW41(-26.527,38.002) BW42(-27.177,38.002) BW43(-27.827,38.002) BW44(-28.477,38.002) BW45(-29.128,38.002) BW46(-29.778,38.002) BY1(0,38.799) BY2(-0.65,38.799) BY3(-1.3,38.799) BY4(-1.951,38.799) BY5(-2.601,38.799) BY6(-3.251,38.799) BY35(-22.625,38.789) BY36(-23.276,38.789) BY37(-23.926,38.789) BY38(-24.576,38.789) BY39(-25.226,38.789) BY40(-25.877,38.789) BY41(-26.527,38.789) BY42(-27.177,38.789) BY43(-27.827,38.789) BY44(-28.477,38.789) BY45(-29.128,38.789) BY46(-29.778,38.789) C5(-2.743,1.3) C6(-3.531,1.3) C7(-4.318,1.3) C9(-5.105,1.3) C10(-5.893,1.3) C11(-6.68,1.3) C12(-7.468,1.3) C13(-8.255,1.3) C15(-9.042,1.3) C16(-9.83,1.3) C17(-10.617,1.3) C18(-11.405,1.3) C20(-12.192,1.3) C21(-12.979,1.3) C22(-13.767,1.3) C23(-14.554,1.3) C24(-15.342,1.3) C25(-16.129,1.3) C26(-16.916,1.3) C28(-17.704,1.3) C29(-18.491,1.3) C30(-19.279,1.3) C31(-20.066,1.3) C32(-20.853,1.3) C34(-21.641,1.3) C35(-22.428,1.3) C36(-23.216,1.3) C37(-24.003,1.3) C39(-24.79,1.3) C40(-25.578,1.3) C41(-26.365,1.3) C42(-27.153,1.3) C43(-27.827,1.781) C44(-28.477,1.781) CA1(0,39.688) CA2(-0.65,39.688) CA3(-1.3,39.688) CA4(-1.951,39.688) CA5(-2.601,39.688) CA6(-3.251,39.688) CA7(-3.911,39.278) CA8(-4.561,39.278) CA9(-5.212,39.278) CA10(-5.862,39.278) CA35(-22.625,39.577) CA36(-23.276,39.577) CA37(-23.926,39.577) CA38(-24.576,39.577) CA39(-25.226,39.577) CA40(-25.877,39.577) CA41(-26.527,39.577) CA42(-27.177,39.577) CA43(-27.827,39.577) CA44(-28.477,39.577) CA45(-29.128,39.577) CA46(-29.778,39.577) CB7(-3.911,40.192) CB8(-4.561,40.192) CB9(-5.212,40.192) CB10(-5.862,40.192) CB35(-22.625,40.364) CB36(-23.276,40.364) CB37(-23.926,40.364) CB38(-24.576,40.364) CB39(-25.226,40.364) CB40(-25.877,40.364) CB41(-26.527,40.364) CB42(-27.177,40.364) CB43(-27.827,40.364) CB44(-28.477,40.364) CB45(-29.128,40.364) CB46(-29.778,40.364) CC1(0,40.577) CC2(-0.65,40.577) CC3(-1.3,40.577) CC4(-1.951,40.577) CC5(-2.601,40.577) CC6(-3.251,40.577) CD1(0,41.314) CD2(-0.65,41.314) CD3(-1.3,41.314) CD4(-1.951,41.314) CD5(-2.601,41.314) CD6(-3.251,41.314) CD7(-3.911,41.106) CD8(-4.561,41.106) CD9(-5.212,41.106) CD10(-5.862,41.106) CD35(-22.625,41.151) CD36(-23.276,41.151) CD37(-23.926,41.151) CD38(-24.576,41.151) CD39(-25.226,41.151) CD40(-25.877,41.151) CD41(-26.527,41.151) CD42(-27.177,41.151) CD43(-27.827,41.151) CD44(-28.477,41.151) CD45(-29.128,41.151) CD46(-29.778,41.151) CE1(0,42.203) CE2(-0.65,42.203) CE3(-1.3,42.203) CE4(-1.951,42.203) CE5(-2.601,42.203) CE6(-3.251,42.203) CE7(-3.911,42.021) CE8(-4.561,42.021) CE9(-5.212,42.021) CE10(-5.862,42.021) CE35(-22.625,41.939) CE36(-23.276,41.939) CE37(-23.926,41.939) CE38(-24.576,41.939) CE39(-25.226,41.939) CE40(-25.877,41.939) CE41(-26.527,41.939) CE42(-27.177,41.939) CE43(-27.827,41.939) CE44(-28.477,41.939) CE45(-29.128,41.939) CE46(-29.778,41.939) CF7(-3.911,42.935) CF8(-4.561,42.935) CF9(-5.212,42.935) CF10(-5.862,42.935) CF35(-22.625,42.726) CF36(-23.276,42.726) CF37(-23.926,42.726) CF38(-24.576,42.726) CF39(-25.226,42.726) CF40(-25.877,42.726) CF41(-26.527,42.726) CF42(-27.177,42.726) CF43(-27.827,42.726) CF44(-28.477,42.726) CF45(-29.128,42.726) CF46(-29.778,42.726) CG1(0,43.092) CG2(-0.65,43.092) CG3(-1.3,43.092) CG4(-1.951,43.092) CG5(-2.601,43.092) CG6(-3.251,43.092) CG35(-22.625,43.514) CG36(-23.276,43.514) CG37(-23.926,43.514) CG38(-24.576,43.514) CG39(-25.226,43.514) CG40(-25.877,43.514) CG41(-26.527,43.514) CG42(-27.177,43.514) CG43(-27.827,43.514) CG44(-28.477,43.514) CG45(-29.128,43.514) CG46(-29.778,43.514) CH1(0,43.828) CH2(-0.65,43.828) CH3(-1.3,43.828) CH4(-1.951,43.828) CH5(-2.601,43.828) CH6(-3.251,43.828) CH7(-3.911,43.85) CH8(-4.561,43.85) CH9(-5.212,43.85) CH10(-5.862,43.85) CJ1(0,44.717) CJ2(-0.65,44.717) CJ3(-1.3,44.717) CJ4(-1.951,44.717) CJ5(-2.601,44.717) CJ6(-3.251,44.717) CJ7(-3.911,44.764) CJ8(-4.561,44.764) CJ9(-5.212,44.764) CJ10(-5.862,44.764) CJ35(-22.625,44.301) CJ36(-23.276,44.301) CJ37(-23.926,44.301) CJ38(-24.576,44.301) CJ39(-25.226,44.301) CJ40(-25.877,44.301) CJ41(-26.527,44.301) CJ42(-27.177,44.301) CJ43(-27.827,44.301) CJ44(-28.477,44.301) CJ45(-29.128,44.301) CJ46(-29.778,44.301) CK35(-22.625,45.088) CK36(-23.276,45.088) CK37(-23.926,45.088) CK38(-24.576,45.088) CK39(-25.226,45.088) CK40(-25.877,45.088) CK41(-26.527,45.088) CK42(-27.177,45.088) CK43(-27.827,45.088) CK44(-28.477,45.088) CK45(-29.128,45.088) CK46(-29.778,45.088) CL1(0,45.606) CL2(-0.65,45.606) CL3(-1.3,45.606) CL4(-1.951,45.606) CL5(-2.601,45.606) CL6(-3.251,45.606) CL7(-3.911,45.678) CL8(-4.561,45.678) CL9(-5.212,45.678) CL10(-5.862,45.678) CL35(-22.625,45.876) CL36(-23.276,45.876) CL37(-23.926,45.876) CL38(-24.576,45.876) CL39(-25.226,45.876) CL40(-25.877,45.876) CL41(-26.527,45.876) CL42(-27.177,45.876) CL43(-27.827,45.876) CL44(-28.477,45.876) CL45(-29.128,45.876) CL46(-29.778,45.876) CM1(0,46.343) CM2(-0.65,46.343) CM3(-1.3,46.343) CM4(-1.951,46.343) CM5(-2.601,46.343) CM6(-3.251,46.343) CM7(-3.911,46.593) CM8(-4.561,46.593) CM9(-5.212,46.593) CM10(-5.862,46.593) CM35(-22.625,46.663) CM36(-23.276,46.663) CM37(-23.926,46.663) CM38(-24.576,46.663) CM39(-25.226,46.663) CM40(-25.877,46.663) CM41(-26.527,46.663) CM42(-27.177,46.663) CM43(-27.827,46.663) CM44(-28.477,46.663) CM45(-29.128,46.663) CM46(-29.778,46.663) CN1(0,47.232) CN2(-0.65,47.232) CN3(-1.3,47.232) CN4(-1.951,47.232) CN5(-2.601,47.232) CN6(-3.251,47.232) CN7(-3.911,47.507) CN8(-4.561,47.507) CN9(-5.212,47.507) CN10(-5.862,47.507) CN35(-22.625,47.451) CN36(-23.276,47.451) CN37(-23.926,47.451) CN38(-24.576,47.451) CN39(-25.226,47.451) CN40(-25.877,47.451) CN41(-26.527,47.451) CN42(-27.177,47.451) CN43(-27.827,47.451) CN44(-28.477,47.451) CN45(-29.128,47.451) CN46(-29.778,47.451) CP1(0,48.121) CP2(-0.65,48.121) CP3(-1.3,48.121) CP4(-1.951,48.121) CP5(-2.601,48.121) CP6(-3.251,48.121) CR7(-3.911,48.422) CR8(-4.561,48.422) CR9(-5.212,48.422) CR10(-5.862,48.422) CR35(-22.625,48.238) CR36(-23.276,48.238) CR37(-23.926,48.238) CR38(-24.576,48.238) CR39(-25.226,48.238) CR40(-25.877,48.238) CR41(-26.527,48.238) CR42(-27.177,48.238) CR43(-27.827,48.238) CR44(-28.477,48.238) CR45(-29.128,48.238) CR46(-29.778,48.238) CT1(0,48.858) CT2(-0.65,48.858) CT3(-1.3,48.858) CT4(-1.951,48.858) CT5(-2.601,48.858) CT6(-3.251,48.858) CT7(-3.911,49.336) CT8(-4.561,49.336) CT9(-5.212,49.336) CT10(-5.862,49.336) CT35(-22.625,49.025) CT36(-23.276,49.025) CT37(-23.926,49.025) CT38(-24.576,49.025) CT39(-25.226,49.025) CT40(-25.877,49.025) CT41(-26.527,49.025) CT42(-27.177,49.025) CT43(-27.827,49.025) CT44(-28.477,49.025) CT45(-29.128,49.025) CT46(-29.778,49.025) CU1(0,49.747) CU2(-0.65,49.747) CU3(-1.3,49.747) CU4(-1.951,49.747) CU5(-2.601,49.747) CU6(-3.251,49.747) CU35(-22.625,49.813) CU36(-23.276,49.813) CU37(-23.926,49.813) CU38(-24.576,49.813) CU39(-25.226,49.813) CU40(-25.877,49.813) CU41(-26.527,49.813) CU42(-27.177,49.813) CU43(-27.827,49.813) CU44(-28.477,49.813) CU45(-29.128,49.813) CU46(-29.778,49.813) CV1(0,50.636) CV2(-0.65,50.636) CV3(-1.3,50.636) CV4(-1.951,50.636) CV5(-2.601,50.636) CV6(-3.251,50.636) CV7(-3.911,50.25) CV8(-4.561,50.25) CV9(-5.212,50.25) CV10(-5.862,50.25) CV35(-22.625,50.6) CV36(-23.276,50.6) CV37(-23.926,50.6) CV38(-24.576,50.6) CV39(-25.226,50.6) CV40(-25.877,50.6) CV41(-26.527,50.6) CV42(-27.177,50.6) CV43(-27.827,50.6) CV44(-28.477,50.6) CV45(-29.128,50.6) CV46(-29.778,50.6) CW1(0,51.372) CW2(-0.65,51.372) CW3(-1.3,51.372) CW4(-1.951,51.372) CW5(-2.601,51.372) CW6(-3.251,51.372) CW7(-3.911,51.165) CW8(-4.561,51.165) CW9(-5.212,51.165) CW10(-5.862,51.165) CW35(-22.625,51.388) CW36(-23.276,51.388) CW37(-23.926,51.388) CW38(-24.576,51.388) CW39(-25.226,51.388) CW40(-25.877,51.388) CW41(-26.527,51.388) CW42(-27.177,51.388) CW43(-27.827,51.388) CW44(-28.477,51.388) CW45(-29.128,51.388) CW46(-29.778,51.388) CY7(-3.911,52.079) CY8(-4.561,52.079) CY9(-5.212,52.079) CY10(-5.862,52.079) D4(-2.057,1.948) D5(-2.743,1.951) D6(-3.531,1.951) D7(-4.318,1.951) D9(-5.105,1.951) D10(-5.893,1.951) D11(-6.68,1.951) D12(-7.468,1.951) D13(-8.255,1.951) D15(-9.042,1.951) D16(-9.83,1.951) D17(-10.617,1.951) D18(-11.405,1.951) D20(-12.192,1.951) D21(-12.979,1.951) D22(-13.767,1.951) D23(-14.554,1.951) D24(-15.342,1.951) D25(-16.129,1.951) D26(-16.916,1.951) D28(-17.704,1.951) D29(-18.491,1.951) D30(-19.279,1.951) D31(-20.066,1.951) D32(-20.853,1.951) D34(-21.641,1.951) D35(-22.428,1.951) D36(-23.216,1.951) D37(-24.003,1.951) D39(-24.79,1.951) D40(-25.578,1.951) D41(-26.365,1.951) D42(-27.153,1.951) DA1(0,52.515) DA2(-0.65,52.261) DA3(-1.3,52.261) DA4(-1.951,52.261) DA5(-2.601,52.261) DA6(-3.251,52.261) DA35(-22.625,52.175) DA36(-23.276,52.175) DA37(-23.926,52.175) DA38(-24.576,52.175) DA39(-25.226,52.175) DA40(-25.877,52.175) DA41(-26.527,52.175) DA42(-27.177,52.175) DA43(-27.827,52.175) DA44(-28.477,52.175) DA45(-29.128,52.175) DA46(-29.778,52.175) DB2(-0.65,53.099) DB3(-1.3,53.099) DB4(-1.951,53.099) DB5(-2.601,53.099) DB6(-3.251,53.099) DB7(-3.911,52.994) DB8(-4.561,52.994) DB9(-5.212,52.994) DB10(-5.862,52.994) DB35(-22.625,52.962) DB36(-23.276,52.962) DB37(-23.926,52.962) DB38(-24.576,52.962) DB39(-25.226,52.962) DB40(-25.877,52.962) DB41(-26.527,52.962) DB42(-27.177,52.962) DB43(-27.827,52.962) DB44(-28.477,52.962) DB45(-29.128,52.962) DB46(-29.778,52.912) DC2(-0.65,53.938) DC3(-1.3,53.887) DC4(-1.951,53.887) DC5(-2.601,53.887) DC6(-3.251,53.887) DC7(-3.987,53.883) DC8(-4.876,53.877) DC9(-5.664,53.877) DC11(-6.451,53.877) DC12(-7.238,53.877) DC13(-8.026,53.877) DC14(-8.813,53.877) DC16(-9.601,53.877) DC17(-10.388,53.877) DC18(-11.175,53.877) DC19(-11.963,53.877) DC20(-12.75,53.877) DC22(-13.538,53.877) DC23(-14.325,53.877) DC24(-15.112,53.877) DC25(-15.9,53.877) DC26(-16.687,53.877) DC27(-17.475,53.877) DC28(-18.262,53.877) DC30(-19.049,53.877) DC31(-19.837,53.877) DC32(-20.624,53.877) DC33(-21.412,53.877) DC35(-22.199,53.877) DC36(-22.986,53.877) DC37(-23.774,53.877) DC38(-24.576,53.75) DC39(-25.226,53.75) DC40(-25.877,53.75) DC41(-26.527,53.75) DC42(-27.177,53.75) DC43(-27.827,53.75) DC44(-28.477,53.75) DC45(-29.128,53.75) DD2(-0.963,54.552) DD3(-1.613,54.629) DD5(-2.525,54.629) DD7(-4.089,54.527) DD8(-4.876,54.527) DD9(-5.664,54.527) DD11(-6.451,54.527) DD12(-7.238,54.527) DD13(-8.026,54.527) DD14(-8.813,54.527) DD16(-9.601,54.527) DD17(-10.388,54.527) DD18(-11.175,54.527) DD19(-11.963,54.527) DD20(-12.75,54.527) DD22(-13.538,54.527) DD23(-14.325,54.527) DD24(-15.112,54.527) DD25(-15.9,54.527) DD26(-16.687,54.527) DD27(-17.475,54.527) DD28(-18.262,54.527) DD30(-19.049,54.527) DD31(-19.837,54.527) DD32(-20.624,54.527) DD33(-21.412,54.527) DD35(-22.199,54.527) DD36(-22.986,54.527) DD37(-23.774,54.527) DD38(-24.561,54.527) DD39(-25.349,54.527) DD41(-26.136,54.527) DD42(-26.923,54.527) DD43(-27.711,54.527) DD44(-28.477,54.486) DD45(-29.128,54.486) DE3(-1.3,55.201) DE4(-2.106,55.129) DE5(-2.748,55.292) DE6(-3.169,54.73) DE7(-4.089,55.177) DE8(-4.876,55.177) DE9(-5.664,55.177) DE11(-6.451,55.177) DE12(-7.238,55.177) DE13(-8.026,55.177) DE14(-8.813,55.177) DE16(-9.601,55.177) DE17(-10.388,55.177) DE18(-11.175,55.177) DE19(-11.963,55.177) DE20(-12.75,55.177) DE22(-13.538,55.177) DE23(-14.325,55.177) DE24(-15.112,55.177) DE25(-15.9,55.177) DE26(-16.687,55.177) DE27(-17.475,55.177) DE28(-18.262,55.177) DE30(-19.049,55.177) DE31(-19.837,55.177) DE32(-20.624,55.177) DE33(-21.412,55.177) DE35(-22.199,55.177) DE36(-22.986,55.177) DE37(-23.774,55.177) DE38(-24.561,55.177) DE39(-25.349,55.177) DE41(-26.136,55.177) DE42(-26.923,55.177) DE43(-27.711,55.177) DE44(-28.463,55.138) DF3(-1.483,55.834) DF4(-2.374,55.851) DF6(-3.294,55.788) DF7(-4.089,55.828) DF8(-4.876,55.828) DF9(-5.664,55.828) DF11(-6.451,55.828) DF12(-7.238,55.828) DF13(-8.026,55.828) DF14(-8.813,55.828) DF16(-9.601,55.828) DF17(-10.388,55.828) DF18(-11.175,55.828) DF19(-11.963,55.828) DF20(-12.75,55.828) DF22(-13.538,55.828) DF23(-14.325,55.828) DF24(-15.112,55.828) DF25(-15.9,55.828) DF26(-16.687,55.828) DF27(-17.475,55.828) DF28(-18.262,55.828) DF30(-19.049,55.828) DF31(-19.837,55.828) DF32(-20.624,55.828) DF33(-21.412,55.828) DF35(-22.199,55.828) DF36(-22.986,55.828) DF37(-23.774,55.828) DF38(-24.561,55.828) DF39(-25.349,55.828) DF41(-26.136,55.828) DF42(-26.923,55.828) DF43(-27.711,55.828) DG6(-3.192,56.461) DG7(-4.089,56.478) DG8(-4.876,56.478) DG9(-5.664,56.478) DG11(-6.451,56.478) DG12(-7.238,56.478) DG13(-8.026,56.478) DG14(-8.813,56.478) DG16(-9.601,56.478) DG17(-10.388,56.478) DG18(-11.175,56.478) DG19(-11.963,56.478) DG20(-12.75,56.478) DG22(-13.538,56.478) DG23(-14.325,56.478) DG24(-15.112,56.478) DG25(-15.9,56.478) DG26(-16.687,56.478) DG27(-17.475,56.478) DG28(-18.262,56.478) DG30(-19.049,56.478) DG31(-19.837,56.478) DG32(-20.624,56.478) DG33(-21.412,56.478) DG35(-22.199,56.478) DG36(-22.986,56.478) DG37(-23.774,56.478) DG38(-24.561,56.478) DG39(-25.349,56.478) DG41(-26.136,56.478) DG42(-26.923,56.478) DH8(-4.648,57.128) DH9(-5.664,57.128) DH11(-6.451,57.128) DH12(-7.238,57.128) DH13(-8.026,57.128) DH14(-8.813,57.128) DH16(-9.601,57.128) DH17(-10.388,57.128) DH18(-11.175,57.128) DH19(-11.963,57.128) DH20(-12.75,57.128) DH22(-13.538,57.128) DH23(-14.325,57.128) DH24(-15.112,57.128) DH25(-15.9,57.128) DH26(-16.687,57.128) DH27(-17.475,57.128) DH28(-18.262,57.128) DH30(-19.049,57.128) DH31(-19.837,57.128) DH32(-20.624,57.128) DH33(-21.412,57.128) DH35(-22.199,57.128) DH36(-22.986,57.128) DH37(-23.774,57.128) DH38(-24.561,57.128) DH39(-25.323,57.128) E2(-0.65,2.495) E3(-1.3,2.495) E4(-2.057,2.598) E5(-2.743,2.601) E6(-3.531,2.601) E7(-4.318,2.601) E9(-5.105,2.601) E10(-5.893,2.601) E11(-6.68,2.601) E12(-7.468,2.601) E13(-8.255,2.601) E15(-9.042,2.601) E16(-9.83,2.601) E17(-10.617,2.601) E18(-11.405,2.601) E20(-12.192,2.601) E21(-12.979,2.601) E22(-13.767,2.601) E23(-14.554,2.601) E24(-15.342,2.601) E25(-16.129,2.601) E26(-16.916,2.601) E28(-17.704,2.601) E29(-18.491,2.601) E30(-19.279,2.601) E31(-20.066,2.601) E32(-20.853,2.601) E34(-21.641,2.601) E35(-22.428,2.601) E36(-23.216,2.601) E37(-24.003,2.601) E39(-24.79,2.601) E40(-25.578,2.601) E41(-26.365,2.601) E42(-27.153,2.601) E43(-27.827,2.569) E44(-28.477,2.569) E45(-29.128,2.569) F2(-0.65,3.239) F3(-1.3,3.239) F4(-1.951,3.239) F5(-2.601,3.239) F6(-3.251,3.239) F7(-4.318,3.251) F9(-5.105,3.251) F10(-5.893,3.251) F11(-6.68,3.251) F12(-7.468,3.251) F13(-8.255,3.251) F15(-9.042,3.251) F16(-9.83,3.251) F17(-10.617,3.251) F18(-11.405,3.251) F20(-12.192,3.251) F21(-12.979,3.251) F22(-13.767,3.251) F23(-14.554,3.251) F24(-15.342,3.251) F25(-16.129,3.251) F26(-16.916,3.251) F28(-17.704,3.251) F29(-18.491,3.251) F30(-19.279,3.251) F31(-20.066,3.251) F32(-20.853,3.251) F34(-21.641,3.251) F35(-22.428,3.251) F36(-23.216,3.251) F37(-24.003,3.251) F39(-24.79,3.251) F40(-25.578,3.251) F41(-26.365,3.251) F42(-27.177,3.356) F43(-27.827,3.356) F44(-28.477,3.356) F45(-29.128,3.356) G1(0,4.027) G2(-0.65,4.027) G3(-1.3,4.027) G4(-1.951,4.027) G5(-2.601,4.027) G6(-3.251,4.027) G7(-3.911,3.946) G8(-4.561,3.946) G9(-5.212,3.921) G10(-5.862,3.921) G11(-6.512,3.921) G12(-7.162,3.921) G13(-7.813,3.921) G14(-8.463,3.921) G15(-9.113,3.921) G16(-9.83,3.901) G17(-10.617,3.901) G18(-11.405,3.901) G20(-12.192,3.901) G21(-12.979,3.901) G22(-13.767,3.901) G23(-14.554,3.901) G24(-15.342,3.901) G25(-16.129,3.901) G26(-16.916,3.901) G28(-17.704,3.901) G29(-18.491,3.901) G30(-19.279,3.901) G31(-20.066,3.901) G32(-20.853,3.901) G34(-21.641,3.901) G35(-22.428,3.901) G36(-23.216,3.901) G37(-24.003,3.901) G39(-24.79,3.901) G40(-25.877,4.144) G41(-26.527,4.144) G42(-27.177,4.144) G43(-27.827,4.144) G44(-28.477,4.144) G45(-29.128,4.144) H1(0,4.814) H2(-0.65,4.814) H3(-1.3,4.814) H4(-1.951,4.814) H5(-2.601,4.814) H6(-3.251,4.814) H7(-3.911,4.861) H8(-4.561,4.861) H9(-5.212,4.835) H10(-5.862,4.835) H11(-6.512,4.835) H12(-7.162,4.835) H16(-9.83,4.552) H17(-10.617,4.552) H18(-11.405,4.552) H20(-12.192,4.552) H21(-12.979,4.552) H22(-13.767,4.552) H23(-14.554,4.552) H24(-15.342,4.552) H25(-16.129,4.552) H26(-16.916,4.552) H28(-17.704,4.552) H29(-18.491,4.552) H30(-19.279,4.552) H31(-20.066,4.552) H32(-20.853,4.552) H34(-21.641,4.552) H35(-22.428,4.552) H36(-23.216,4.552) H39(-25.226,4.931) H40(-25.877,4.931) H41(-26.527,4.931) H42(-27.177,4.931) H43(-27.827,4.931) H44(-28.477,4.931) H45(-29.128,4.931) H46(-29.778,4.931) J1(0,5.601) J2(-0.65,5.601) J3(-1.3,5.601) J4(-1.951,5.601) J5(-2.601,5.601) J6(-3.251,5.601) K7(-3.911,5.775) K8(-4.561,5.775) K9(-5.212,5.75) K10(-5.862,5.75) K11(-6.512,5.75) K12(-7.162,5.75) K39(-25.226,5.718) K40(-25.877,5.718) K41(-26.527,5.718) K42(-27.177,5.718) K43(-27.827,5.718) K44(-28.477,5.718) K45(-29.128,5.718) K46(-29.778,5.718) L1(0,6.389) L2(-0.65,6.389) L3(-1.3,6.389) L4(-1.951,6.389) L5(-2.601,6.389) L6(-3.251,6.389) L7(-3.911,6.689) L8(-4.561,6.689) L9(-5.212,6.664) L10(-5.862,6.664) L11(-6.512,6.664) L12(-7.162,6.664) L39(-25.226,6.506) L40(-25.877,6.506) L41(-26.527,6.506) L42(-27.177,6.506) L43(-27.827,6.506) L44(-28.477,6.506) L45(-29.128,6.506) L46(-29.778,6.506) M1(0,7.176) M2(-0.65,7.176) M3(-1.3,7.176) M4(-1.951,7.176) M5(-2.601,7.176) M6(-3.251,7.176) M7(-3.911,7.604) M8(-4.561,7.604) M9(-5.212,7.578) M10(-5.862,7.578) M11(-6.512,7.578) M12(-7.162,7.578) M39(-25.226,7.293) M40(-25.877,7.293) M41(-26.527,7.293) M42(-27.177,7.293) M43(-27.827,7.293) M44(-28.477,7.293) M45(-29.128,7.293) M46(-29.778,7.293) N1(0,7.964) N2(-0.65,7.964) N3(-1.3,7.964) N4(-1.951,7.964) N5(-2.601,7.964) N6(-3.251,7.964) N39(-25.226,8.081) N40(-25.877,8.081) N41(-26.527,8.081) N42(-27.177,8.081) N43(-27.827,8.081) N44(-28.477,8.081) N45(-29.128,8.081) N46(-29.778,8.081) P1(0,8.751) P2(-0.65,8.751) P3(-1.3,8.751) P4(-1.951,8.751) P5(-2.601,8.751) P6(-3.251,8.751) P7(-3.911,8.518) P8(-4.561,8.518) P9(-5.212,8.493) P10(-5.862,8.493) P11(-6.512,8.493) P12(-7.162,8.493) P39(-25.226,8.868) P40(-25.877,8.868) P41(-26.527,8.868) P42(-27.177,8.868) P43(-27.827,8.868) P44(-28.477,8.868) P45(-29.128,8.868) P46(-29.778,8.868) R1(0,9.538) R2(-0.65,9.538) R3(-1.3,9.538) R4(-1.951,9.538) R5(-2.601,9.538) R6(-3.251,9.538) R7(-3.911,9.433) R8(-4.561,9.433) R9(-5.212,9.407) R10(-5.862,9.407) R11(-6.512,9.407) R12(-7.162,9.407) T39(-25.226,9.655) T40(-25.877,9.655) T41(-26.527,9.655) T42(-27.177,9.655) T43(-27.827,9.655) T44(-28.477,9.655) T45(-29.128,9.655) T46(-29.778,9.655) U1(0,10.326) U2(-0.65,10.326) U3(-1.3,10.326) U4(-1.951,10.326) U5(-2.601,10.326) U6(-3.251,10.326) U7(-3.911,10.347) U8(-4.561,10.347) U9(-5.212,10.322) U10(-5.862,10.322) U11(-6.512,10.322) U12(-7.162,10.322) U39(-25.226,10.443) U40(-25.877,10.443) U41(-26.527,10.443) U42(-27.177,10.443) U43(-27.827,10.443) U44(-28.477,10.443) U45(-29.128,10.443) U46(-29.778,10.443) V1(0,11.113) V2(-0.65,11.113) V3(-1.3,11.113) V4(-1.951,11.113) V5(-2.601,11.113) V6(-3.251,11.113) V7(-3.911,11.261) V8(-4.561,11.261) V9(-5.212,11.236) V10(-5.862,11.236) V11(-6.512,11.236) V12(-7.162,11.236) V39(-25.226,11.23) V40(-25.877,11.23) V41(-26.527,11.23) V42(-27.177,11.23) V43(-27.827,11.23) V44(-28.477,11.23) V45(-29.128,11.23) V46(-29.778,11.23) W1(0,11.901) W2(-0.65,11.901) W3(-1.3,11.901) W4(-1.951,11.901) W5(-2.601,11.901) W6(-3.251,11.901) W7(-3.911,12.176) W8(-4.561,12.176) W9(-5.212,12.15) W10(-5.862,12.15) W11(-6.512,12.15) W12(-7.162,12.15) W39(-25.226,12.018) W40(-25.877,12.018) W41(-26.527,12.018) W42(-27.177,12.018) W43(-27.827,12.018) W44(-28.477,12.018) W45(-29.128,12.018) W46(-29.778,12.018) Y1(0,12.688) Y2(-0.65,12.688) Y3(-1.3,12.688) Y4(-1.951,12.688) Y5(-2.601,12.688) Y6(-3.251,12.688) Y39(-25.226,12.805) Y40(-25.877,12.805) Y41(-26.527,12.805) Y42(-27.177,12.805) Y43(-27.827,12.805) Y44(-28.477,12.805) Y45(-29.128,12.805) Y46(-29.778,12.805)
  round 0.356 smd: A42(-26.809,0) DD1(0,54.314) DD46(-29.778,54.387) DG3(-1.387,56.478) DH42(-26.847,57.128) E46(-29.778,2.897)
  round 0.381 smd: AA16(-9.763,13.065) AB16(-9.763,13.979) AB37(-23.871,13.592) AB38(-24.521,13.592) AC37(-23.871,14.38) AC38(-24.521,14.38) AD16(-9.763,15.046) AD37(-23.871,15.167) AD38(-24.521,15.167) AE16(-9.763,15.96) AE37(-23.871,15.955) AE38(-24.521,15.955) AG16(-9.763,17.027) AG37(-23.871,16.742) AG38(-24.521,16.742) AH16(-9.763,17.942) AH37(-23.871,17.529) AH38(-24.521,17.529) AJ37(-23.871,18.317) AJ38(-24.521,18.317) AK16(-9.763,19.008) AK37(-23.871,19.104) AK38(-24.521,19.104) AL16(-9.763,19.923) AL37(-23.871,19.892) AL38(-24.521,19.892) AN16(-9.763,20.99) AN37(-23.871,20.679) AN38(-24.521,20.679) AP16(-9.763,21.904) AP37(-23.871,21.466) AP38(-24.521,21.466) AR37(-23.871,22.254) AR38(-24.521,22.254) AT16(-9.763,22.818) AT37(-23.871,23.041) AT38(-24.521,23.041) AU16(-9.763,23.733) AU37(-23.871,23.829) AU38(-24.521,23.829) AV16(-9.763,24.647) AV37(-23.871,24.616) AV38(-24.521,24.616) AW16(-9.763,25.562) AW37(-23.871,25.403) AW38(-24.521,25.403) AY16(-9.763,26.476) AY37(-23.871,26.191) AY38(-24.521,26.191) BA37(-23.871,26.978) BA38(-24.521,26.978) BB16(-9.763,27.39) BC14(-8.563,28.305) BC15(-9.47,28.128) BC16(-10.12,28.128) BC17(-10.77,28.128) BC18(-11.42,28.128) BC19(-12.071,28.128) BC20(-12.721,28.128) BC21(-13.371,28.128) BC22(-14.021,28.128) BC23(-14.672,28.128) BC24(-15.322,28.128) BC25(-15.972,28.128) BC26(-16.622,28.128) BC27(-17.273,28.128) BC28(-17.923,28.128) BC29(-18.573,28.128) BC30(-19.223,28.128) BC31(-19.873,28.128) BC32(-20.524,28.128) BC33(-21.174,28.128) BC34(-21.824,28.128) BC35(-22.474,28.128) BC36(-23.125,28.128) BC37(-23.775,28.128) BC38(-24.425,28.128) BM15(-9.47,33.791) BM16(-10.12,33.791) BM17(-10.77,33.791) BM18(-11.42,33.791) BM19(-12.071,33.791) BM20(-12.721,33.791) BM21(-13.371,33.791) BM22(-14.021,33.791) BM23(-14.672,33.791) BM24(-15.322,33.791) BM25(-15.972,33.791) BM26(-16.622,33.791) BM27(-17.273,33.791) BM28(-17.923,33.791) BM29(-18.573,33.791) BM30(-19.223,33.791) BM31(-19.873,33.791) BM32(-20.524,33.791) BM33(-21.174,33.791) BM34(-21.824,33.791) BM35(-22.474,33.791) BP33(-21.274,34.852) BP34(-21.924,34.852) BR13(-7.813,35.62) BR14(-8.463,35.62) BR33(-21.274,35.64) BR34(-21.924,35.64) BT33(-21.274,36.427) BT34(-21.924,36.427) BU13(-7.813,36.534) BU14(-8.463,36.534) BV13(-7.813,37.449) BV14(-8.463,37.449) BV33(-21.274,37.214) BV34(-21.924,37.214) BW13(-7.813,38.363) BW14(-8.463,38.363) BW33(-21.274,38.002) BW34(-21.924,38.002) BY33(-21.274,38.789) BY34(-21.924,38.789) CA13(-7.813,39.278) CA14(-8.463,39.278) CA33(-21.274,39.577) CA34(-21.924,39.577) CB13(-7.813,40.192) CB14(-8.463,40.192) CB33(-21.274,40.364) CB34(-21.924,40.364) CD13(-7.813,41.106) CD14(-8.463,41.106) CD33(-21.274,41.151) CD34(-21.924,41.151) CE13(-7.813,42.021) CE14(-8.463,42.021) CE33(-21.274,41.939) CE34(-21.924,41.939) CF13(-7.813,42.935) CF14(-8.463,42.935) CF33(-21.274,42.726) CF34(-21.924,42.726) CG33(-21.274,43.514) CG34(-21.924,43.514) CH13(-7.813,43.85) CH14(-8.463,43.85) CJ13(-7.813,44.764) CJ14(-8.463,44.764) CJ33(-21.274,44.301) CJ34(-21.924,44.301) CK33(-21.274,45.088) CK34(-21.924,45.088) CL13(-7.813,45.678) CL14(-8.463,45.678) CL33(-21.274,45.876) CL34(-21.924,45.876) CM13(-7.813,46.593) CM14(-8.463,46.593) CM33(-21.274,46.663) CM34(-21.924,46.663) CN13(-7.813,47.507) CN14(-8.463,47.507) CN33(-21.274,47.451) CN34(-21.924,47.451) CR13(-7.813,48.422) CR14(-8.463,48.422) CR33(-21.274,48.238) CR34(-21.924,48.238) CT13(-7.813,49.336) CT14(-8.463,49.336) CT33(-21.274,49.025) CT34(-21.924,49.025) CU33(-21.274,49.813) CU34(-21.924,49.813) CV13(-7.813,50.25) CV14(-8.463,50.25) CV33(-21.274,50.6) CV34(-21.924,50.6) CW13(-7.813,51.165) CW14(-8.463,51.165) CW33(-21.274,51.388) CW34(-21.924,51.388) CY13(-7.813,52.079) CY14(-8.463,52.041) DA13(-8.171,52.625) DA14(-8.851,52.576) DA16(-9.601,52.576) DA17(-10.388,52.576) DA18(-11.175,52.576) DA19(-11.963,52.576) DA20(-12.75,52.576) DA22(-13.538,52.576) DA23(-14.325,52.576) DA24(-15.112,52.576) DA25(-15.9,52.576) DA26(-16.687,52.576) DA27(-17.475,52.576) DA28(-18.262,52.576) DA30(-19.049,52.576) DA31(-19.837,52.576) DA32(-20.624,52.576) DA33(-21.274,52.175) DA34(-21.924,52.175) DB33(-21.274,52.962) DB34(-21.924,52.962) H37(-23.871,4.931) H38(-24.521,4.931) J17(-10.617,5.257) J18(-11.405,5.257) J20(-12.192,5.257) J21(-12.979,5.257) J22(-13.767,5.257) J23(-14.554,5.257) J24(-15.342,5.257) J25(-16.129,5.257) J26(-16.916,5.257) J28(-17.704,5.257) J29(-18.491,5.257) J30(-19.279,5.257) J31(-20.066,5.257) J32(-20.853,5.257) J34(-21.641,5.257) J35(-22.428,5.257) J36(-23.216,5.257) K16(-9.863,5.75) K17(-10.617,6.117) K18(-11.405,6.017) K20(-12.192,6.017) K21(-12.979,6.017) K22(-13.767,6.017) K23(-14.554,6.017) K24(-15.342,6.017) K25(-16.129,6.017) K26(-16.916,6.017) K28(-17.704,6.017) K29(-18.491,6.017) K30(-19.279,6.017) K31(-20.066,6.017) K32(-20.853,6.017) K34(-21.641,6.017) K35(-22.428,6.017) K36(-23.216,6.017) K37(-23.871,5.718) K38(-24.521,5.718) L16(-9.863,6.664) L37(-23.871,6.506) L38(-24.521,6.506) M16(-9.763,7.578) M37(-23.871,7.293) M38(-24.521,7.293) N37(-23.871,8.081) N38(-24.521,8.081) P16(-9.763,8.493) P37(-23.871,8.868) P38(-24.521,8.868) R16(-9.763,9.407) T37(-23.871,9.655) T38(-24.521,9.655) U16(-9.763,10.322) U37(-23.871,10.443) U38(-24.521,10.443) V16(-9.763,11.236) V37(-23.871,11.23) V38(-24.521,11.23) W16(-9.763,12.15) W37(-23.871,12.018) W38(-24.521,12.018) Y37(-23.871,12.805) Y38(-24.521,12.805)
