# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
JTAG_TDO: length 21.1
  TOP w0.122: v7(44.31,14.5) 44.31,14.04 44.75,13.59 UE3.F6
  GND2 w0.102: v7(44.31,14.5) 44.03,14.78 v5(43.91,14.78)
  GND3 w0.102: v8(44.23,15.08) 43.93,14.78 v5(43.91,14.78)
  IN3 w0.064: v8(44.23,15.08) 44.25,15.1 45.63,15.1 46.97,13.76 47.47,13.76 48.3,12.93 48.3,12.29 51.09,9.5 v3(51.09,8.59)
  BOTTOM w0.127: JDEG1.5 50.39,7.78 v16(50.67,8.06) 50.87,8.26 50.87,8.37 v3(51.09,8.59) 52.05,9.55 53.79,9.55 53.9,9.66 RPE7.4
JTAG_TMS: length 19.8
  GND2 w0.102: v7(43.95,15.79) 43.78,15.96 v5(43.67,15.96)
  GND3 w0.102: v8(43.99,16.21) 43.74,15.96 v5(43.67,15.96)
  IN3 w0.064: v8(43.99,16.21) 44.71,16.21 47.02,13.9 47.53,13.9 48.44,12.99 48.44,12.35 51.4,9.38 51.4,8.15 v3(51.54,8.02)
  BOTTOM w0.127: RPE7.2 52.81,8.66 v16(52.74,8.59) 52.54,8.39 51.91,8.39 v3(51.54,8.02) 51.39,7.87 JDEG1.3
KB_DET#: length 89
  TOP w0.127: v2(18.42,9.61) RH191.1 v16(20.74,5.61) 21.75,5.61 v2(22.58,6.43)
  IN1 w0.064: v4(33,57.99) 32.54,58.45 30.66,58.45 28.77,56.56 28.77,55.65 27.89,54.76 27.89,53.66 24.81,50.58 24.81,44.63 24.23,44.05 24.23,36.85 24.6,36.47 24.6,35.44 27.24,32.8 28.85,32.8 31.02,30.63 31.02,27.74 31.57,27.2 31.57,21.71 30.12,20.25 30.11,20.25 28.12,18.26 27.32,18.26 23.82,14.75 23.82,14.41 21.5,12.1 20.91,12.1 v2(18.42,9.61) ; v2(22.58,6.43) 22.78,6.23 35.59,6.23 v9(36.1,6.75)
  GND2 w0.102: v5(33.07,57.51) 33.07,57.92 v4(33,57.99)
  GND3 w0.102: v6(33.4,57.44) 33.14,57.44 v5(33.07,57.51)
  BOTTOM w0.076: UH4.AK45 33.24,57.2 33.24,57.27 v6(33.4,57.44)
  BOTTOM w0.127: v9(36.1,6.75) 35.92,6.93 JKB1.5
LAN_WAKE#: length 49.7
  TOP w0.127: RE275.2 35.37,8.51 35.72,8.86 v1(35.72,9.1) 35.4,9.42 35.02,9.42 34.83,9.61 34.83,10.1 34.32,10.61 34.32,10.76 34.02,11.07 34.02,11.5 v7(33.88,11.64)
  GND2 w0.102: v7(33.88,11.64) 33.88,11.99 v5(33.85,12.02)
  GND3 w0.102: v8(33.85,12.43) v5(33.85,12.02)
  IN3 w0.064: v3(23.4,41.1) 23.12,40.82 22.09,40.82 21.79,41.13 20.04,41.13 19.86,41.31 19.25,41.31 v3(19.2,41.26) 19.14,41.2 19.14,39.98 19.44,39.68 19.44,35.96 20.18,35.22 20.18,34.72 25.03,29.86 25.03,29.67 26.54,28.16 26.7,28.16 29.73,25.13 29.73,23.12 28.71,22.1 28.71,19.71 28.96,19.46 28.96,18.19 32.43,14.73 32.43,13.85 v8(33.85,12.43)
  BOTTOM w0.076: v3(23.4,41.1) 23.72,41.1 24.08,40.74 25.44,40.74 25.53,40.83 26.03,40.83 26.27,40.59 UH4.BD11
  BOTTOM w0.127: v3(19.2,41.26) 19.22,41.26 19.61,41.64 RH128.1
LAN_WAKE#_R: length 7.7
  TOP w0.127: v7(41.95,8.99) UE3.L3 ; v2(36,8.76) 35.95,8.71 RE275.1
  IN1 w0.064: v7(41.95,8.99) 41.18,8.22 38.3,8.22 37.82,8.7 37.09,8.7 36.9,8.9 36.14,8.9 v2(36,8.76)
LCD_DBC: length 9.3
  IN2 w0.074: v5(39.57,52.48) 39.57,53.24 38.91,53.9 38.91,54.16 38.33,54.74 38.33,55.15 38.63,55.45 38.63,56.04 38.1,56.57 v5(38.1,58.02)
  GND3 w0.102: v6(38.1,58.35) v5(38.1,58.02) ; v6(39.66,52.15) 39.66,52.39 v5(39.57,52.48)
  BOTTOM w0.076: 38.5,58.76 v6(38.1,58.35)
  BOTTOM w0.127: RH97.1 RH98.1 38.83,59.09 38.5,58.76
LCD_TST: length 161.4
  TOP w0.127: v2(58.17,100.24) 58.63,100.24 59.31,99.56 59.31,94.42 59.47,94.25 59.47,94.06 v1(59.34,93.94) 59.28,93.87 58.98,93.87 RV788.1 ; UE3.M2 41.55,8.58 41.12,8.15 41.12,7.66 v7(39.09,5.63) RE160.1
  IN1 w0.064: v4(40.75,90.98) 40.75,92.04 40.59,92.21 40.59,93.33 41.04,93.78 41.04,97.07 42.74,98.77 48.01,98.77 49.48,100.24 v2(58.17,100.24) ; v4(37.56,74.22) 37.56,74.07 37.25,73.76 35.3,73.76 34,72.45 31.94,72.45 31.61,72.12 28.56,72.12 26.29,69.85 26.29,67.17 25.03,65.92 25.03,63.28 25.24,63.07 25.24,61.86 21.77,58.39 20.61,58.39 17.78,55.56 17.78,53.66 16.74,52.62 16.74,46.89 16.4,46.55 16.4,39.1 16.8,38.7 16.8,38.31 16.15,37.66 16.15,34.12 v4(16.53,33.74)
  GND2 w0.102: v5(16.15,33.61) 16.4,33.61 v4(16.53,33.74) ; v5(40.98,90.36) 40.75,90.59 v4(40.75,90.98) ; v5(37.89,74) 37.79,74 v4(37.56,74.22) ; v7(39.09,5.63) 38.9,5.63 v5(38.77,5.76)
  IN2 w0.074: v5(37.89,74) 39.39,74 41.06,75.67 43.73,75.67 44.75,76.7 44.75,84.76 43.07,86.44 43.07,88.54 41.25,90.36 v5(40.98,90.36)
  GND3 w0.102: v5(38.77,5.76) 38.55,5.54 v8(38.52,5.54) ; v5(16.15,33.61) 16.15,33.58 16.1,33.53 16.1,33.2 v8(16.15,33.15)
  IN3 w0.064: v8(38.52,5.54) 37.81,6.25 33.92,6.25 32.37,7.8 29.38,7.8 25.8,11.37 25.26,11.37 22.98,13.65 22.98,14.33 19.96,17.35 19.96,23.73 14.94,28.75 14.94,32.78 15.29,33.13 16.13,33.13 v8(16.15,33.15)
LCD_VCC_TEST_EN: length 136.6
  TOP w0.127: UE3.E1 40.5,14.45 39.56,14.45 39.32,14.2 36.81,14.2 v7(36.76,14.25)
  IN1 w0.064: v4(30.39,28.21) 30.05,28.21 29.43,28.83 29.43,32.03 28.79,32.66 27.18,32.66 24.46,35.39 24.46,36.42 24.09,36.79 24.09,44.11 24.67,44.69 24.67,50.63 27.74,53.7 27.74,54.85 28.61,55.72 28.61,56.63 30.67,58.69 32.34,58.69 33.23,59.58 36.22,59.58 37.41,60.77 38.34,60.77 39.72,62.15 39.96,62.39 39.96,62.92 41.77,64.73 41.77,69.47 43.17,70.86 43.17,72.37 44.26,73.46 44.26,85.18 43.19,86.25 43.19,91.08 42.34,91.93 42.34,96.57 43.2,97.42 52.39,97.42 53.06,98.09 58.54,98.09 58.98,97.66 66.02,97.66 v4(68.36,95.32)
  GND2 w0.102: v5(68.6,95.02) 68.36,95.27 v4(68.36,95.32) ; v4(30.39,28.21) 30.39,28.09 v5(30.55,27.92) ; v7(36.76,14.25) 36.74,14.23 36.42,14.23 v5(36.37,14.18)
  GND3 w0.102: v6(68.92,94.7) v5(68.6,95.02) ; v8(30.83,27.7) 30.61,27.92 v5(30.55,27.92) ; v5(36.37,14.18) v8(36.37,14.56)
  IN3 w0.064: v8(30.83,27.7) 32.12,26.42 32.12,21.75 33.23,20.64 33.23,19.01 36.37,15.87 v8(36.37,14.56)
  BOTTOM w0.127: v1(68.07,95.23) 68.39,95.23 v6(68.92,94.7) 69.17,94.7 69.69,94.18 DV4.2
LDO_1VALWP: length 2.3
  BOTTOM w0.127: PC711.1 13.18,48.47 13.71,47.94 14.53,47.94 v1(15.03,48.44)
LDO_+0.95VSP:
  vias: v1(104.43,31.26)
LDO_IN: length 6.4
  BOTTOM w0.127: v1(49.31,62.69) 48.61,62.69 48.31,63 PD308.1
  BOTTOM w0.254: PU300.1 46.65,66.03 45.92,66.76 44.68,66.76 43.6,67.84 PR363.1
LDO_VDD08: length 1.1
  BOTTOM w0.127: PC3269.1 152.26,87.95 v1(152.7,88.38)
LID_CL_SIO#: length 8.1
  TOP w0.127: UE3.N11 48.75,7.44 49.22,6.97 49.22,6.15 49.34,6.02 50.29,6.02 50.52,5.8 RE259.2 50.73,5.2 50.86,5.07 50.86,4.18 51.6,3.45 51.6,2.24 51.84,2 v16(52.2,2)
LID_CL_SIO_TAB#: length 8.9
  IN1 w0.064: v2(55.3,10.88) 55.3,11.62 54.13,12.8 54.13,13.5 53.59,14.05 51.95,14.05 51.63,14.36 51.63,14.78 51.43,14.98 50.82,14.98 50.63,14.79 50.15,14.79 v2(49.55,14.19)
LOOP_BACK_OUT#: length 5.1
  BOTTOM w0.127: v1(116.56,15.96) 116.87,15.64 R1.2 115.93,15.12 115.65,15.4 113.56,15.4 JIO1.E2
LX_1VALWP: length 2.3
  TOP w0.508: PR700.1 11.22,47.88 v1(9.62,47.88) v9(9.04,47.88)
  vias: v3(8.57,48.13) v3(8.58,47.82) v3(8.57,47.49) v3(8.95,52.7) v3(8.95,52.38) v3(8.95,52.03) v3(9.23,52.52)
LX_+0.95VSP:
  vias: v1(102.71,34.18) v2(101.55,26.12) v2(101.57,25.84) v2(101.83,30.69) v2(101.83,30.36) v2(101.83,30.05) v2(101.9,26.12) v2(101.9,25.84) v2(102.16,30.69) v2(102.16,30.36) v2(102.16,30.03) v2(102.49,30.66) v2(102.49,30.33) v2(102.49,30.03) v2(102.82,30.66) v2(102.82,30.33) v2(102.82,30) v6(102.08,38.13) v6(102.43,38.46) v6(102.46,38.11) v6(102.84,38.46) v6(102.83,38.12) v9(102.26,36.91) v9(102.26,36.33) v9(102.26,35.74) v9(102.26,35.16) v9(102.84,36.91) v9(102.84,36.33) v9(102.84,35.74) v9(102.84,35.16) v9(103.43,36.91) v9(103.43,36.33) v9(103.43,35.74) v9(103.43,35.16)
LX_VDD08: length 2.2
  TOP w0.127: PR2328.1 v1(149.63,87.04)
  TOP w0.508: v9(150.47,85.39) 150.06,85.8 PR2328.1
  vias: v3(147.02,88.1) v3(147.34,88.09) v3(147.52,91.96) v3(147.52,91.64)
ME_EN: length 10.4
  TOP w0.127: SW1.2 2.63,15.79 1.9,15.07 1.9,8.32 v1(2.1,8.12) 2.17,8.06 RH156.1 RH157.1
ME_FWP: length 64.8
  TOP w0.127: v9(13.56,6.18) v1(13.56,6.69) ; SW1.3 2.63,18.79 v9(2.69,18.85) ; v7(49.15,11.89) 49.15,12.19 UE3.G12
  IN1 w0.064: v7(49.15,11.89) 49.09,11.84 48.27,11.84 48.15,11.71 47.81,11.71 47.03,10.93 46.85,10.93 46.32,10.4 46.32,9.66 45.01,8.35 45.01,7.6 44.27,6.86 43.73,6.86 42.22,5.35 36.67,5.35 36.41,5.09 22.14,5.09 20.83,6.41 13.78,6.41 v9(13.56,6.18)
  GND2 w0.102: v7(3.96,8.95) 3.93,8.95 v5(3.53,9.35)
  GND3 w0.102: v8(3.01,9.85) 3.48,9.38 3.5,9.38 v5(3.53,9.35)
  IN3 w0.064: v9(13.56,6.18) 13.34,6.41 6.45,6.41 v8(3.01,9.85) 2.64,10.22 2.64,13.33 2.63,13.34 2.63,18.79 v9(2.69,18.85)
ME_SUS_PWR_ACK: length 56.4
  TOP w0.127: UE3.B13 v7(50.75,16.59)
  GND2 w0.102: v7(50.75,16.59) 50.34,16.59 v5(50.33,16.6)
  GND3 w0.102: v8(49.96,16.59) 50.32,16.59 v5(50.33,16.6)
  IN3 w0.064: v8(49.96,16.59) 48.61,17.94 38.25,17.94 36.27,19.92 36.27,28.04 33.48,30.83 33.48,32.72 30.45,35.75 30.45,36.71 30.22,36.94 30.22,39.6 30.46,39.84 30.46,41.08 29.61,41.94 29.61,44.49 29.4,44.7 29.05,44.7 28.41,44.05 26.31,44.05 25.81,44.54 23.76,44.54 v3(23.58,44.37)
  BOTTOM w0.127: v3(23.58,44.37) 22.93,44.37 22.76,44.54 RH637.2 v1(20.16,44.54) 19.33,44.54 19.11,44.76 17.88,44.76 RH129.1
MEC_XTAL1: length 4.9
  TOP w0.127: YE2.1 39.62,21.35 40.43,20.53 CE66.1 v1(40.43,19.32) 40.43,19.31 40.75,18.99 UE3.A1
MEC_XTAL2: length 2.7
  TOP w0.127: RE178.2 41.36,19.54 CE67.1 41.36,20.67 42.12,21.42 YE2.2
MEC_XTAL2_R: length 2.3
  TOP w0.127: RE178.1 41.92,17.82 UE3.A3
MEDIACARD_IRQ#: length 21.2
  TOP w0.127: RR7.1 24.61,60.09 23.78,59.26 22.41,59.26 21.35,58.2 v1(21.35,55.14) 21.35,54.74 22.24,53.84 23.73,53.84 24.22,54.32 25.4,54.32 25.88,53.84 28.58,53.84 29.57,54.83 30.82,54.83 31.29,54.36 RH113.1 31.75,54.36 v7(32.2,54.82)
  GND2 w0.102: v7(32.2,54.82) 32.2,54.51 v5(32.13,54.44)
  GND3 w0.102: v5(32.13,54.44) 32.2,54.51 v6(32.61,54.51)
MEM_CONFIG0: length 6.2
  TOP w0.127: RH220.1 RH225.2 39.1,51.99 39.6,52.48 v1(39.6,54.18) 39.2,54.58 38,54.58 v9(37.73,54.85)
  BOTTOM w0.076: v9(37.73,54.85) 37.73,54.94 UH4.AB41
MEM_CONFIG1: length 5.6
  BOTTOM w0.076: UH4.AB42 37.43,56 37.43,56.46 37.51,56.54 37.51,58.76
  BOTTOM w0.127: RH222.2 37.9,60.76 38.24,60.42 38.24,59.89 38.15,59.8 38.13,59.8 RH227.1 37.9,59.16 37.51,58.77 37.51,58.76
MEM_CONFIG2: length 4.8
  BOTTOM w0.076: UH4.AB43 37.19,56.5 37.33,56.64 37.33,58.14 37.09,58.38 37.09,58.76
  BOTTOM w0.127: 37.09,58.76 RH226.1 37.32,59.7 37.34,59.7 37.44,59.79 37.44,60.31 37.34,60.41 37.33,60.41 RH224.2
MEM_CONFIG3: length 2.9
  TOP w0.127: v9(37.72,53.37) 37.54,53.19 37.54,52.18 37.35,51.99 RH218.2 RH223.1
  BOTTOM w0.076: UH4.AB36 37.72,53.35 v9(37.72,53.37)
MEM_CONFIG4: length 4.9
  TOP w0.127: RH219.1 RH221.2 38.06,51.99 38.3,52.23 38.3,53.61 v1(37.68,54.23) v9(37,54.91)
  BOTTOM w0.076: UH4.AB39 v9(37,54.91)
MOD_ID1: length 3.2
  TOP w0.127: v7(37.13,70.77) RP66.2
  GND2 w0.102: v7(37.13,70.77) 36.53,70.77 v5(36.36,70.6)
  GND3 w0.102: v5(36.36,70.6) 36.36,70.35 v6(36.29,70.28)
  BOTTOM w0.076: UPD1.L10 35.43,70.28 v6(36.29,70.28)
MOD_ID2: length 5.1
  TOP w0.127: RP69.1 34.85,68.75 v7(35.13,69.03)
  GND2 w0.254: v5(34.88,69.35) 34.88,69.3 35.13,69.05 v7(35.13,69.03)
  GND3 w0.102: v5(34.88,69.35) 34.81,69.42 v6(34.45,69.42)
  BOTTOM w0.076: v6(34.45,69.42) 34.35,69.42 34.25,69.32 32.83,69.32 32.43,69.72 32.43,70.31 32.22,70.53 UPD1.L4
MSATA_DEVSLP: length 93
  TOP w0.127: v9(35.32,58.01) 35.46,57.86 41.65,57.86 43.92,55.59 44.48,55.59 45.2,54.87 45.2,35.82 46.88,34.14 47.58,34.14 47.82,33.89 v2(48.71,33.89) ; v7(87.65,15.91) 87.84,16.1 87.84,17.54 87.22,18.17 87.22,21.79 85.95,23.06 85.95,26.64 v1(86.09,26.78) v2(86.09,27.2)
  IN1 w0.064: v2(86.09,27.2) 85.82,27.46 80.59,27.46 79.8,28.25 78.91,28.25 78.41,28.76 68.81,28.76 67.77,29.8 65.51,29.8 64.78,30.53 62.87,30.53 61.92,31.48 58.36,31.48 58.16,31.27 56.08,31.27 55.31,32.04 55.09,32.04 53.23,33.89 v2(48.71,33.89)
  GND2 w0.102: v5(87.65,15.5) v7(87.65,15.91)
  GND3 w0.102: v6(87.96,14.94) 87.96,15.2 v5(87.65,15.5)
  BOTTOM w0.076: v9(35.32,58.01) 35.15,57.85 35.15,55.99 UH4.AG42
  BOTTOM w0.127: JNGFF2.38 89.41,14.87 89.25,14.71 88.19,14.71 v6(87.96,14.94)
MSCLK: length 13.5
  TOP w0.127: v7(48.54,10.53) 48.29,10.79 48.29,11.13 48.22,11.2 48.22,11.52 UE3.H10 ; v2(47.6,6.81) 48.17,6.81 49.22,5.76 49.22,5.54 RE209.1 49.76,5.35 49.88,5.23 v7(49.88,4.78) 49.88,4.72 49.69,4.53 v1(49.69,4.45) 49.69,4.21 50.4,3.5 50.54,3.5 50.81,3.23 RE201.2
  IN1 w0.064: v7(48.54,10.53) 48.41,10.4 48.41,10.38 47.66,9.63 47.66,9.16 47.15,8.65 47.15,7.26 v2(47.6,6.81)
  GND2 w0.102: v5(49.89,4.38) 49.88,4.38 v7(49.88,4.78)
  GND3 w0.102: v6(49.89,4.71) v5(49.89,4.38)
MSDATA: length 15.4
  TOP w0.127: v16(50.39,3.13) 49.91,3.61 RE205.1 ; RE205.1 RE204.2 ; RE205.1 v7(49.37,4.71) ; UE3.G9 47.15,12.29 47.5,11.94 47.5,10.72 47.69,10.53 v2(47.69,10.51)
  IN1 w0.064: v2(47.69,10.51) 47.69,10.39 47.33,10.04 47.33,9.82 47.52,9.63 47.52,9.22 47.01,8.71 47.01,6.27 v9(46.96,6.22)
  GND2 w0.102: v7(49.37,4.71) 49.39,4.72 v5(49.39,5.04)
  GND3 w0.102: v6(49.39,4.71) v5(49.39,5.04)
  BOTTOM w0.127: v9(46.96,6.22) 46.96,6.56 47.42,7.02 48.63,7.02 49.09,6.56 49.09,6.02 49.39,5.72 v6(49.39,4.71)
NB_LID#: length 221.1
  TOP w0.127: v9(13.12,62.12) 13.31,61.93 13.31,53.63 v7(15.29,51.64) 15.59,51.34 v1(15.59,50.12) 15.91,49.8 15.91,48.64 16.65,47.9 20.99,47.9 DZ127.1 ; v7(50.71,3.77) 50.52,3.96 RE259.1
  IN1 w0.064: v7(50.71,3.77) 50.71,3.76 53.08,3.76 54.33,2.51 55.54,2.51 56.62,3.59 59.62,3.59 60.29,2.91 70.12,2.91 70.3,2.74 73.49,2.74 73.75,2.48 82.63,2.48 82.74,2.58 83.95,2.58 84.1,2.43 89.58,2.43 89.87,2.72 91.58,2.72 91.87,2.43 95.15,2.43 96.61,3.89 103.61,3.89 104.14,4.43 107,4.43 111.1,6.12 111.59,6.12 113.31,6.12 113.93,5.5 124.41,5.5 126.54,7.63 128.28,7.63 130.09,5.82 146.96,5.82 149.68,3.1 152.92,3.1 153.91,4.1 157.08,4.1 157.77,4.78 v2(157.77,7.16)
  GND2 w0.102: v7(15.29,51.64) v5(15.29,51.29) ; v7(50.71,3.77) 50.44,3.5 50.44,3.39 v5(50.35,3.3)
  GND3 w0.102: v5(15.29,51.29) 15.34,51.24 v8(15.34,50.86) ; v8(49.87,2.9) 50.03,3.06 50.12,3.06 v5(50.35,3.3)
  IN3 w0.064: v8(49.87,2.9) 46.27,2.9 45.49,3.68 44.75,3.68 44.48,3.94 40.15,3.94 39.35,4.74 38.67,4.74 37.49,5.92 33.78,5.92 32.23,7.47 29.31,7.47 25.72,11.06 25.18,11.06 22.7,13.54 22.7,14.22 19.4,17.52 19.26,17.52 15.64,21.14 15.64,24.7 16.44,25.5 16.44,26.86 14.66,28.63 14.66,32.94 13.85,33.76 13.85,37.33 15.6,39.08 15.6,47.85 14.5,48.95 14.5,50.02 v8(15.34,50.86)
  BOTTOM w0.127: v9(13.12,62.12) 11.53,62.12 10.65,63 RE150.2 11.39,64.28 CE71.1 11.45,65.03 11.55,65.13 UE12.3
NB_LID#_R: length 7.1
  GND2 w0.102: v5(21.92,45.78) 21.7,45.99 v7(21.5,45.99)
  GND3 w0.127: v6(21.6,45.61) 21.76,45.78 v5(21.92,45.78)
  BOTTOM w0.076: UH4.BC22 26.7,45.75 26.46,45.52 26.17,45.52 26.11,45.57 25,45.57 23.89,46.68 22.74,46.68 22.07,46.02
  BOTTOM w0.127: v6(21.6,45.61) 21.67,45.61 22.07,46.02
NB_MODE#: length 26.3
  TOP w0.127: UE3.J8 46.35,11.17 45.95,11.58 v7(45.95,12.92) ; QC123.1 30.39,23.58 30.58,23.39 v1(30.58,23.01) v7(30.58,22.13) 30.22,22.13 RC101.1
  GND2 w0.102: v7(30.58,22.13) 30.99,22.13 v5(31.17,21.95) ; v7(45.95,12.92) v5(45.56,12.92)
  GND3 w0.102: v8(45.31,13.4) 45.31,13.18 v5(45.56,12.92) ; v5(31.17,21.95) 31.28,21.84 v8(31.28,21.55)
  IN3 w0.064: v8(31.28,21.55) 31.28,20.61 31.71,20.18 31.71,19.94 35.69,15.96 35.69,14.48 36.74,13.43 45.28,13.43 v8(45.31,13.4)
NB_MODE#_R: length 48.6
  TOP w0.127: RC102.2 27,22.93 QC123.3 28.11,22.54 RC387.1 RC101.2 28.98,19.49 v1(28.46,18.97) 27.94,18.45 v9(26.34,18.45)
  IN3 w0.064: v3(20.55,45.17) 19.18,45.17 17.96,43.94 17.96,43.39 17.58,43.02 17.58,42.01 17.29,41.71 17.29,39.8 17.78,39.31 17.78,38.65 17.98,38.45 17.98,36.53 17.72,36.27 17.72,35.83 17.98,35.57 17.98,34.64 23.43,29.18 23.43,28.8 25.03,27.21 25.03,26.6 26.79,24.83 26.79,24.05 27.17,23.67 27.17,23.03 26.62,22.48 26.62,21.15 26.29,20.82 26.29,18.49 v9(26.34,18.45)
  BOTTOM w0.076: UH4.BE21 25.65,45.13 25.54,45.24 24.27,45.24 24.04,45.47 24.04,45.89 23.89,46.03 22.8,46.03 22.07,45.3
  BOTTOM w0.127: v3(20.55,45.17) 20.65,45.27 22.04,45.27 22.07,45.3
NB_MUTE#: length 72.7
  TOP w0.122: v7(43.15,17.81) UE3.A4
  IN1 w0.064: v7(43.15,17.81) 43.48,17.81 43.76,18.08 43.95,18.08 44.07,18.2 46.55,18.2 46.67,18.2 47.03,18.57 54.12,18.57 54.69,18.01 55.45,18.01 56.59,16.86 59.1,16.86 61.03,14.93 61.85,14.93 64.34,12.43 67.36,12.43 70.55,9.24 71.26,9.24 71.85,8.65 76.82,8.65 77.52,7.95 78.79,7.95 78.97,7.77 82.56,7.77 83.2,7.14 84.64,7.14 85.01,6.77 94,6.77 94.24,6.53 97.62,6.53 98,6.91 99.7,6.91 101.27,8.48 103.21,8.48 v4(103.34,8.35)
  GND2 w0.102: v5(103.54,8.86) 103.34,8.66 v4(103.34,8.35)
  GND3 w0.102: v5(103.54,8.86) 103.98,9.3 v8(103.98,9.31)
  IN3 w0.064: v8(103.98,9.31) 104.99,10.32 105.41,10.32 v3(105.49,10.4)
  BOTTOM w0.127: JIO1.K7 108.03,10.9 107.54,10.4 v3(105.49,10.4)
NGFF_PWREN: length 118.9
  TOP w0.127: v7(88.81,2.69) 87.73,3.77 87.73,14.74 87.35,15.12 87.35,16.22 v2(87.26,16.31) ; v2(27.45,26.22) v1(28.42,26.22) 30.29,26.22 30.77,25.74 v2(33.32,25.74)
  IN1 w0.064: v2(87.26,16.31) 87.24,16.33 85.76,16.33 85.09,17 76.06,17 73.13,19.93 69.41,19.93 64.6,24.74 60.31,24.74 60.08,24.96 58.13,24.96 57.76,24.59 55.42,24.59 53.67,26.34 45.09,26.34 43.84,27.59 39.15,27.59 38.12,26.56 34.22,26.56 33.4,25.74 v2(33.32,25.74) ; v4(20.04,50.07) 20.04,49.02 20.37,48.69 20.37,47.56 20.04,47.22 20.04,43.69 20.32,43.41 20.32,42.37 19.37,41.43 19.37,33.99 24.55,28.81 24.86,28.81 v2(27.45,26.22)
  GND2 w0.102: v4(20.04,50.07) 20.04,50.3 v5(19.88,50.45) ; v7(88.81,2.69) 88.88,2.76 v5(89.16,2.76)
  GND3 w0.102: v5(19.88,50.45) 19.81,50.37 v6(19.53,50.37) ; v5(89.16,2.76) 88.97,2.95 v6(88.63,2.95)
  BOTTOM w0.076: 22.07,49.8 22.52,49.8 23.63,48.68 24.16,48.68 24.44,48.96 25.24,48.96 25.32,48.87 26.03,48.87 26.14,48.77 26.62,48.77 26.86,48.54 UH4.BC27
  BOTTOM w0.127: R5829.1 v6(88.63,2.95) ; v6(19.53,50.37) 20.11,49.8 22.07,49.8
NRB_BIT: length 5.6
  BOTTOM w0.076: 22.07,50.37 22.3,50.37 23.63,49.04 v1(23.85,49.04) 24.29,49.04 24.38,49.13 25.3,49.13 25.39,49.04 26.1,49.04 26.12,49.02 UH4.BD28
  BOTTOM w0.127: 21.31,50.37 22.07,50.37
PA_USB2_RBIAS: length 1.3
  GND2 w0.152: v5(36.26,77.22) 36.14,77.09 v7(35.89,77.09)
  GND3 w0.152: v6(36.25,77.56) 36.25,77.23 v5(36.26,77.22)
  BOTTOM w0.152: UT2.H19 35.9,77.91 v6(36.25,77.56)
PANEL_BKEN_EC: length 156.9
  TOP w0.127: v2(71,6.41) 71,7.04 71.86,7.9 71.86,11.79 76.46,16.39 76.46,21.66 77.77,22.97 77.77,25.2 v1(78.35,25.78) v7(78.84,26.27) ; v2(47.03,10.63) 47.03,10.63 UE3.J9
  IN1 w0.064: v4(51.3,77.36) 51.64,77.7 51.64,81.92 50.85,82.71 50.85,85.55 54.96,89.65 54.96,91.93 55.55,92.52 59.19,92.52 v2(59.35,92.68) ; v2(71,6.41) 70.88,6.29 68.53,6.29 67.41,7.42 62.61,7.42 62.17,7.86 58.03,7.86 57.65,8.24 54.01,8.24 53.63,8.62 53.63,9.15 52.63,10.14 52.63,10.19 51.67,11.16 50.98,11.16 50.64,11.5 49.6,11.5 49.47,11.63 48.98,11.63 48.92,11.7 48.33,11.7 48.2,11.57 47.87,11.57 47.03,10.73 v2(47.03,10.63)
  GND2 w0.102: v7(78.84,26.27) v5(78.51,26.27) ; v5(51.3,77.02) v4(51.3,77.36)
  IN2 w0.074: v5(51.3,77.02) 52.83,75.5 54.71,75.5 55.89,74.31 55.89,71.26 55.06,70.43 55.06,67.48 51.28,63.7 51.28,63.2 50.03,61.95 50.03,54.83 53.92,50.94 53.92,45.57 52.46,44.11 52.46,34.67 52.48,34.64 52.48,29.66 55.27,26.87 55.27,26.61 55.9,25.98 58.54,25.98 59.46,25.06 72.36,25.06 73.85,26.55 75.7,26.55 76.16,26.09 77.06,26.09 77.29,25.86 78.1,25.86 v5(78.51,26.27)
PANEL_BKEN_PCH: length 53
  IN1 w0.064: v4(39.09,52.58) 39.28,52.58 40.19,53.5 40.19,54 40.8,54.61 v2(40.8,55.14) 40.8,56.51 41.96,57.67 41.96,58.42 44.23,60.69 44.23,61.83 45.36,62.96 45.36,67.83 46.03,68.5 46.47,68.5 47,69.03 47,69.52 51.83,74.34 51.83,81.97 51.01,82.79 51.01,85.47 55.1,89.56 55.1,91.87 55.61,92.38 59.01,92.38 59.35,92.04 v2(59.35,91.38)
  GND2 w0.102: v5(38.83,52.28) 38.83,52.33 v4(39.09,52.58)
  GND3 w0.102: v5(38.83,52.28) 38.8,52.25 v6(38.48,52.25)
PB_USB2_RBIAS: length 2.7
  TOP w0.127: v7(35.24,77.08) 34.24,77.08 v1(33.88,76.73)
  GND2 w0.152: v7(35.24,77.08) 35.22,77.11 35.22,77.19 v5(35.46,77.43)
  GND3 w0.152: v5(35.46,77.43) 35.23,77.66 v6(35.15,77.66)
  BOTTOM w0.152: UT2.F19 35.15,77.86 v6(35.15,77.66)
PBAT_CHARGER_SMBCLK: length 151
  TOP w0.127: RE112.1 39.91,5.34 v1(40.04,5.48) 40.59,6.02 v9(40.59,6.42) 40.59,6.59 40.8,6.8 41.55,7.55 UE3.N2 ; PR216.2 127.23,16.46 PD104.2 127.33,16.34 126.95,15.96 126.95,15.86 127.05,15.75 127.33,15.75 128.04,15.04 128.04,6.22 v2(128.09,6.18)
  IN1 w0.064: v2(165.07,2.04) 164.03,3.08 154.33,3.08 153.34,2.09 149.26,2.09 147.57,3.77 128.74,3.77 128.01,4.51 128.01,6.1 v2(128.09,6.18) 128.01,6.26 128.01,6.42 127.82,6.61 127.13,6.61 125.01,4.49 109.92,4.49 108.02,3.7 107.53,3.21 107.53,2.24 106.69,1.41 100.84,1.41 99.38,2.88 97.03,2.88 95.57,1.42 54.77,1.42 52.96,3.23 52.52,3.23 v4(52.24,2.95)
  GND2 w0.102: v5(52.04,3.31) 52.04,3.23 52.24,3.03 v4(52.24,2.95)
  GND3 w0.102: v8(52.07,3.64) 52.07,3.33 v5(52.04,3.31)
  IN3 w0.064: v9(40.59,6.42) 40.75,6.42 40.87,6.3 40.87,6.05 41.05,5.86 43.21,5.86 43.52,5.56 44.39,5.56 45.68,4.27 45.93,4.27 46.59,3.61 51.16,3.61 51.44,3.89 52.04,3.89 52.14,3.79 52.14,3.71 v8(52.07,3.64)
PBAT_CHARGER_SMBDAT: length 151
  TOP w0.127: UE3.M3 41.94,8.18 41.94,7.58 41.26,6.9 41.26,6.42 v9(41.25,6.42) 41.25,6.02 40.55,5.32 RE111.1 ; v2(127.71,6.18) 127.79,6.26 127.79,14.93 127.22,15.5 126.95,15.5 126.69,15.75 126.69,15.96 126.34,16.3 PD104.3 126.53,16.52 PR217.2
  IN1 w0.064: v4(52.65,2.95) 52.74,3.04 52.88,3.04 54.69,1.23 95.65,1.23 97.11,2.69 99.3,2.69 100.76,1.22 106.77,1.22 107.72,2.16 107.72,3.13 108.13,3.54 109.96,4.3 125.09,4.3 127.21,6.42 127.75,6.42 127.82,6.34 127.82,6.29 v2(127.71,6.18) 127.82,6.07 127.82,4.43 128.66,3.58 147.49,3.58 149.18,1.9 153.42,1.9 154.41,2.89 163.95,2.89 164.45,2.39 164.45,2.3 v2(164.18,2.04)
  GND2 w0.102: v5(52.61,3.32) 52.61,2.99 v4(52.65,2.95)
  GND3 w0.102: v8(52.45,3.64) 52.45,3.49 v5(52.61,3.32)
  IN3 w0.064: v8(52.45,3.64) 52.33,3.75 52.33,3.87 52.12,4.08 51.36,4.08 51.09,3.8 46.67,3.8 46.01,4.46 45.76,4.46 44.47,5.75 43.6,5.75 43.29,6.05 41.13,6.05 41.06,6.13 41.06,6.37 41.1,6.42 v9(41.25,6.42)
PBAT_PRES#: length 152.5
  TOP w0.127: v7(124.08,8.34) v1(124.08,10.43) 124.08,15.35 124.31,15.58 PD105.3 PD105.2 125.32,16.35 PR218.2 125.23,17.28 PR219.1 ; v2(86.08,2.73) 86.03,2.78 86.03,5.42 v2(86.01,5.43) ; v7(47.55,14.14) 47.55,14.13 47.55,13.93 47.15,13.54 UE3.F9
  IN1 w0.064: v2(86.08,2.73) 87.08,2.73 87.3,2.95 89.05,2.95 89.15,2.86 91.69,2.86 91.8,2.75 94.7,2.75 96.31,4.36 103.41,4.36 103.94,4.9 106.9,4.9 111.01,6.59 111.4,6.59 113.5,6.59 114.12,5.97 121.71,5.97 v7(124.08,8.34) 130.35,14.61 134.16,14.61 134.9,13.87 160.61,13.87 162.35,12.13 163.02,12.13 165.5,9.64 165.5,8.68 169.91,4.27 v2(169.91,4.08) ; v2(86.01,5.43) 85.66,5.78 84.18,5.78 84.1,5.86 80.32,5.86 80.07,6.11 78.42,6.11 78.12,6.41 76.88,6.41 76.34,6.95 70.77,6.95 70.53,6.71 69.91,6.71 67.86,8.76 65.39,8.76 64.76,9.4 62.02,9.4 59.66,11.76 56.52,11.76 55.82,12.46 54.86,12.46 54.41,12.91 54.41,13.62 53.71,14.33 52.06,14.33 51.91,14.48 51.91,14.89 51.52,15.28 50.69,15.28 50.5,15.09 49.53,15.09 49.33,14.89 48.14,14.89 47.55,14.3 v7(47.55,14.14)
PBTN_SW#: length 166.3
  TOP w0.127: v7(32.53,20.5) 32.53,20.96 32.86,21.29 v16(33.12,21.29) 34.13,21.29 34.54,20.88 34.54,19.27 35.15,18.66 CE103.1 35.15,17.82 RE187.2
  GND2 w0.102: v7(32.53,20.5) v5(32.18,20.5)
  GND3 w0.102: v6(31.81,20.53) 31.84,20.5 v5(32.18,20.5)
  IN3 w0.064: v6(104.06,9.9) 103.5,9.9 102.98,9.38 100.46,9.38 v3(99.25,8.18) 99.11,8.04 94.42,8.04 94.24,8.22 87.1,8.22 86.68,7.79 84.62,7.79 v3(84.57,7.75) ; v3(155,6.58) 154.73,6.58 153.25,8.06 148.47,8.06 147.1,6.69 145.61,6.69 144.91,7.39 138.66,7.39 137.64,6.37 137.34,6.37 135.8,4.83 v3(124.3,4.83)
  BOTTOM w0.127: v3(84.57,7.75) 81.95,5.12 81.95,1.86 81.62,1.53 RW2.2 66.13,1.53 65.83,1.23 44.74,1.23 42.46,3.51 41.69,3.51 41.23,3.05 39.93,3.05 39.28,3.7 38.77,3.7 38.46,4.01 38.46,8.45 37.06,9.86 37.06,14.4 36.08,15.38 35.09,15.38 34.87,15.15 33.21,15.15 32.64,15.72 32.64,19.71 v6(31.81,20.53) ; v3(99.25,8.18) 101.06,6.37 101.06,2.02 101.38,1.7 101.38,1.63 101.58,1.43 106.54,1.43 107.86,2.75 107.86,3.13 108.66,3.93 123.41,3.93 v3(124.3,4.83)
PBTN_SW#_APS: length 11.8
  BOTTOM w0.127: R5863.1 74.44,2.67 73.5,1.73 67.29,1.73 66.91,2.11 RW2.1 66.05,2.11 v1(65.5,1.56) 65.07,1.56 SW4.1
PCH_ACC1_INT1: length 11.2
  TOP w0.127: DZ123.2 17.97,45.89 v1(17.81,45.74)
  GND2 w0.102: v7(19.15,45.99) 18.81,45.99 v5(18.77,46.03)
  GND3 w0.127: v6(19.08,45.84) 18.99,45.96 18.81,45.98 v5(18.77,46.03)
  BOTTOM w0.076: UH4.BB22 27.11,45.88 27,45.98 26.17,45.98 26.12,45.94 25.1,45.94 24.03,47.01 22.5,47.01 22.07,46.59
  BOTTOM w0.127: 22.07,46.59 22.06,46.58 21.89,46.58 21.58,46.26 19.78,46.26 19.36,45.84 v6(19.08,45.84)
PCH_ACC1_INT1_R: length 0.9
  TOP w0.127: DZ123.1 18.08,47.39 RR20.1
PCH_ACC2_INT1: length 9.5
  TOP w0.127: v1(19.76,44.98) 20.35,45.57 DZ124.2
  GND2 w0.102: v7(20.35,45.99) 20.18,45.99 v5(20.04,45.85)
  GND3 w0.127: v6(19.74,45.61) 20.02,45.79 v5(20.04,45.85)
  BOTTOM w0.076: 22.07,46.37 22.18,46.37 22.66,46.85 23.96,46.85 25.06,45.75 UH4.BD22
  BOTTOM w0.127: v6(19.74,45.61) 19.74,45.75 20.03,46.03 21.63,46.03 21.98,46.37 22.07,46.37
PCH_ACC2_INT1_R: length 4.5
  TOP w0.127: DZ124.1 20.1,47.39 19.4,46.69 RR21.1 18.02,46.51 17.75,46.25 v1(16.48,46.25)
PCH_ALW_ON: length 88.8
  TOP w0.127: v2(48.6,23.91) 48.6,23.82 47.98,23.2 UZ15.2 ; v9(40.71,3.44) 40.93,3.23 v16(40.93,2.88)
  IN1 w0.064: v2(48.6,23.91) 47.65,23.91 47.2,24.36 45.04,24.36 43.25,26.16 41.13,26.16 39.9,24.92 38.15,24.92 33.85,20.62 33.85,19.71 32.15,18 30.23,18 28.24,16.02 28.24,15.34 v4(27.46,14.56) 25.56,12.66 v9(25.56,9.61) ; v9(40.71,3.44) 43.65,3.44 44.47,4.25 44.48,4.25 44.69,4.47 44.69,4.93 44.9,5.14 v2(45.12,5.14) 46.63,6.65 46.63,8.31 v2(46.35,8.59)
  GND2 w0.102: v5(26.96,14.55) 27.45,14.55 v4(27.46,14.56)
  GND3 w0.102: v8(26.96,14.88) v5(26.96,14.55)
  IN3 w0.064: v9(25.56,9.61) 25.5,9.54 25.5,8.12 27.54,6.08 31.18,6.08 31.86,5.4 37.54,5.4 38.48,4.46 39.24,4.46 40.12,3.57 40.58,3.57 v9(40.71,3.44) ; v8(26.96,14.88) 26.96,15.57 25.56,16.98 25.56,18.77 25.73,18.95 25.73,22.38 26.26,22.9 26.26,24.53 25.59,25.21 25.24,25.21 25.1,25.07 24.26,25.07 23.89,25.44 22.82,25.44 22.3,25.97 22.3,26.9 22.49,27.09 22.49,28.72 v3(18.92,32.29)
  BOTTOM w0.127: RZ57.1 19.19,31.67 18.92,31.93 v3(18.92,32.29)
PCH_ALW_ON_R: length 5.1
  BOTTOM w0.127: v1(18.45,32.4) 18.6,32.25 RZ57.2 18.6,31.31 19.19,30.72 RZ58.2 19.19,29.63 19.38,29.44 20.42,29.44 20.61,29.64 UZ3.3
PCH_BATLOW#: length 7.4
  BOTTOM w0.076: UH4.BD13 24.4,41.2 23.41,42.2
  BOTTOM w0.127: RH125.1 19.86,42.63 v1(22.26,42.63) 22.46,42.63 22.89,42.2 23.41,42.2
PCH_CPU_BCLK_N: length 85.3
  IN1 w0.086: v9(44.33,34.05) 44.44,34.16 44.44,34.4 45.03,34.98 45.03,36.08 47.33,38.38 47.33,40.3 55.6,48.57 55.6,51.82 53.76,53.65 53.76,62.74 55.49,64.47 55.49,65.18 59.98,69.68 62.58,69.68 64.16,68.1 68.9,68.1 72.5,71.71 72.5,75.92 76.95,80.37 76.95,81.59 77.56,82.2 77.56,82.51 79.87,84.82 82.19,84.82 82.57,84.44 86.68,84.44 86.85,84.27 v4(87.48,84.27)
  GND2 w0.102: v4(87.48,84.27) 87.48,84.12 v5(87.64,83.96)
  GND3 w0.102: v6(87.96,83.82) 87.81,83.81 v5(87.64,83.96)
  BOTTOM w0.076: UH4.H2 44.21,35.86 44.21,35.29 44.38,35.11 44.38,34.81 44.64,34.55 44.64,34.37 v9(44.33,34.05)
PCH_CPU_BCLK_P: length 85.4
  IN1 w0.086: v4(87.39,83.53) 87.57,83.71 87.57,83.86 87.47,83.96 86.72,83.96 86.55,84.13 82.44,84.13 82.06,84.51 80,84.51 77.87,82.38 77.87,82.07 77.26,81.46 77.26,80.24 72.81,75.79 72.81,71.58 69.03,67.79 64.03,67.79 62.45,69.37 60.11,69.37 55.8,65.06 55.8,64.34 54.07,62.61 54.07,53.78 55.91,51.94 55.91,48.45 47.64,40.17 47.64,38.25 45.34,35.95 45.34,34.85 44.75,34.27 44.75,34.21 v9(44.91,34.05)
  GND2 w0.102: v4(87.39,83.53) 87.57,83.53 v5(87.71,83.39)
  GND3 w0.102: v5(87.71,83.39) v6(87.96,83.17)
  BOTTOM w0.076: UH4.G2 44.37,35.77 44.37,35.36 44.55,35.18 44.55,34.88 44.81,34.62 44.81,34.15 v9(44.91,34.05)
PCH_CPU_PCIBCLK_N: length 85.4
  IN1 w0.086: v9(43.37,34.73) 44.08,34.73 44.55,35.19 44.55,36.31 46.82,38.59 46.82,40.47 55.13,48.78 55.13,51.6 53.03,53.7 53.03,63.4 59.89,70.26 62.96,70.26 64.64,68.58 68.39,68.58 72,72.19 72,78.96 78.48,85.44 87.1,85.44 87.45,85.31 v4(87.47,85.32)
  GND2 w0.102: v5(87.73,85.54) v4(87.47,85.32)
  GND3 w0.102: v6(87.96,85.77) v5(87.73,85.54)
  BOTTOM w0.076: v9(43.37,34.73) 43.37,35.5 43.41,35.55 UH4.J1
PCH_CPU_PCIBCLK_P: length 85.4
  IN1 w0.086: v4(87.49,85.95) 87.55,85.92 87.58,85.85 87.58,85.75 87.5,85.67 87.38,85.67 87.16,85.75 78.35,85.75 71.69,79.09 71.69,72.32 68.27,68.89 64.77,68.89 63.09,70.57 59.76,70.57 52.72,63.53 52.72,53.57 54.82,51.47 54.82,48.91 46.51,40.6 46.51,38.72 44.24,36.44 44.24,35.32 44.08,35.16 v9(43.86,35.16)
  GND2 w0.102: v5(87.73,86.19) v4(87.49,85.95)
  GND3 w0.102: v6(87.96,86.42) v5(87.73,86.19)
  BOTTOM w0.076: v9(43.86,35.16) 43.86,35.6 43.62,35.84 UH4.J2
PCH_DPWROK: length 94.1
  TOP w0.127: v2(70.87,8.27) 70.87,11.37 73.42,13.91 73.42,15.56 75.47,17.61 v1(75.47,22.75) 75.47,22.78 v2(75.47,24.02) ; RE248.2 53.78,17.34 v2(53.78,16.63) ; RH138.1 v2(29.88,38.87)
  IN1 w0.064: v2(53.78,16.63) 54.49,15.92 54.49,15.56 57.31,12.74 60.14,12.74 62.4,10.48 65.29,10.48 65.83,9.94 68.06,9.94 70.01,8 70.6,8 v2(70.87,8.27) ; v2(75.47,24.02) 74.86,24.63 69.46,24.63 65.99,28.09 62.79,28.09 61.19,29.7 58.05,29.7 57.87,29.88 55.5,29.88 54.77,30.6 54.53,30.6 52.93,32.2 48.37,32.2 47.69,31.52 46.75,31.52 46.41,31.18 42.73,31.18 40.33,33.58 40.33,33.88 40.33,34.73 39.88,35.18 32.14,35.18 30.03,37.29 30.03,38.09 30.1,38.16 30.1,38.65 v2(29.88,38.87)
PCH_DPWROK_EC: length 8.9
  TOP w0.127: RE248.1 51.91,16.67 v2(51.91,16.08) ; v2(46.15,13.81) 46.15,13.59 UE3.F8
  IN1 w0.064: v2(51.91,16.08) 51.28,15.45 50.62,15.45 50.43,15.26 49.39,15.26 49.18,15.05 47.57,15.05 46.39,13.87 46.23,13.87 46.16,13.81 v2(46.15,13.81)
PCH_DPWROK_R: length 15.1
  TOP w0.127: RH138.2 v7(29.31,39.87) 29.22,39.87 28.89,39.54 28.89,39.54 28.79,39.44 28.79,39.44 28.04,38.69 27.78,38.69 v16(27.21,38.12)
  GND2 w0.102: v7(29.31,39.87) 29.3,39.87 v5(29,40.16)
  GND3 w0.102: v5(29,40.16) 29.13,40.29 v6(29.31,40.29)
  IN3 w0.064: v6(29.31,40.29) 29.31,40.29 28.93,40.67 27.68,40.67 27.19,40.18 26.65,40.18 24.1,37.63 v3(24.1,37.19)
  BOTTOM w0.076: v3(24.1,37.19) 23.87,37.19 23.56,36.88 23.56,36.64 22.77,35.85 22.07,35.85
  BOTTOM w0.127: 22.07,35.85 21.42,35.85 21.26,36.01 RH626.2
PCH_JTAG_TCK1: length 203.6
  IN1 w0.064: v2(139.9,80.41) 139.9,77.71 138.02,75.83 138.02,74.8 135.79,72.57 134.62,72.57 132.59,70.54 129.92,70.54 128.88,69.5 128.88,64.06 129.32,63.62 129.32,62.75 129.87,62.2 129.87,61.09 130.36,60.6 130.36,56.26 131.51,55.11 131.51,52.35 136.37,47.49 139.23,47.49 141.48,45.24 142.86,45.24 146.78,41.32 146.78,35.72 144.19,33.13 142.65,33.13 142.62,33.11 142.62,32.57 142.18,32.12 139.83,32.12 135.74,28.03 130.96,28.03 129.81,26.89 129.81,21.79 128.41,20.39 125.38,20.39 124.75,21.02 123.26,21.02 122.98,21.3 115.13,21.3 113.34,23.09 113.34,23.65 112.68,24.31 109,24.31 108.74,24.06 105.75,24.06 105.38,23.68 104.76,23.68 103.71,22.63 96.4,22.63 95.53,23.5 89,23.5 88.04,24.47 85.54,24.47 85.24,24.77 82.22,24.77 81.77,24.33 79.92,24.33 77.19,27.06 v4(76.53,27.06)
  GND2 w0.102: v4(76.53,27.06) 76.28,27.06 v5(76.09,27.25)
  GND3 w0.102: v5(76.09,27.25) v6(75.57,27.25)
  BOTTOM w0.076: UH4.AN3 31.68,36.23 31.49,36.05 31.49,35.77 31.6,35.67 31.6,33.51 31.62,33.48 31.62,33.36
  BOTTOM w0.127: 31.62,33.36 31.62,30.75 v1(31.87,30.51) 33.07,29.3 33.09,29.3 36.73,25.66 41.01,25.66 44.12,22.55 51.29,22.55 54.01,25.27 55.2,25.27 58.8,28.87 73.95,28.87 v6(75.57,27.25)
PCH_MUTE#: length 119.8
  IN1 w0.064: v4(30.05,57.19) 29.87,57.19 29.1,56.43 29.1,55.58 28.18,54.66 28.18,53.5 25.93,51.25 25.93,48.35 26.12,48.17 26.12,47.6 25.42,46.9 25.42,44.45 25.17,44.21 25.17,42.07 24.79,41.69 24.79,38.07 25.61,37.25 25.61,37.03 27.36,35.28 28.43,35.28 31.7,32.01 37.92,32.01 40.86,29.07 47.28,29.07 47.61,29.39 51.04,29.39 52.12,28.31 53.33,28.31 53.85,27.8 54.95,27.8 55.91,26.83 57.32,26.83 58.02,26.12 64.98,26.12 69.96,21.14 73.85,21.14 75.07,19.91 76.83,19.91 77.69,19.06 80.69,19.06 81.7,20.06 82.85,20.06 83.51,19.41 85.07,19.41 85.47,19.01 87.52,19.01 88.03,18.5 v4(88.11,18.5)
  GND2 w0.102: v4(30.05,57.19) 30.05,56.89 v5(30.11,56.83) ; v5(88.46,18.47) 88.13,18.47 v4(88.11,18.5)
  IN2 w0.074: v5(104.3,23.07) 104.01,23.36 98.44,23.36 97.6,22.52 95.93,22.52 95.48,22.98 92.06,22.98 91.24,22.15 91.24,21.24 v5(88.46,18.47)
  GND3 w0.102: v6(104.43,22.61) 104.43,22.94 v5(104.3,23.07) ; v6(30.43,57.1) 30.39,57.1 v5(30.11,56.83)
  BOTTOM w0.076: v6(30.43,57.1) 30.43,57.05 30.28,56.9 UH4.AT44
  BOTTOM w0.127: JIO1.A9 106.06,20.16 106.73,20.83 106.73,21.42 105.86,22.3 v1(105.44,22.3) 104.71,22.3 104.43,22.58 v6(104.43,22.61)
PCH_PCIE_WAKE#: length 187
  TOP w0.127: RE288.2 36.67,9.56 v7(36.76,9.65) 36.79,9.67 39.28,9.67 39.8,9.15 40.37,9.15 40.61,9.39 UE3.L1 ; v2(47.1,43.97) 47.1,53.94 49.68,56.52 v1(51.47,56.52) v7(52.45,56.52) 52.7,56.52 52.97,56.79 52.97,58.01 52.13,58.84 45.15,58.84 42.9,61.1 42.9,66.88 41.7,68.08 41.7,69.03 41.22,69.52 41.22,70.79 41.37,70.95 41.37,71.39 41.5,71.52 41.99,71.52 50.83,80.36 50.83,81.47 52.1,82.75 52.1,83.39 51.47,84.03 49.06,84.03 46.9,86.19 46.9,86.57 46.61,86.86 RT226.1 46.21,86.87 46.21,87.92 RT430.2
  IN1 w0.064: v2(47.1,43.97) 47.1,43.57 45.31,41.78 41.59,41.78 39.84,40.02 34.45,40.02 v4(33.69,40.79) ; v4(84.9,53.93) 84.88,53.95 81.65,53.95 80.49,52.79 v4(73.38,52.79)
  GND2 w0.102: v5(52.83,56.42) 52.55,56.42 v7(52.45,56.52) ; v5(33.4,41.03) 33.45,41.03 v4(33.69,40.79) ; v4(84.9,53.93) v5(85.23,53.91) ; v4(73.38,52.79) v5(73,52.79) ; v7(36.76,9.65) v5(36.46,9.95)
  IN2 w0.074: v5(73,52.79) 73,55.17 71.5,56.67 71.5,62.59 70.53,63.56 58,63.56 55.37,60.93 55.37,60.64 53.69,58.96 53.69,56.85 53.26,56.42 v5(52.83,56.42)
  GND3 w0.102: v6(36.27,10.33) 36.27,10.14 v5(36.46,9.95) ; v6(32.97,41.03) v5(33.4,41.03) ; v6(85.51,53.64) v5(85.23,53.91)
  IN3 w0.064: v3(35.52,13.64) 35.16,14.01 35.16,15.76 31.19,19.73 31.19,19.96 30.72,20.43 30.72,21.92 31.28,22.48 31.28,25.77 28.86,28.19 28.86,28.56 26.3,31.12 26.06,31.12 25.89,31.29 24.97,31.29 21.82,34.45 21.82,36.48 22.4,37.06 22.4,38.41 24.19,40.2 v3(24.19,41)
  BOTTOM w0.076: 22.07,41.89 22.09,41.87 23.29,41.87 24.16,41 v3(24.19,41) 25.22,41 25.24,41.02 26.12,41.02 26.18,40.96 26.47,40.96 26.71,41.2 UH4.BC13 26.92,41.2 27.28,40.85 29.41,40.85 29.56,40.7 30.3,40.7 30.55,40.95 32.89,40.95 v6(32.97,41.03)
  BOTTOM w0.127: 22.07,41.89 21.87,42.09 21.37,42.09 RH124.1 ; v6(36.27,10.33) 36.27,12.74 35.52,13.49 v3(35.52,13.64)
PCH_PECI: length 3.9
  TOP w0.127: RH95.1 31.9,36.4 32.25,36.05 v7(32.25,35.67) 32.11,35.53 v1(31.72,35.53)
  GND2 w0.102: v7(32.25,35.67) 32.58,35.34 v5(32.64,35.34)
  GND3 w0.102: v6(33.07,35.34) v5(32.64,35.34)
  BOTTOM w0.076: UH4.AL3 32.77,36.42 33.07,36.12 v6(33.07,35.34)
PCH_PLTRST#: length 13.7
  TOP w0.127: v7(19.53,48.42) 19.28,48.16 18.39,48.16 18.22,48.33 UH5.2 18.22,49.07 18.08,49.21 17.78,49.21 17.57,49 UH5.1 17.57,48.24 17.43,48.1 17.04,48.1 v1(16.42,48.72)
  GND2 w0.102: v7(19.53,48.42) 19.68,48.27 v5(19.86,48.27)
  GND3 w0.102: v5(19.86,48.27) v8(20.19,48.27)
  IN3 w0.064: v8(20.19,48.27) 20.37,48.27 20.93,48.82 22.53,48.82 22.95,48.41 v6(23.15,48.41)
  BOTTOM w0.076: v6(23.15,48.41) 23.23,48.33 24.27,48.33 24.38,48.21 26.12,48.21 26.2,48.3 27.01,48.3 27.16,48.15 UH4.BB27
PCH_PLTRST#_5105: length 12.9
  TOP w0.127: UE13.4 33.39,10.81 33.31,10.88 33.31,10.9 RE183.1 32.86,10.91 32.86,10.9 32.72,10.77 32.72,9.21 v2(33.09,8.85) ; UE3.K1 40.17,9.61 v2(40.17,9.44)
  IN1 w0.064: v2(40.17,9.44) 38.39,9.44 38.32,9.52 37.03,9.52 36.89,9.38 35.38,9.38 34.34,8.34 33.6,8.34 v2(33.09,8.85)
PCH_PLTRST#_EC: length 330.1
  TOP w0.127: UV14.1 52.93,23.72 52.66,23.99 52.66,25.74 v2(52.81,25.89) ; v7(37.51,92.06) 37.84,91.73 37.84,89.21 R164.1 ; v9(20.29,9.35) 21.55,10.61 26.34,10.61 v1(26.45,10.5) 29.77,7.18 RE193.2 31.01,6.94 32.61,6.94 32.74,7.07 32.74,7.95 ; v7(88.62,14.64) 88.62,10.5 88.93,10.18 v2(88.93,4.09) ; v2(24.86,62.97) 24.86,63.31 UR1.1 ; RR38.1 52.58,92.63 52.14,92.19 50.17,92.19 49.95,91.97 40.55,91.97 v7(40.38,91.8) ; v2(17.24,55.07) 15.91,53.74 15.91,50.69 17.14,49.46 18.72,49.46 19.28,50.02 19.28,51.42 19.02,51.67 RH123.1 18.82,51.21 18.87,51.16 UH5.4
  IN1 w0.064: v7(88.62,14.64) 88.58,14.67 84.81,14.67 84.13,15.35 80.66,15.35 80.38,15.63 79.8,15.63 78.81,16.62 73.75,16.62 71.11,19.26 68.88,19.26 63.94,24.21 55.26,24.21 53.6,25.87 52.83,25.87 v2(52.81,25.89) 52.74,25.96 44.93,25.96 43.68,27.21 39.85,27.21 38.82,26.18 36.95,26.18 36.11,25.34 34.55,25.34 33.93,24.72 33.93,21.76 33.13,20.96 33.13,20.01 31.85,18.73 31.12,18.73 31,18.85 v4(30.17,18.85) 30.05,18.85 27.24,16.04 27.24,15.56 23.14,11.46 23.14,10 22.66,9.52 20.46,9.52 v9(20.29,9.35) 18.16,7.23 13.4,7.23 12.12,8.5 7.43,8.5 5.69,10.25 5.69,13.72 7.72,15.75 10.94,15.75 13.03,17.84 14.3,17.84 15.34,18.88 15.34,19.89 14.65,20.58 14.65,23.81 15.27,24.44 15.27,26.06 15.74,26.53 15.74,27.84 14.77,28.81 14.77,32.49 10.24,37.01 9.72,37.01 8.23,38.51 8.23,52.18 8.94,52.9 14.84,52.9 17.01,55.07 v2(17.24,55.07) 17.24,55.22 20.58,58.55 21.71,58.55 24.86,61.71 v2(24.86,62.97) 24.89,63 24.89,65.98 26.12,67.21 26.12,69.88 28.5,72.26 31.55,72.26 31.88,72.59 33.94,72.59 35.37,74.02 v4(37.11,74.02) ; v4(113.79,15.38) 113.46,15.05 113.46,14.46 112.79,13.79 112.79,12.01 111.75,10.96 111.75,9.68 111.59,9.53 110.54,9.53 110.05,10.02 109.46,10.02 109.27,10.21 106.6,10.21 103.98,7.59 103.98,6.94 103.23,6.19 103.2,6.19 98.88,6.19 98.07,5.38 94.92,5.38 93.33,3.79 92.19,3.79 92.02,3.97 89.06,3.97 v2(88.93,4.09) ; v7(40.38,91.8) 40.13,92.06 v7(37.51,92.06)
  GND2 w0.102: v5(37.36,73.74) 37.11,74 v4(37.11,74.02) ; v7(40.38,91.8) 40.64,91.55 v5(40.64,91.5) ; v5(29.94,19.11) 30.17,18.88 v4(30.17,18.85) ; v4(113.79,15.38) 113.79,16.19 v5(113.99,16.39) ; v5(88.92,14.86) 88.69,14.64 v7(88.62,14.64)
  IN2 w0.074: v5(37.36,73.74) 37.54,73.56 39.2,73.56 41.14,75.5 43.8,75.5 44.93,76.62 44.93,84.83 43.25,86.51 43.25,88.57 40.64,91.19 v5(40.64,91.5)
  GND3 w0.102: v6(114.6,17.08) 114.6,17 v5(113.99,16.39) ; v6(88.55,15.02) 88.71,14.86 v5(88.92,14.86) ; v6(29.52,19.27) 29.78,19.27 v5(29.94,19.11) ; v6(41.12,91.78) 40.92,91.78 v5(40.64,91.5)
  BOTTOM w0.127: v9(20.29,9.35) 20.21,9.43 20.21,10.49 20.34,10.61 UE2.17 ; LED_RST.1 28.92,19.86 v6(29.52,19.27) ; JNGFF2.50 89.44,17.87 88.97,17.4 88.97,15.44 v6(88.55,15.02) ; v6(41.12,91.78) 42.26,91.78 42.67,91.37 RT234.2 ; v6(114.6,17.08) 114.6,17.36 JIO1.C1
PCH_PWROK: length 18.3
  IN3 w0.064: v3(28.55,40.29) 27.81,39.55 27.02,39.55 26.03,38.56 26.03,38.21 25.73,37.9 25.27,37.9 24.89,37.52 24.89,36.28 25.29,35.87 v3(25.29,34.7)
  BOTTOM w0.127: v3(25.29,34.7) 25.29,34.68 24.36,33.74 24.36,32.64 23.85,32.14 23.85,29.9 23.47,29.52 23.47,28.22 23.1,27.86 ; 23.1,27.86 RH153.1 23.09,27.45 v16(22.29,26.66) ; 23.1,27.86 24,27.86 UH7.4
PCH_RSMRST#: length 112.1
  TOP w0.127: v7(74.04,3.19) 73,3.19 72.49,3.7 72.49,12.08 72.73,12.32 73.78,12.32 77.07,15.61 77.07,21.41 78.58,22.92 v1(78.58,23.89) 78.58,24.71 v2(79.36,25.48) ; RE155.1 v7(43.15,4.62)
  GND2 w0.102: v7(43.15,4.62) 43.15,4.93 v5(43.18,4.96) ; v7(74.04,3.19) v5(74.04,2.81)
  GND3 w0.102: v8(42.88,5.1) 43.04,5.1 v5(43.18,4.96) ; v8(73.85,2.28) 73.85,2.62 v5(74.04,2.81)
  IN3 w0.064: v3(17.58,35.4) 17.58,34.64 22.63,29.6 22.63,27.04 22.44,26.85 22.44,26.03 22.88,25.58 23.95,25.58 24.32,25.21 25.04,25.21 25.18,25.34 25.65,25.34 26.4,24.59 26.4,22.85 25.87,22.32 25.87,18.89 25.69,18.71 25.69,17.04 27.82,14.91 27.82,14.49 30.13,12.18 30.13,10.18 31.28,9.04 32.82,9.04 33.29,8.56 35.71,8.56 36.38,7.89 38.54,7.89 39.67,6.76 39.67,6.6 40.86,5.41 42.57,5.41 v8(42.88,5.1) 43.09,5.1 43.96,4.22 44.6,4.22 44.87,3.96 45.61,3.96 46.27,3.3 52.74,3.3 53.14,3.7 54.78,3.7 55.13,3.35 56.49,3.35 57.82,2.01 69.2,2.01 69.59,2.4 73.73,2.4 v8(73.85,2.28)
  BOTTOM w0.127: v3(17.58,35.4) 18.14,35.96 RH137.1
PCH_RSMRST#_R: length 11.2
  IN3 w0.064: v3(23.97,36.85) 24.13,36.85 24.37,37.09 24.37,37.7 26.7,40.04 27.53,40.04 v6(27.79,40.29)
  BOTTOM w0.076: 22.08,35.6 22.76,35.6 23.97,36.82 v3(23.97,36.85)
  BOTTOM w0.089: 22.07,35.6 22.08,35.6
  BOTTOM w0.127: 22.07,35.6 21.71,35.6 21.24,35.13 v16(21.18,35.13) 20.93,35.39 20.93,35.64 20.67,35.9 RH626.1 20.37,36.28 RH137.2
PCH_RTCRST#: length 115.4
  TOP w0.127: R5830.1 v16(66.95,13.75) 66.95,12.63 61.37,7.05 60.03,7.05 v9(57.96,4.98) ; v9(77,3.38) 77,3.64 77.75,4.4 77.75,5.68 77.83,5.75 JAPS1.9
  IN3 w0.064: v6(22.83,40.24) 21.88,39.29 21.88,37.28 21.33,36.73 19.91,36.73 v3(19.73,36.56) 20.16,36.12 20.55,36.12 21.21,35.46 21.21,34.32 24.76,30.77 25.67,30.77 25.84,30.6 26.08,30.6 28.19,28.49 28.19,28.12 30.76,25.56 30.76,22.69 30.2,22.13 30.2,20.21 30.67,19.75 30.67,18.22 30.9,17.99 32.19,17.99 34.64,15.54 34.64,13.79 35.44,12.99 44.82,12.99 46.99,10.82 46.99,9.43 46.58,9.03 46.58,7.92 47.11,7.38 49.51,7.38 49.96,6.94 53.19,6.94 54.18,5.94 55.52,5.94 56.48,4.98 v9(57.96,4.98) 58.34,4.61 59.58,4.61 60.77,3.41 74.33,3.41 74.59,3.16 76.77,3.16 v9(77,3.38)
  BOTTOM w0.076: UH4.BC10 26.57,40.02 26.43,40.16 22.91,40.16 v6(22.83,40.24)
  BOTTOM w0.127: v3(19.73,36.56) 18.87,36.56 18.64,36.79 CLRC.1 17.85,37.9 CH80.1 RH135.2
PCH_RTCX1: length 3.6
  BOTTOM w0.089: 25.24,39.65 25.35,39.76 26.07,39.76 26.13,39.69 26.66,39.69 26.91,39.44 UH4.BC9
  BOTTOM w0.127: RH212.2 24.79,39.2 25.24,39.65
PCH_RTCX2: length 2.6
  BOTTOM w0.089: 25.26,39.93 26.27,39.93 UH4.BD10
  BOTTOM w0.127: RH213.2 24.74,39.77 24.9,39.93 25.26,39.93
PCH_RTD3_CIO_PWR_EN: length 61.4
  IN2 w0.074: v5(32.81,92.91) 32.75,92.84 29.19,92.84 26.09,89.74 26.09,88.97 26.48,88.58 26.48,87.16 27.04,86.59 27.04,78.8 26.21,77.96 26.21,68.17 26.65,67.73 27.52,67.73 32.4,62.85 36.54,62.85 37.83,61.56 37.83,61.26 38.39,60.7 38.39,58.44 38.45,58.38 38.45,57.8 38.3,57.66 38.3,56.58 39,55.88 39,55.15 39.15,55 39.15,54.73 39.75,54.13 v5(40.48,54.13)
  GND3 w0.102: v6(40.78,54.43) v5(40.48,54.13) ; v5(32.81,92.91) v8(32.81,92.49)
  IN3 w0.064: v8(32.81,92.49) 32.81,91.08 33.49,90.4 35.16,90.4 35.85,89.71 v3(35.85,89.2)
  BOTTOM w0.127: RT420.2 RT19.2 v3(35.85,89.2)
PCH_RTD3_CIO_PWR_EN_R: length 2.3
  BOTTOM w0.076: RT420.1 36.42,87.65 36.29,87.52 36.05,87.52 35.09,86.56 UT2.F1
PCH_RTD3_USB_PWR_EN: length 55
  TOP w0.127: v7(34.34,92.02) 34.32,92 v1(34.32,90.57) 33.97,90.21 33.97,89.41 34.18,89.2 RT35.2 RT20.2 RT421.2
  GND2 w0.102: v5(34.35,92.58) 34.35,92.03 v7(34.34,92.02)
  IN2 w0.074: v5(34.35,92.58) 34.02,92.25 33.5,92.25 33.25,92.51 33.25,93.05 33.04,93.25 32.37,93.25 32.11,92.99 28.36,92.99 27.42,92.05 27.42,91.49 25.79,89.87 25.79,88.84 26.18,88.46 26.18,87.03 26.74,86.46 26.74,78.92 25.91,78.09 25.91,68.04 26.52,67.43 27.4,67.43 31.98,62.85 31.98,59.71 v5(32.8,58.88)
  GND3 w0.102: v6(33.22,58.81) 32.88,58.81 v5(32.8,58.88)
  BOTTOM w0.076: 33.19,58.76 33.19,57.61 32.98,57.39 32.98,56.42 32.89,56.33 32.89,55.99 UH4.AL42
  BOTTOM w0.127: 33.19,58.76 33.19,58.78 v6(33.22,58.81)
PCH_RTD3_USB_PWR_EN_R: length 3.4
  GND2 w0.102: v7(34.9,87.93) v5(34.9,87.48)
  GND3 w0.102: v5(34.9,87.48) 34.72,87.31 v8(34.72,87.15)
  IN3 w0.064: v3(34.17,85.43) 33.91,85.69 33.91,86.34 v8(34.72,87.15)
  BOTTOM w0.127: UT2.D4 v3(34.17,85.43)
PCH_SATA_LED#: length 4.4
  BOTTOM w0.076: UH4.AD44 36.05,56.81 36.05,58.47 35.82,58.7 35.82,58.76
  BOTTOM w0.127: 35.82,58.76 35.82,59.23 35.81,59.24 35.81,60.6 35.69,60.72 RH92.1
PCH_SPI_CLK: length 140
  TOP w0.127: v9(78.77,4.59) 78.77,3.52 77.4,2.15 v1(58.07,2.15) 55.96,2.15 v9(55.96,2.16)
  IN1 w0.064: v4(16.48,51.67) 16.3,51.49 16.3,47.07 15.96,46.74 15.96,39.09 14.57,37.7 14.57,33.74 16.38,31.93 16.38,29.43 16.8,29.01 16.8,26.49 16.34,26.02 16.34,24.28 15.59,23.54 15.59,20.87 16.59,19.87 16.59,18.9 18.32,17.17 18.32,11.34 16.8,9.83 15.11,9.83 v9(13.9,8.62)
  GND2 w0.102: v5(17.56,51.67) v4(16.48,51.67)
  GND3 w0.102: v6(17.56,52.1) v5(17.56,51.67)
  IN3 w0.064: v9(55.96,2.16) 55,1.2 32.65,1.2 30.58,3.27 19.25,3.27 v9(13.9,8.62) ; v6(17.56,52.1) 18.29,52.1 19.47,50.92 21.73,50.92 22.55,51.74 v3(22.55,51.95)
  BOTTOM w0.076: v3(22.55,51.95) 23.21,51.95 25.04,50.12 26.13,50.12 26.18,50.06 26.59,50.06 UH4.BC31
  BOTTOM w0.127: v9(13.9,8.62) 15.77,10.5 RE21.1 ; v9(78.77,4.59) 78.77,4.71 78.85,4.79 78.85,7.1 78.85,7.1 JSPI2.7
PCH_SPI_CLK_0_R: length 15
  IN3 w0.064: v3(17.71,60.28) 17.63,60.2 17.63,58.81 17.29,58.48 17.29,58.03 17.54,57.79 17.54,57.68 17.47,57.61 17.36,57.61 16.95,58.02 16.84,58.02 16.77,57.95 16.77,57.84 17.18,57.43 17.18,57.32 17.11,57.25 17,57.25 16.59,57.66 16.48,57.66 16.41,57.59 16.41,57.48 16.82,57.07 16.82,56.96 16.75,56.89 16.64,56.89 16.23,57.3 16.12,57.3 16.05,57.23 16.05,57.12 16.37,56.8 16.37,56.69 16.3,56.62 16.19,56.62 16.01,56.8 15.62,56.8 v3(15.04,56.22)
  BOTTOM w0.127: v3(15.04,56.22) 14.77,55.95 14.77,53.84 14.93,53.68 v9(14.93,53.65) 14.93,53.19 16.02,52.1 RP5.1
PCH_SPI_CS#0: length 128
  TOP w0.127: v2(33.27,24.9) v16(31.72,24.9) 31.14,24.9 30.51,25.53 v2(27.86,25.53)
  IN1 w0.064: v2(33.27,24.9) 34.1,25.72 36.22,25.72 36.87,26.37 38.47,26.37 39.5,27.4 43.76,27.4 45.01,26.15 53.59,26.15 55.34,24.4 64.02,24.4 68.67,19.74 72.81,19.74 v9(74.31,18.24) ; v2(27.86,25.53) 26.22,25.53 24.08,27.68 24.08,28.75 18.65,34.17 18.65,38.05 18.04,38.66 18.04,42.35 18.83,43.14 18.83,45.69 18.56,45.95 18.56,48.13 18.83,48.39 18.83,51.04 19.86,52.07 v4(19.86,53.65)
  GND2 w0.102: v5(19.86,54.01) v4(19.86,53.65)
  GND3 w0.102: v6(19.86,53.68) v5(19.86,54.01)
  BOTTOM w0.076: UH4.BD31 25.12,50.3 23.4,52.01 23.4,52.43 23.17,52.66 22.07,52.66
  BOTTOM w0.127: UH6.1 11.73,57.74 11.98,57.49 11.98,57.25 11.83,57.11 11.22,57.11 11.1,56.98 11.1,56.75 11.27,56.57 11.87,56.57 12.13,56.32 12.34,56.32 12.49,56.47 12.49,57.08 12.64,57.23 12.85,57.23 13,57.08 13,55.86 13.14,55.71 13.35,55.71 13.5,55.86 13.5,57.08 13.65,57.23 17.02,57.23 17.44,56.81 17.65,56.81 17.96,57.12 18.17,57.12 18.32,56.97 18.32,56.76 17.73,56.17 17.73,55.96 17.88,55.81 18.09,55.81 18.68,56.4 18.89,56.4 19.03,56.25 19.03,56.04 18.73,55.74 18.73,55.53 19.86,54.39 v6(19.86,53.68) 20.88,52.66 22.07,52.66 ; JSPI2.8 78.35,12.83 75.61,15.57 75.61,17.72 75.09,18.24 v9(74.31,18.24)
PCH_SPI_CS#1: length 0.8
  GND2 w0.102: v7(28.84,51.15) 28.63,50.95 v5(28.63,50.82)
  GND3 w0.102: v6(28.63,50.43) v5(28.63,50.82)
PCH_SPI_CS#2: length 56.5
  IN1 w0.064: v4(17.57,12.68) 17.87,12.98 17.87,16.99 15.97,18.88 15.97,19.82 15.13,20.66 15.13,23.71 15.89,24.47 15.89,26.21 16.11,26.43 16.11,28.5 15.78,28.83 15.78,31.9 14.13,33.55 14.13,37.88 15.52,39.27 15.52,46.92 v4(15.87,47.28)
  GND2 w0.102: v5(16.27,47.36) 16.18,47.28 v4(15.87,47.28) ; v4(17.57,12.68) 17.42,12.53 v5(17.42,12.34)
  GND3 w0.102: v5(16.27,47.36) 16.56,47.66 v8(16.63,47.66) ; v6(17.57,11.99) 17.42,12.15 v5(17.42,12.34)
  IN3 w0.064: v8(16.63,47.66) 16.89,47.91 17.52,47.91 18.33,48.72 20.08,48.72 20.55,49.2 21.58,49.2 22.68,50.3 27.27,50.3 27.68,49.89 v3(29.21,49.89)
  BOTTOM w0.076: UH4.AT31 30.16,50.41 29.64,49.89 v3(29.21,49.89)
  BOTTOM w0.127: v1(16.74,11.39) 17.34,11.99 v6(17.57,11.99) RE22.1
PCH_SPI_CS#2_R: length 2
  BOTTOM w0.127: RE22.2 19.67,11.96 20.17,11.96 20.32,12.11 UE2.20
PCH_SPI_HOLD#: length 17.3
  IN3 w0.064: v3(20.56,59.65) 20.14,59.65 19.07,58.58 19.07,55.93 18.45,55.31 18.45,54.2 v6(19.86,52.79)
  BOTTOM w0.076: UH4.BD30 26.25,49.68 26.01,49.93 24.7,49.93 24.18,50.45 24.18,50.49 v1(23.09,51.58) 22.36,51.58 21.59,52.36 20.29,52.36
  BOTTOM w0.127: v6(19.86,52.79) 20.29,52.36 ; RH114.2 v3(20.56,59.65)
PCH_SPI_HOLD#_0_R: length 1.9
  BOTTOM w0.127: UH6.7 18.59,59.01 19.22,59.65 RH116.1
PCH_SPI_SI: length 136.6
  IN1 w0.064: v4(17.34,52.28) 17.21,52.15 17.21,46.69 16.99,46.47 16.99,39.18 17.46,38.7 17.46,37.74 17.14,37.42 17.14,36.45 17.39,36.2 17.56,36.2 17.64,36.12 17.64,36.02 17.56,35.94 17.39,35.94 17.32,35.87 17.32,35.76 17.39,35.69 17.56,35.69 17.64,35.61 17.64,35.51 17.56,35.43 17.39,35.43 17.32,35.36 17.32,35.25 17.39,35.18 17.56,35.18 17.64,35.11 17.64,35 17.56,34.93 17.39,34.93 17.32,34.85 17.32,34.75 17.39,34.67 17.56,34.67 17.64,34.6 17.64,34.49 17.56,34.42 17.39,34.42 17.32,34.34 17.32,34.24 17.39,34.16 17.56,34.16 17.64,34.09 17.64,33.98 17.56,33.91 17.39,33.91 17.32,33.84 17.32,33.73 17.39,33.66 17.56,33.66 17.64,33.58 17.64,33.48 17.56,33.4 17.39,33.4 17.32,33.33 17.32,33.22 17.39,33.15 17.56,33.15 17.64,33.07 17.64,32.97 17.56,32.89 17.39,32.89 17.32,32.82 17.32,32.71 17.39,32.64 17.56,32.64 17.64,32.57 17.64,32.46 17.56,32.39 17.39,32.39 17.32,32.31 17.32,32.21 17.39,32.13 17.56,32.13 17.64,32.06 17.64,31.78 17.97,31.45 17.97,30.51 17.73,30.27 17.73,24.58 16.36,23.22 16.36,22.1 17.71,20.76 17.71,18.96 17.91,18.75 17.91,18.65 17.74,18.48 17.74,18.38 17.82,18.3 17.92,18.3 18.09,18.47 18.2,18.47 18.27,18.39 18.27,18.29 18.1,18.12 18.1,18.02 18.18,17.94 18.28,17.94 18.45,18.11 18.56,18.11 18.76,17.9 18.76,12.43 v7(18.92,12.27)
  GND2 w0.102: v5(17.22,52.6) 17.22,52.41 v4(17.34,52.28) ; v5(18.54,12.27) v7(18.92,12.27)
  GND3 w0.102: v6(18.18,12.27) v5(18.54,12.27) ; v6(17.56,52.6) v5(17.22,52.6)
  IN3 w0.064: v6(18.18,12.27) 18.18,10.19 20.35,8.02 21.83,8.02 22.53,8.72 23.87,8.72 26.7,5.89 31.1,5.89 31.78,5.21 37.46,5.21 38.94,3.73 39.69,3.73 40.34,3.08 40.94,3.08 41.48,3.61 44.31,3.61 44.58,3.35 45.35,3.35 46.26,2.44 50.05,2.44 50.29,2.69 52.07,2.69 52.43,2.33 53.53,2.33 54.03,2.83 55.07,2.83 55.25,3.02 56.35,3.02 57.68,1.68 78.24,1.68 79.33,2.77 v3(79.85,2.77) ; v6(17.56,52.6) 17.67,52.71 18.54,52.71 19.88,51.36 v3(21.08,51.36)
  BOTTOM w0.076: UH4.BB29 27.2,49.14 26.99,49.35 26.74,49.35 26.64,49.45 25.67,49.45 25.57,49.55 24.17,49.55 v1(23.43,50.28) 22.7,51.01 21.43,51.01 v3(21.08,51.36)
  BOTTOM w0.127: v6(17.56,52.6) 17.85,52.6 18.11,52.34 18.11,51.07 RC44.1 ; JSPI2.5 v3(79.85,2.77)
PCH_SPI_SI_0_R: length 14.4
  IN3 w0.064: v3(18,61.55) 18,61.5 18.16,61.34 18.16,61.25 18.24,61.17 18.62,61.17 18.69,61.1 18.69,60.99 18.62,60.92 18.24,60.92 18.16,60.84 18.16,60.74 18.24,60.66 18.62,60.66 18.69,60.59 18.69,60.49 18.62,60.41 18.24,60.41 18.16,60.34 18.16,60.23 18.24,60.16 18.62,60.16 18.69,60.08 18.69,59.98 18.62,59.9 18.24,59.9 18.16,59.83 18.16,57.01 v9(17.27,56.11) 15.67,56.11 v3(15.54,55.99)
  BOTTOM w0.127: RP5.2 16.24,52.6 15.44,53.4 15.44,53.89 15.27,54.05 15.27,55.72 v3(15.54,55.99)
PCH_SPI_SO: length 140.3
  TOP w0.127: v7(54.58,2.79) v1(55.2,2.16) 55.72,1.64 77.61,1.64 79.35,3.38 v9(79.35,4.59)
  IN1 w0.064: v9(19.28,14.76) 19.28,15.42 19.35,15.49 19.99,15.49 20.06,15.57 20.06,15.67 19.99,15.75 19.07,15.75 19,15.82 19,15.93 19.07,16 19.99,16 20.06,16.07 20.06,16.18 19.99,16.25 19.07,16.25 19,16.33 19,16.43 19.07,16.51 19.99,16.51 20.06,16.58 20.06,16.69 19.99,16.76 19.16,16.76 19.05,16.87 19.05,17.32 19.12,17.4 19.66,17.4 19.73,17.47 19.73,17.57 19.66,17.65 19.12,17.65 19.05,17.72 19.05,17.89 17.9,19.03 17.9,20.83 16.55,22.18 16.55,23.14 17.92,24.5 17.92,30.2 18.16,30.44 18.16,31.53 17.83,31.86 17.83,36.21 17.33,36.72 17.33,37.34 17.65,37.66 17.65,38.78 17.19,39.24 17.19,44.61 17.84,45.26 17.84,47.79 17.6,48.03 17.6,51.64 17.87,51.91 17.87,52.62 v4(18.01,52.76)
  GND2 w0.102: v7(54.58,2.79) 54.39,2.79 v5(54.25,2.93) ; v5(17.93,53.1) 17.93,52.84 v4(18.01,52.76)
  GND3 w0.102: v6(17.56,53.1) v5(17.93,53.1) ; v8(54.25,2.57) v5(54.25,2.93)
  IN3 w0.064: v8(54.25,2.57) 53.82,2.14 52.35,2.14 51.99,2.5 50.37,2.5 50.13,2.25 37.28,2.25 36.69,2.85 32.55,2.85 30.34,5.06 26.28,5.06 23.99,7.36 22.57,7.36 21.82,6.6 18.01,6.6 15.67,8.93 15.67,11.16 v9(19.28,14.76) ; v6(17.56,53.1) 18.53,53.1 19.73,51.9 21.02,51.9 v3(21.54,51.38)
  BOTTOM w0.076: UH4.BE30 25.7,49.68 25.65,49.74 24.42,49.74 22.87,51.29 21.63,51.29 v3(21.54,51.38)
  BOTTOM w0.127: v9(79.35,4.59) 79.35,7.1 79.35,7.1 JSPI2.6 ; v9(19.28,14.76) 18.61,14.76 18.18,14.33 RE18.1
