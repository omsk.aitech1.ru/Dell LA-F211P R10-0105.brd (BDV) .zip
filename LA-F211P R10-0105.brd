# Allegro board LA-F211P R10-0105.brd (continued)
## Nets (continued)
DDR_A_MA9: RD175.1 UC1.CG4 UD1.R7 UD2.R7 UD3.R7 UD4.R7
DDR_A_MA10: RD176.1 UC1.BT2 UD1.M3 UD2.M3 UD3.M3 UD4.M3
DDR_A_MA11: RD177.1 UC1.CC2 UD1.T2 UD2.T2 UD3.T2 UD4.T2
DDR_A_MA12: RD178.1 UC1.CH4 UD1.M7 UD2.M7 UD3.M7 UD4.M7
DDR_A_MA13: RD179.1 UC1.BM3 UD1.T8 UD2.T8 UD3.T8 UD4.T8
DDR_A_MA14: RD180.1 UC1.BR4 UD1.L2 UD2.L2 UD3.L2 UD4.L2
DDR_A_MA15: RD181.1 UC1.BL1 UD1.M8 UD2.M8 UD3.M8 UD4.M8
DDR_A_MA16: RD182.1 UC1.BT4 UD1.L8 UD2.L8 UD3.L8 UD4.L8
DDR_A_ODT0: RD189.1 UC1.BL3 UD1.K3 UD2.K3 UD3.K3 UD4.K3
DDR_A_PARITY: RD192.1 UC1.BR3 UD1.T3 UD2.T3 UD3.T3 UD4.T3
DDR_B_ACT#: RD200.1 UC1.CF9 UD5.L3 UD6.L3 UD7.L3 UD8.L3
DDR_B_ALERT#: RD202.2 UC1.CE8 UD5.P9 UD6.P9 UD7.P9 UD8.P9
DDR_B_BA0: RD218.1 UC1.BU8 UD5.N2 UD6.N2 UD7.N2 UD8.N2
DDR_B_BA1: RD212.1 UC1.BU9 UD5.N8 UD6.N8 UD7.N8 UD8.N8
DDR_B_BG0: RD210.1 UC1.CE9 UD5.M2 UD6.M2 UD7.M2 UD8.M2
DDR_B_BG1: RD246.2 RD248.2 RD250.2 RD252.2 UC1.CE7
DDR_B_CKE0: RD220.1 UC1.CF8 UD5.K2 UD6.K2 UD7.K2 UD8.K2
DDR_B_CLK0: RD201.1 UC1.CA9 UD5.K7 UD6.K7 UD7.K7 UD8.K7
DDR_B_CLK#0: RD225.1 UC1.CB9 UD5.K8 UD6.K8 UD7.K8 UD8.K8
DDR_B_CS#0: RD207.1 UC1.BP11 UD5.L7 UD6.L7 UD7.L7 UD8.L7
DDR_B_D0: UC1.BH2 UD7.D7
DDR_B_D1: UC1.BH1 UD7.B8
DDR_B_D2: UC1.BH4 UD7.D3
DDR_B_D3: UC1.BH5 UD7.C8
DDR_B_D4: UC1.BG5 UD7.C2
DDR_B_D5: UC1.BG1 UD7.A3
DDR_B_D6: UC1.BG2 UD7.C7
DDR_B_D7: UC1.BG4 UD7.C3
DDR_B_D8: UC1.BE2 UD7.H7
DDR_B_D9: UC1.BE5 UD7.H8
DDR_B_D10: UC1.BC2 UD7.J7
DDR_B_D11: UC1.BC1 UD7.G2
DDR_B_D12: UC1.BE4 UD7.H2
DDR_B_D13: UC1.BE1 UD7.F7
DDR_B_D14: UC1.BC4 UD7.H3
DDR_B_D15: UC1.BC5 UD7.J3
DDR_B_D16: UC1.BH8 UD5.B8
DDR_B_D17: UC1.BK10 UD5.C2
DDR_B_D18: UC1.BK11 UD5.A3
DDR_B_D19: UC1.BK8 UD5.C3
DDR_B_D20: UC1.BK7 UD5.D3
DDR_B_D21: UC1.BH10 UD5.C8
DDR_B_D22: UC1.BH11 UD5.D7
DDR_B_D23: UC1.BH7 UD5.C7
DDR_B_D24: UC1.BE7 UD5.H3
DDR_B_D25: UC1.BE10 UD5.H2
DDR_B_D26: UC1.BC10 UD5.J3
DDR_B_D27: UC1.BE8 UD5.F7
DDR_B_D28: UC1.BE11 UD5.G2
DDR_B_D29: UC1.BC8 UD5.H8
DDR_B_D30: UC1.BC7 UD5.H7
DDR_B_D31: UC1.BC11 UD5.J7
DDR_B_D32: UC1.AY5 UD8.C8
DDR_B_D33: UC1.AW4 UD8.C3
DDR_B_D34: UC1.AY1 UD8.B8
DDR_B_D35: UC1.AW2 UD8.C7
DDR_B_D36: UC1.AY2 UD8.D7
DDR_B_D37: UC1.AW5 UD8.C2
DDR_B_D38: UC1.AY4 UD8.A3
DDR_B_D39: UC1.AW1 UD8.D3
DDR_B_D40: UC1.AU1 UD8.F7
DDR_B_D41: UC1.AT4 UD8.H3
DDR_B_D42: UC1.AU2 UD8.H7
DDR_B_D43: UC1.AT5 UD8.J3
DDR_B_D44: UC1.AU5 UD8.H8
DDR_B_D45: UC1.AT2 UD8.J7
DDR_B_D46: UC1.AU4 UD8.H2
DDR_B_D47: UC1.AT1 UD8.G2
DDR_B_D48: UC1.AY10 UD6.C3
DDR_B_D49: UC1.AY7 UD6.D3
DDR_B_D50: UC1.AW11 UD6.D7
DDR_B_D51: UC1.AY8 UD6.A3
DDR_B_D52: UC1.AW8 UD6.B8
DDR_B_D53: UC1.AY11 UD6.C2
DDR_B_D54: UC1.AW7 UD6.C7
DDR_B_D55: UC1.AW10 UD6.C8
DDR_B_D56: UC1.AU7 UD6.H3
DDR_B_D57: UC1.AU10 UD6.H2
DDR_B_D58: UC1.AT11 UD6.J7
DDR_B_D59: UC1.AU8 UD6.F7
DDR_B_D60: UC1.AU11 UD6.G2
DDR_B_D61: UC1.AT8 UD6.H8
DDR_B_D62: UC1.AT7 UD6.H7
DDR_B_D63: UC1.AT10 UD6.J3
DDR_B_DQS0: UC1.BH3 UD7.B7
DDR_B_DQS1: UC1.BE3 UD7.G3
DDR_B_DQS2: UC1.BK9 UD5.B7
DDR_B_DQS3: UC1.BC9 UD5.G3
DDR_B_DQS4: UC1.AY3 UD8.B7
DDR_B_DQS5: UC1.AU3 UD8.G3
DDR_B_DQS6: UC1.AW9 UD6.B7
DDR_B_DQS7: UC1.AT9 UD6.G3
DDR_B_DQS#0: UC1.BG3 UD7.A7
DDR_B_DQS#1: UC1.BC3 UD7.F3
DDR_B_DQS#2: UC1.BH9 UD5.A7
DDR_B_DQS#3: UC1.BE9 UD5.F3
DDR_B_DQS#4: UC1.AW3 UD8.A7
DDR_B_DQS#5: UC1.AT3 UD8.F3
DDR_B_DQS#6: UC1.AY9 UD6.A7
DDR_B_DQS#7: UC1.AU9 UD6.F3
DDR_B_MA0: RD206.1 UC1.BV9 UD5.P3 UD6.P3 UD7.P3 UD8.P3
DDR_B_MA1: RD198.1 UC1.BW6 UD5.P7 UD6.P7 UD7.P7 UD8.P7
DDR_B_MA2: RD217.1 UC1.BW5 UD5.R3 UD6.R3 UD7.R3 UD8.R3
DDR_B_MA3: RD213.1 UC1.BY5 UD5.N7 UD6.N7 UD7.N7 UD8.N7
DDR_B_MA4: RD205.1 UC1.BY6 UD5.N3 UD6.N3 UD7.N3 UD8.N3
DDR_B_MA5: RD204.1 UC1.CA6 UD5.P8 UD6.P8 UD7.P8 UD8.P8
DDR_B_MA6: RD211.1 UC1.CB7 UD5.P2 UD6.P2 UD7.P2 UD8.P2
DDR_B_MA7: RD216.1 UC1.CB10 UD5.R8 UD6.R8 UD7.R8 UD8.R8
DDR_B_MA8: RD214.1 UC1.CB8 UD5.R2 UD6.R2 UD7.R2 UD8.R2
DDR_B_MA9: RD224.1 UC1.CE11 UD5.R7 UD6.R7 UD7.R7 UD8.R7
DDR_B_MA10: RD209.1 UC1.BU7 UD5.M3 UD6.M3 UD7.M3 UD8.M3
DDR_B_MA11: RD215.1 UC1.CB11 UD5.T2 UD6.T2 UD7.T2 UD8.T2
DDR_B_MA12: RD219.1 UC1.CE10 UD5.M7 UD6.M7 UD7.M7 UD8.M7
DDR_B_MA13: RD221.1 UC1.BP9 UD5.T8 UD6.T8 UD7.T8 UD8.T8
DDR_B_MA14: RD203.1 UC1.BU11 UD5.L2 UD6.L2 UD7.L2 UD8.L2
DDR_B_MA15: RD223.1 UC1.BP8 UD5.M8 UD6.M8 UD7.M8 UD8.M8
DDR_B_MA16: RD222.1 UC1.BU10 UD5.L8 UD6.L8 UD7.L8 UD8.L8
DDR_B_ODT0: RD199.1 UC1.BP7 UD5.K3 UD6.K3 UD7.K3 UD8.K3
DDR_B_PARITY: RD208.1 UC1.BV7 UD5.T3 UD6.T3 UD7.T3 UD8.T3
DDR_CHA_EN: RH66.1 RH68.1 UH4.BE39
DDR_CHB_EN: RH67.1 RH69.1 UH4.BD38
DDR_DRAMRST#: RC32.2 RC33.1 UH4.BC14
DDR_DRAMRST#_R: CC139.1 CD111.2 CD112.2 CD113.2 CD114.1 RC33.2 UD1.P1 UD2.P1 UD3.P1 UD4.P1 UD5.P1 UD6.P1 UD7.P1 UD8.P1
DDR_VTT_PG_CTRL: UC1.DH13 UC6.2
DEBUG_TX: JDEG1.9 RE203.2 RE209.2
DGPU_HOLD_RST#: RH657.1 RH658.1 UH4.AL44 UV14.2
DGPU_PWR_EN: DV14.2 DV15.1 R5840.1 RH179.1 RH181.1 UH4.AL36 UZ22.2
DGPU_PWROK: PR1823.1 PR1856.1 PU78.2 QC125.3 RH148.2 RH659.1 UH4.AJ38
DGPU_PWROK_EC: QC125.1 RE433.2 RE437.1 RE438.1 RH659.2
DISPOFF#: DV5.1 JEDP1.35 RV783.1
DMI_CRX_PTX_N0: UC1.AK10 UH4.C27
DMI_CRX_PTX_N1: UC1.AK8 UH4.B28
DMI_CRX_PTX_N2: UC1.AL11 UH4.B29
DMI_CRX_PTX_N3: UC1.AL9 UH4.B30
DMI_CRX_PTX_P0: UC1.AK11 UH4.B27
DMI_CRX_PTX_P1: UC1.AK7 UH4.A28
DMI_CRX_PTX_P2: UC1.AL12 UH4.C29
DMI_CRX_PTX_P3: UC1.AL8 UH4.A30
DMI_CTX_PRX_N0: UC1.AP4 UH4.L27
DMI_CTX_PRX_N1: UC1.AM6 UH4.E24
DMI_CTX_PRX_N2: UC1.AM3 UH4.G27
DMI_CTX_PRX_N3: UC1.AP2 UH4.L29
DMI_CTX_PRX_P0: UC1.AP5 UH4.N27
DMI_CTX_PRX_P1: UC1.AM5 UH4.G24
DMI_CTX_PRX_P2: UC1.AM2 UH4.E26
DMI_CTX_PRX_P3: UC1.AP1 UH4.K29
DPHUB_SMBCLK: JIO1.K6 RE228.1 UE3.F7
DPHUB_SMBDAT: JIO1.J6 RE227.1 UE3.B6
DPMST_LANE: JIO1.N7 UE3.N10
DPSNK_RBIAS: RT23.1 UT2.Y18
DPSRC_RBIAS: RT9.2 UT2.N6
DRVON: PR2250.1 PU1800.32 PU1900.16 PU1901.16 PU2000.16 PU2201.16
EDP_1: JEDP1.19 RR17.2
EDP_2: JEDP1.20 RR16.2
EDP_3: JEDP1.21 RR15.2
EDP_AUXN: CV243.1 UC1.A34
EDP_AUXN_C: CV243.2 RV797.1
EDP_AUXN_R: JEDP1.14 RV797.2
EDP_AUXP: CV244.1 UC1.B34
EDP_AUXP_C: CV244.2 RV800.1
EDP_AUXP_R: JEDP1.13 RV800.2
EDP_COMP: RH37.1 UC1.E44
EDP_DISP_UTIL: RH36.1 UC1.C43
EDP_HPD: RH620.1 RV798.1 UH4.BD7
EDP_HPD_S: JEDP1.32 RV798.2
EDP_TXN0: CV234.1 UC1.B37
EDP_TXN0_C: CV234.2 RV790.1
EDP_TXN0_R: JEDP1.10 RV790.2
EDP_TXN1: CV238.1 UC1.D36
EDP_TXN1_C: CV238.2 RV792.1
EDP_TXN1_R: JEDP1.7 RV792.2
EDP_TXN2: CV240.1 UC1.B36
EDP_TXN2_C: CV240.2 RV794.1
EDP_TXN2_R: JEDP1.4 RV794.2
EDP_TXN3: CV242.1 UC1.E37
EDP_TXN3_C: CV242.2 RV796.1
EDP_TXN3_R: JEDP1.1 RV796.2
EDP_TXP0: CV233.1 UC1.C37
EDP_TXP0_C: CV233.2 RV789.1
EDP_TXP0_R: JEDP1.11 RV789.2
EDP_TXP1: CV237.1 UC1.E36
EDP_TXP1_C: CV237.2 RV791.1
EDP_TXP1_R: JEDP1.8 RV791.2
EDP_TXP2: CV239.1 UC1.A36
EDP_TXP2_C: CV239.2 RV793.1
EDP_TXP2_R: JEDP1.5 RV793.2
EDP_TXP3: CV241.1 UC1.F37
EDP_TXP3_C: CV241.2 RV795.1
EDP_TXP3_R: JEDP1.2 RV795.2
EGND: JFP1.6 R5841.2 R5849.2
EN_0.6V: PC813.1 PR805.2 PR808.1 PU800.16
EN_1.2V: PR814.1 PU800.15
EN_1VALWP: PC712.1 PR703.2 PR704.1 PU700.11
EN_+0.95VSP: PC1011.1 PD1000.2 PR1003.2 PU1000.11
EN_INVPWR: QV9.2 RE161.1 RV787.1 UE3.B2
EN_VDD08: PC3274.1 PR2329.1 PR2334.2 PU2304.11
ENVDD: DV4.1 RZ21.1 UZ6.4
ENVDD_PCH: DV4.3 UE3.N9 UH4.W42
ESPI_ALERT#: RH166.1 UE3.H7 UH4.AW17
ESPI_CLK: RH168.1 UH4.BC17
ESPI_CLK_R: CH84.1 JESPI1.10 RE172.1 RH168.2 RH169.2 UE3.G7
ESPI_CS#: JESPI1.7 UE3.H6 UH4.BE16
ESPI_IO0: JESPI1.3 RH621.2 UE3.K5
ESPI_IO0_R: RH621.1 UH4.AT22
ESPI_IO1: JESPI1.4 RH622.2 UE3.L4
ESPI_IO1_R: RH622.1 UH4.AV22
ESPI_IO2: JESPI1.5 RH623.2 UE3.G6
ESPI_IO2_R: RH623.1 UH4.AT19
ESPI_IO3: JESPI1.6 RH624.2 UE3.L5
ESPI_IO3_R: RH624.1 UH4.BD16
ESPI_RESET#: RE428.2 UE3.K6 UH4.BC18
FB_1VALWP: PC706.2 PR702.2 PR705.1 PU700.14
FB_+0.95VSP: PC1012.2 PR1007.2 PR1009.1 PU1000.14
FB_VDD08: PC3285.2 PR2335.1 PR2336.2 PU2304.14
FGND: JFP1.5 R222.2
FPR__GPIO_DET#: JFP1.8 MD3.3 R5824.2
FPR_DET#: R5824.1 RE265.1 UE3.B3
FPR_SCAN#: R5823.1 RE278.1 RE279.1 UE3.E5
FPR_SCAN#_CONN: JFP1.7 MD3.2 R5823.2
FRS_ON_P1: UPD1.L7 US5.3
FRS_ON_P2: UPD1.L8 US6.3
GPIO_6_REG_HOTB: QC3.1 RH634.2 UC1.V4
GPP_C2_SMBALERT#: RH611.2 UH4.BB41
GPP_C5_SML0ALERT#: RH151.2 UH4.BA40
GPPB_23_SML1ALERT#: RH154.2 UH4.AT27
GPU_ANALOGIO_1: RH541.1 UC1.G8
GPU_ANALOGIO_2: RH542.1 UC1.H37
GPU_AUX_ZVSS: RH482.1 UC1.A6
GPU_B+: PC1900.1 PC1901.1 PC1902.1 PC1903.1 PC1904.1 PC1905.1 PC1910.1 PC1911.1 PC1912.1 PC1913.1 PC1914.1 PC1915.1 PC1920.1 PC1921.1 PC1922.1 PC2000.1 PC2001.1 PC2002.1 PC2003.1 PC2004.1 PC2005.1 PC2010.1 PC2011.1 PC2013.1 PC2014.1 PC2016.1 PC2017.1 PC2020.1 PC2021.1 PL1900.2 PL1901.2 PR1803.1 PU1900.8 PU1900.9 PU1901.8 PU1901.9 PU2000.8 PU2000.9 PU2201.8 PU2201.9
GPU_BP_0: RH534.1 UC1.M1
GPU_BP_0_R: RH534.2 RH536.2
GPU_BP_1: RH535.1 UC1.M2
GPU_BP_1_R: RH535.2 RH537.2
GPU_DBG_DFTIO_0: T551.1(TP-1) UC1.BG35
GPU_DBG_DFTIO_1: T556.1(TP-1) UC1.BJ32
GPU_DP_ZVSS: RH481.1 UC1.B5
GPU_GPIO0: RH486.2 UC1.R2
GPU_GPIO2: RH608.2 UC1.N4
GPU_GPIO11: RH517.2 RH521.2 UC1.U5
GPU_GPIO12: RH522.2 RH527.2 UC1.U4
GPU_GPIO13: RH525.2 RH528.2 UC1.R3
GPU_GPIO15: RH504.2 UC1.R4
GPU_GPIO20: RH505.2 UC1.P5
GPU_GPIO29: RH506.2 UC1.M4
GPU_GPIO_8_ROM_SO: RH488.2 RH492.2 RP88.2 UC1.U1
GPU_GPIO_9_ROM_SI: RH491.2 RH503.2 RP88.4 UC1.W1
GPU_GPIO_10_ROM_SCK: RP88.3 UC1.W2
GPU_GPIO_19_CTF: QC1.2 RH627.1 UC1.P1
GPU_GPIO_19_CTF#: DV10.1 DV12.1 QC1.6 RH614.2
GPU_GPIO_22_ROMCS_N: RH526.2 RP88.1 UC1.V3
GPU_HSYNC: RH494.2 RH524.2 UC1.J1
GPU_I2C_SCL_R: PR1877.1 RH553.2 UC1.J4
GPU_I2C_SDA_R: PR1878.1 RH554.2 UC1.J5
GPU_JTAG_TCK: JDGPU1.3 UC1.V8
GPU_JTAG_TDI: JDGPU1.5 UC1.U8
GPU_JTAG_TDO: JDGPU1.6 UC1.U9
GPU_JTAG_TESTEN: JDGPU1.2 RH530.2 RH531.1 UC1.W9
GPU_JTAG_TMS: JDGPU1.4 UC1.V7
GPU_JTAG_TRST#: JDGPU1.10 RH532.2 RH533.2 UC1.W8
GPU_MACO_EN: T801.1(TP-1) UC1.P42
GPU_MTESTA: T766.1(TP-1) UC1.P41
GPU_OSC_XTAL_OUT: CH240.1 RH567.1 YC1.3
GPU_PCIE_ZVSS: RH480.1 UC1.M44
GPU_PLLCHARZ_H: CH223.1 T778.1(TP-1) UC1.G39
GPU_PLLCHARZ_L: CH224.1 T779.1(TP-1) UC1.H38
GPU_PX_EN: QC1.5 RH628.1 UC1.P44
GPU_PX_EN#: DV11.1 QC1.3 RH613.2
GPU_SMBCLK_Q: QE27.1 RE289.2 RH646.2 UC1.L43
GPU_SMBDAT_Q: QE27.4 RE290.2 RH647.2 UC1.L42
GPU_SMCLK: QE27.6 RE277.1 RH646.1 UE3.D7
GPU_SMDAT: QE27.3 RE276.1 RH647.1 UE3.E7
GPU_SPI_CLK_R1: RP88.6 UC8.6
GPU_SPI_CS_R_N: RH570.2 RP88.8 UC8.1
GPU_SPI_HOLD_N: RH569.2 UC8.7
GPU_SPI_MISO_R1: RP88.7 UC8.2
GPU_SPI_MOSI_R1: RP88.5 UC8.5
GPU_SPI_WP_N: RH607.2 UC8.3
GPU_TEMPIN_RET: RH549.2 UC1.T41
GPU_TEST_PG: RH538.2 UC1.V6
GPU_TEST_PG_BACO: RH539.2 UC1.K42
GPU_VSYNC: RH493.2 RH523.2 UC1.J2
GPU_XTAL_IN: RH567.2 UC1.N46
H_CATERR#: RH48.2 UC1.DH25
H_CPUPWRGD: T834.1(TP-1) UC1.DH23 UH4.AM3
H_PECI_CPU: RH55.2 UC1.DG24
H_PM_DOWN: RH54.1 UH4.AH2
H_PM_DOWN_R: RH54.2 UC1.DD23
H_PM_SYNC_R: RH96.2 UC1.DE22
H_PROCHOT#: PR515.1 PR802.1 PR1120.1 RE158.2 RH50.1 RH51.2 RH589.2 RH633.1
H_PROCHOT#_R: RH50.2 UC1.DF24
H_PROCHOT#_R1: RE158.1 UE3.H13
H_PROCHOT_N_FET: QC7.2 QC7.3 RH605.2
H_PROCHOT_N_R: QC7.6 RH589.1
H_THERMTRIP#: RH94.1 UH4.AJ3
H_THERMTRIP#_R: QE16.3 RH42.2 RH94.2 UC1.DG25
H_VCCST_PWRGD_P: RH45.2 RH52.1 UE7.4
HDA_BIT_CLK: CH81.2 RP6.8 UH4.BA9
HDA_BIT_CLK_R: CH116.1 JIO1.E6 RP6.1
HDA_RST#: CH119.1 T810.1(TP-1) UH4.BD8
HDA_SDIN0: CH120.1 JIO1.H8 UH4.BE7
HDA_SDOUT: CH82.2 CH121.1 RH156.2 RP6.5 UH4.BB7
HDA_SDOUT_R: JIO1.G7 RP6.4
HDA_SYNC: RP6.7 UH4.BD9
HDA_SYNC_R: JIO1.F7 RP6.2
HDD_DET#: RH93.1 UH4.AG39
HOST_DEBUG_TX: JDEG1.8 RE202.2 RE206.2 UE3.G11
HOST_SD_WP#: QR1.2 RH180.2 UH4.AU44
HUB1_LP_CTL: R5831.2 UE3.A12
HUB1_LP_CTL_PCH: R5832.2 RH639.1 RH640.1 UH4.AJ43
HUB1_LP_CTL_R: JIO1.J7 R5831.1 R5832.1
HUB1_RST#: JIO1.H6 UE3.M4
I2C0_SCK_TS: RC184.2 RR16.1 UH4.AR38
I2C0_SDA_TS: RC183.2 RR15.1 UH4.AT42
I2C1_SCK_TP: JKB1.20 UH4.AR41
I2C1_SDA_TP: JKB1.19 UH4.AR44
I2C2_IRQ_TS: QV11.3 RH654.1 UH4.AG43
I2C2_IRQ_TS_Q: QV11.4 RR17.1 RR44.2
I_ADP: PR537.2 UE3.B11
I_BATT: PR536.2 RE125.2
I_BATT_R: CE60.1 RE125.1 UE3.J4
I_LIM_SEL_P1#: QP3.2 RP120.2 UPD1.B8
I_LIM_SEL_P2#: QP4.2 RP123.2 UPD1.B9
I_SYS: PR526.2 PR529.1 PR1136.1 RE126.2
I_SYS_R: CE61.1 RE126.1 RE159.1 UE3.J5
ILMT_1VALWP: PR706.2 PR707.1 PU700.13
ILMT_+0.95VSP: PR1008.2 PR1010.1 PU1000.13
ILMT_VDD08: PR2332.1 PR2333.2 PU2304.13
IMVP_VR_ON_EC: RE293.2 UE3.N7 UZ11.1
IMVP_VR_PG: PR1122.1 UH7.1
INTRUDER#: RH115.1 UH4.BE11
INV_PWM: DV6.1 JEDP1.36 RV786.1
IRCAM_EN: QZ11.2 RE430.1 RE431.1 RH655.1
ISH_I2C0_SCK: RH469.1 RH588.1 UH4.BC38
ISH_I2C0_SCK_R: R373.1 R5838.1 RH469.2 RR34.1
ISH_I2C0_SDA: RH468.1 RH587.1 UH4.BB38
ISH_I2C0_SDA_R: R370.1 R5839.1 RH468.2 RR35.1
JTAG_CLK: JDEG1.4 RPE7.3 UE3.C8
JTAG_RST#: CE63.1 JTAG2.1 RE156.1 RE164.1 UE3.G13
JTAG_TDI: JDEG1.2 RPE7.1 UE3.E9
JTAG_TDO: JDEG1.5 RPE7.4 UE3.F6
JTAG_TMS: JDEG1.3 RPE7.2 UE3.C5
KB_DET#: JKB1.5 RH191.1 UH4.AK45
LAN_WAKE#: RE275.2 RH128.1 UH4.BD11
LAN_WAKE#_R: RE275.1 UE3.L3
LCD_DBC: RH97.1 RH98.1 UH4.U35
LCD_TST: RE160.1 RV788.1 UE3.M2
LCD_VCC_TEST_EN: DV4.2 UE3.E1
LDO_1VALWP: PC711.1 PU700.16 PU700.17
LDO_+0.95VSP: PC1010.1 PU1000.16 PU1000.17
LDO_IN: PC330.1 PD304.1 PD305.1 PD306.1 PD307.1 PD308.1 PR363.1 PU300.1
LDO_VDD08: PC3269.1 PU2304.16 PU2304.17
LID_CL_SIO#: RE259.2 UE3.N11
LID_CL_SIO_TAB#: RE260.2 UE3.E12
LOOP_BACK_OUT#: JIO1.E2 R1.2
LX_1VALWP: PC705.2 PL701.1 PR700.1 PU700.6 PU700.19 PU700.20
LX_+0.95VSP: PC1002.2 PL1001.1 PR1000.1 PU1000.6 PU1000.19 PU1000.20
LX_VDD08: PC3272.2 PL2207.1 PR2328.1 PU2304.6 PU2304.19 PU2304.20
ME_EN: RH156.1 RH157.1 SW1.2
ME_FWP: RH157.2 SW1.3 UE3.G12
ME_SUS_PWR_ACK: RH129.1 RH637.2 UE3.B13
MEC_XTAL1: CE66.1 UE3.A1 YE2.1
MEC_XTAL2: CE67.1 RE178.2 YE2.2
MEC_XTAL2_R: RE178.1 UE3.A3
MEDIACARD_IRQ#: RH113.1 RR7.1 UH4.AL39
MEM_CONFIG0: RH220.1 RH225.2 UH4.AB41
MEM_CONFIG1: RH222.2 RH227.1 UH4.AB42
MEM_CONFIG2: RH224.2 RH226.1 UH4.AB43
MEM_CONFIG3: RH218.2 RH223.1 UH4.AB36
MEM_CONFIG4: RH219.1 RH221.2 UH4.AB39
MOD_ID1: RP66.2 RP67.1 UPD1.L10
MOD_ID2: RP68.2 RP69.1 UPD1.L4
MSATA_DEVSLP: JNGFF2.38 RD17.2 UH4.AG42
MSCLK: JDEG1.6 RE201.2 RE209.1 UE3.H10
MSDATA: JDEG1.7 RE204.2 RE205.1 UE3.G9
NB_LID#: CE71.1 DZ127.1 R5841.1 RE150.2 RE259.1 UE12.3
NB_LID#_R: DZ127.2 RH592.1 UH4.BC22
NB_MODE#: QC123.1 RC10.2 RC101.1 UE3.J8
NB_MODE#_R: QC123.3 RC101.2 RC102.2 RC387.1 UH4.BE21
NB_MUTE#: JIO1.K7 UE3.A4
NGFF_PWREN: R5829.1 RH182.2 UH4.BC27
NRB_BIT: RH197.2 UH4.BD28
PA_USB2_RBIAS: RT42.1 UT2.H19
PANEL_BKEN_EC: DV5.2 UE3.J9
PANEL_BKEN_PCH: DV5.3 UH4.W35
PB_USB2_RBIAS: RT43.2 UT2.F19
PBAT_CHARGER_SMBCLK: PD104.2 PR216.2 PR514.1 RE112.1 UE3.N2
PBAT_CHARGER_SMBDAT: PD104.3 PR217.2 PR513.1 RE111.1 UE3.M3
PBAT_PRES#: PD105.2 PD105.3 PR218.2 PR219.1 PR540.1 UE3.F9
PBTN_SW#: CE103.1 JIO1.M11 R5833.1 RE187.2 RW2.2
PBTN_SW#_APS: R5863.1 RW2.1 SW4.1
PCH_ACC1_INT1: DZ123.2 RH593.1 UH4.BB22
PCH_ACC1_INT1_R: DZ123.1 RR20.1
PCH_ACC2_INT1: DZ124.2 RH594.1 UH4.BD22
PCH_ACC2_INT1_R: DZ124.1 RR21.1
PCH_ALW_ON: RE427.2 RZ57.1 UE3.M8 UZ15.2
PCH_ALW_ON_R: RZ57.2 RZ58.2 UZ3.3
PCH_BATLOW#: RH125.1 UH4.BD13
PCH_CPU_BCLK_N: UC1.Y5 UH4.H2
PCH_CPU_BCLK_P: UC1.Y6 UH4.G2
PCH_CPU_PCIBCLK_N: UC1.Y2 UH4.J1
PCH_CPU_PCIBCLK_P: UC1.Y1 UH4.J2
PCH_DPWROK: RE248.2 RH138.1
PCH_DPWROK_EC: RE248.1 UE3.F8
PCH_DPWROK_R: RH138.2 RH152.2 RH626.2 UH4.AV11
PCH_JTAG_TCK1: TP_JTAG_TCK.1(TP-1) UH4.AN3
PCH_MUTE#: JIO1.A9 UH4.AT44
PCH_PCIE_WAKE#: RE288.2 RH124.1 RH550.1 RT226.1 RT430.2 UE3.L1 UH4.BC13
PCH_PECI: RH95.1 UH4.AL3
PCH_PLTRST#: UH4.BB27 UH5.1 UH5.2
PCH_PLTRST#_5105: RE183.1 UE3.K1 UE13.4
PCH_PLTRST#_EC: JIO1.C1 JNGFF2.50 LED_RST.1 R164.1 RE193.2 RH123.1 RR38.1 RT234.2 UE2.17 UE13.2 UH5.4 UR1.1 UV14.1
PCH_PWROK: RH153.1 UH4.AW11 UH7.4
PCH_RSMRST#: RE155.1 RE177.2 RH137.1
PCH_RSMRST#_R: RH137.2 RH626.1 UH4.BA11
PCH_RTCRST#: CH80.1 CLRC.1 JAPS1.9 R5830.1 RH135.2 UH4.BC10
PCH_RTCX1: RH212.2 UH4.BC9
PCH_RTCX2: RH213.2 UH4.BD10
PCH_RTD3_CIO_PWR_EN: RT19.2 RT34.2 RT420.2 UH4.R39
PCH_RTD3_CIO_PWR_EN_R: RT420.1 UT2.F1
PCH_RTD3_USB_PWR_EN: RT20.2 RT35.2 RT421.2 UH4.AL42
PCH_RTD3_USB_PWR_EN_R: RT421.1 UT2.D4
PCH_SATA_LED#: RH92.1 UH4.AD44
PCH_SPI_CLK: JSPI2.7 RE21.1 RP5.8 UH4.BC31
PCH_SPI_CLK_0_R: RP5.1 UH6.6
PCH_SPI_CS#0: JSPI2.8 RH109.2 UH4.BD31 UH6.1
PCH_SPI_CS#1: T62.1(TP-1) UH4.AW31
PCH_SPI_CS#2: RE22.1 UH4.AT31
PCH_SPI_CS#2_R: RE22.2 UE2.20
PCH_SPI_HOLD#: RH111.2 RH114.2 RH116.2 UH4.BD30
PCH_SPI_HOLD#_0_R: RH116.1 UH6.7
PCH_SPI_SI: JSPI2.5 RC44.1 RE19.1 RP5.7 UH4.BB29
PCH_SPI_SI_0_R: RP5.2 UH6.5
PCH_SPI_SO: JSPI2.6 RE18.1 RP5.6 UH4.BE30
PCH_SPI_SO_0_R: RP5.3 UH6.2
PCH_SPI_WP#: RC21.1 RH110.2 RP5.5 UH4.BC29
PCH_SPI_WP#_0_R: RP5.4 UH6.3
PCH_SRTCRST#: CH79.1 CLRME.1 RH131.2 UH4.BB10
PCH_TBT_FORCE_PWR: RH609.1 UH4.P43
PCH_TBT_PERST#: RH643.1 RH644.1 RT233.2 RT428.1 UH4.BD24
PCH_TPM_CLK_C: RE21.2 RE31.1 UE2.19
PCH_TRIGGER: RH62.1 UH4.AL2
PCH_TRIGGER_R: RH62.2 UC1.B45
PCH_WAKE_GPU_N: RH550.2 UC1.N40
PCH_XDP_CLK_N: T812.1(TP-1) UH4.L1
PCH_XDP_CLK_P: T813.1(TP-1) UH4.L2
PCIE_PRX_C_DTX_N5: CR9.2 UR1.8
PCIE_PRX_C_DTX_P5: CR8.2 UR1.7
PCIE_PRX_C_TTX_N9: CT4.2 UT2.V22
PCIE_PRX_C_TTX_N10: CT21.2 UT2.P22
PCIE_PRX_C_TTX_N11: CT8.2 UT2.K22
PCIE_PRX_C_TTX_N12: CT12.2 UT2.F22
PCIE_PRX_C_TTX_P9: CT2.2 UT2.V23
PCIE_PRX_C_TTX_P10: CT19.2 UT2.P23
PCIE_PRX_C_TTX_P11: CT6.2 UT2.K23
PCIE_PRX_C_TTX_P12: CT10.2 UT2.F23
PCIE_PRX_DTX_N1: JIO1.A3 UH4.H15
PCIE_PRX_DTX_N5: CR9.1 UH4.K19
PCIE_PRX_DTX_N14: JNGFF2.29 UH4.D39
PCIE_PRX_DTX_N15: JNGFF2.17 UH4.F41
PCIE_PRX_DTX_N16: JNGFF2.5 UH4.D43
PCIE_PRX_DTX_P1: JIO1.A4 UH4.G15
PCIE_PRX_DTX_P5: CR8.1 UH4.L19
PCIE_PRX_DTX_P14: JNGFF2.31 UH4.E37
PCIE_PRX_DTX_P15: JNGFF2.19 UH4.E41
PCIE_PRX_DTX_P16: JNGFF2.7 UH4.E42
PCIE_PRX_TTX_N9: CT4.1 UH4.G31
PCIE_PRX_TTX_N10: CT21.1 UH4.G29
PCIE_PRX_TTX_N11: CT8.1 UH4.L31
PCIE_PRX_TTX_N12: CT12.1 UH4.G33
PCIE_PRX_TTX_P9: CT2.1 UH4.H31
PCIE_PRX_TTX_P10: CT19.1 UH4.E29
PCIE_PRX_TTX_P11: CT6.1 UH4.K31
PCIE_PRX_TTX_P12: CT10.1 UH4.H33
PCIE_PTX_C_DRX_N5: CR7.2 UR1.4
PCIE_PTX_C_DRX_N14: CD67.2 JNGFF2.35
PCIE_PTX_C_DRX_N15: CD59.2 JNGFF2.23
PCIE_PTX_C_DRX_N16: CD64.2 JNGFF2.11
PCIE_PTX_C_DRX_P5: CR6.2 UR1.3
PCIE_PTX_C_DRX_P14: CD68.2 JNGFF2.37
PCIE_PTX_C_DRX_P15: CD66.2 JNGFF2.25
PCIE_PTX_C_DRX_P16: CD65.2 JNGFF2.13
PCIE_PTX_C_RD_DRX_N1: CH114.2 JIO1.A6
PCIE_PTX_C_RD_DRX_P1: CH115.2 JIO1.A7
PCIE_PTX_C_TRX_N9: CT95.1 UT2.Y22
PCIE_PTX_C_TRX_N10: CT20.1 UT2.T22
PCIE_PTX_C_TRX_N11: CT7.1 UT2.M22
PCIE_PTX_C_TRX_N12: CT11.1 UT2.H22
PCIE_PTX_C_TRX_P9: CT94.1 UT2.Y23
PCIE_PTX_C_TRX_P10: CT5.1 UT2.T23
PCIE_PTX_C_TRX_P11: CT22.1 UT2.M23
PCIE_PTX_C_TRX_P12: CT9.1 UT2.H23
PCIE_PTX_DRX_N1: CH114.1 UH4.A16
PCIE_PTX_DRX_N5: CR7.1 UH4.D22
PCIE_PTX_DRX_N14: CD67.1 UH4.B38
PCIE_PTX_DRX_N15: CD59.1 UH4.B39
PCIE_PTX_DRX_N16: CD64.1 UH4.A41
PCIE_PTX_DRX_P1: CH115.1 UH4.B16
PCIE_PTX_DRX_P5: CR6.1 UH4.C22
PCIE_PTX_DRX_P14: CD68.1 UH4.C38
PCIE_PTX_DRX_P15: CD66.1 UH4.A39
PCIE_PTX_DRX_P16: CD65.1 UH4.A40
PCIE_PTX_TRX_N9: CT95.2 UH4.C31
PCIE_PTX_TRX_N10: CT20.2 UH4.C32
PCIE_PTX_TRX_N11: CT7.2 UH4.C33
PCIE_PTX_TRX_N12: CT11.2 UH4.B35
PCIE_PTX_TRX_P9: CT94.2 UH4.B31
PCIE_PTX_TRX_P10: CT5.2 UH4.B32
PCIE_PTX_TRX_P11: CT22.2 UH4.B33
PCIE_PTX_TRX_P12: CT9.2 UH4.A35
PCIE_RBIAS: RT7.2 UT2.N16
PCIE_RCOMPN: RH158.2 UH4.B18
PCIE_RCOMPP: RH158.1 UH4.C17
PCIE_WAKE#: JIO1.A10 RD18.2 RE185.2 RE288.1 RT237.2 RT429.2
PCIE_WAKE#_AR: RT27.2 RT242.1 RT429.1 RT430.1 RT431.1 UT2.W1
PCIE_WAKE#_AR_R: RT241.2 RT242.2 U4254.4
PCIE_WAKE#_R: RE127.1 RE185.1 UE3.N13
PD1_LPS1#: JIO1.A2 PQ134.1 PQ205.1 PR114.2
PD2_LPS1#: JIO1.C9 PQ137.1 PQ200.1 PR142.2
PD3_LPS1#: JIO1.P4 PQ201.1 PQ204.1
PD4_LPS1#: JIO1.M12 PQ202.1 PQ203.1
PD_USB20_N1: RP131.1 RP133.1 UPD1.A7
PD_USB20_N1_B: LT4.1 UPD1.C1
PD_USB20_N1_B_R: DT16.1 JUSBC1.A7 LT4.2
PD_USB20_N1_T: LT11.1 UPD1.A2
PD_USB20_N1_T_R: DT19.1 JUSBC1.B7 LT11.2
PD_USB20_N2: RP127.2 RP129.2 UPD1.G11
PD_USB20_N2_B: LT8.1 UPD1.L1
PD_USB20_N2_B_R: DT54.1 JUSBC2.A7 LT8.2
PD_USB20_N2_T: LT10.1 UPD1.H1
PD_USB20_N2_T_R: DT57.1 JUSBC2.B7 LT10.2
PD_USB20_P1: RP130.1 RP132.1 UPD1.A6
PD_USB20_P1_B: LT4.4 UPD1.B1
PD_USB20_P1_B_R: DT20.1 JUSBC1.A6 LT4.3
PD_USB20_P1_T: LT11.4 UPD1.A1
PD_USB20_P1_T_R: DT15.1 JUSBC1.B6 LT11.3
PD_USB20_P2: RP126.2 RP128.2 UPD1.F11
PD_USB20_P2_B: LT8.4 UPD1.K1
PD_USB20_P2_B_R: DT58.1 JUSBC2.A6 LT8.3
PD_USB20_P2_T: LT10.4 UPD1.G1
PD_USB20_P2_T_R: DT53.1 JUSBC2.B6 LT10.3
PECI_EC: RE153.2 RH55.1 RH95.2
PECI_EC_R: RE153.1 UE3.K13
PEG_RCOMP: RH35.2 UC1.AC4
PLTRST_CPU#: UC1.DF23 UH4.AK2
PLTRST_GPU_N: PR2340.1 RZ60.2 RZ61.2 RZ62.1 UC1.K41 UV14.4
POWER_SW_IN#: CE101.1 RE184.2 RE187.1 UE3.D5
PROC_DETECT#: RH56.1 UH4.Y44
PROCHOT_FET_INV: DV9.1 QC7.5
PROCHOT_GPU#: RH606.2 UC10.1 UE3.N6
PROCHOT_XOR_OUT: DV9.2 RH582.2 UC10.4
PROCHOT_XOR_OUT_FET: QC6.2 QC6.3 RH603.2
PWM1: PR1814.1 PU1800.31 PU1900.1
PWM2: PR1812.1 PU1800.29 PU1901.1
PWM3: PR1825.1 PU1800.30 PU2000.1
PWM4: PR1832.1 PU1800.28 PU2201.1
PWM_CORE1: PU1100.43 PU1200.9
PWM_CORE2: PU1100.42 PU1201.9
PWM_CORE3: PU1100.41 PU1202.9
PWM_FAN1: JFAN1.2 RE1.2 UE3.L10
PWM_FAN2: JFAN1.4 RE6.2 UE3.L11
PWM_GT1: PU1100.40 PU1300.9
PWM_GT2: PU1100.39 PU1301.9
PWM_SA: PU1100.38 PU1302.9
PWM_VDD12: PR1861.1 PU1800.27 PU2200.2
REM_DIODE1_N: CE58.1 CE83.2 CE93.2 QE12.3 QE20.1 QE20.2 UE3.A8
REM_DIODE1_P: CE58.2 CE83.1 CE93.1 QE12.1 QE12.2 QE20.3 UE3.A7
REM_DIODE2_N: CE59.1 CE87.2 CE94.2 QE14.3 QE21.1 QE21.2 UE3.A10
REM_DIODE2_P: CE59.2 CE87.1 CE94.1 QE14.1 QE14.2 QE21.3 UE3.A9
REM_DIODE3_N: CE90.1 CE95.2 CE105.2 QE22.3 QE28.1 QE28.2 UE3.B9
REM_DIODE3_P: CE90.2 CE95.1 CE105.1 QE22.1 QE22.2 QE28.3 UE3.B8
REM_DIODE4_N: CE62.1 CE104.2 JIO1.K4 QE23.1 QE23.2 UE3.A11
REM_DIODE4_P: CE62.2 CE104.1 JIO1.H5 QE23.3 UE3.B10
RESET_IN#: RE247.1 UE3.C1
RREF: RR9.2 UR1.9
RSVD: UC1.CD14 UC1.CE33 UC1.CJ14 UC1.CM33
RTCRST_ON: Q3.2 R5851.2 UE3.F11
RTCRST_ON_R: C2.1 D321.2 QRTC1.2 R3.1
RTD3 SELECT: RE429.1 RT238.1 RT239.1 U4253.6 U4254.6
RUN_ON_EC: PR900.1 RE294.2 RZ16.1 UE3.E8 UZ2.3 UZ8.1 UZ23.3
RUN_ON_P: DE2.1 PD1000.1 PR1003.1 RZ23.2 RZ28.1 RZ43.1 UZ10.4 UZ14.4
RUNPWROK: DE2.2 LED_RUN.1 RE180.1 RE292.1 RE296.1 RE297.1 RE299.1 UE3.G3 UH7.2
SATA_PRX_DTX_N0B: JNGFF2.43 UH4.G35
SATA_PRX_DTX_P0B: JNGFF2.41 UH4.E35
SATA_PTX_C_DRX_N0B: CD69.2 JNGFF2.47
SATA_PTX_C_DRX_P0B: CD70.2 JNGFF2.49
SATA_PTX_DRX_N0B: CD69.1 UH4.C36
SATA_PTX_DRX_P0B: CD70.1 UH4.B36
SBIOS_TX: RE206.1 UH4.AV44
SD_CD#: JCR1.9 UR1.30
SD_CLK: CR10.1 JCR1.5 RR3.2
SD_CLK_R: RR3.1 UR1.17
SD_CMD: JCR1.3 RR4.2
SD_CMD_R: RR4.1 UR1.19
SD_D2: JCR1.1 RR6.2
SD_D2_R: RR6.1 UR1.21
SD_D3: JCR1.2 RR5.2
SD_D3_R: RR5.1 UR1.20
SD_LN0_M: JCR1.17 UR1.25
SD_LN0_P: JCR1.16 UR1.26
SD_LN1_M: JCR1.19 UR1.23
SD_LN1_P: JCR1.20 UR1.22
SD_RCLK_M: JCR1.8 RR1.2
SD_RCLK_M_R: RR1.1 UR1.15
SD_RCLK_P: JCR1.7 RR2.2
SD_RCLK_P_R: RR2.1 UR1.16
SD_REG2: CR13.1 UR1.24
SER_IRQ: RH625.1 UH4.BA17
SHD_CS#: RE177.1 UE3.M5
SIO_EXT_SCI#: RH175.2 UH4.AV29
SIO_EXT_SMI#: RH112.1 UH4.AF41
SIO_EXT_WAKE#: RH189.2 UE3.M12 UH4.AN44
SIO_PWRBTN#: R5862.1 UE3.K11 UH4.AT13
SIO_RCIN#: RH167.1 UH4.AT17
SIO_SLP_A#: JAPS1.6 UE3.M11 UH4.BC15
SIO_SLP_S0#: DZ1.2 JAPS1.15 PR1110.1 RE17.1 RE271.1 RZ26.1 UH4.BC26
SIO_SLP_S3#: JAPS1.2 QE13.2 RT16.2 UE3.K9 UH4.AW15 UZ8.2 UZ11.2
SIO_SLP_S4#: JAPS1.5 UE3.N12 UH4.BD15 UZ16.2
SIO_SLP_S5#: DZ1.3 JAPS1.4 RZ42.1 UE3.N8 UH4.BA13
SIO_SLP_SUS#: PR703.1 PR1500.1 QE25.2 RE115.1 RZ58.1 UH4.BB13
SIO_SLP_WLAN#: Q5.1 UH4.AV13
SLP_WLAN#_GATE: Q5.2 R1194.2 UE3.K10
SLP_WLAN#_M: Q5.3 R5828.1
SLP_WLAN#_M_R: JIO1.J11 R5828.2 R5829.2
SM_PG_CTRL: PR805.1 RH59.2 UC6.4
SM_RCOMP0: RC20.1 UC1.AC2
SM_RCOMP1: RC26.1 UC1.AC1
SM_RCOMP2: RC14.1 UC1.AC3
SMBCLK: RH139.2 UH4.AW44
SMBDAT: RH140.2 UH4.BB43
SML1_SMBCLK: RH141.2 UE3.D8 UH4.AW42
SML1_SMBDAT: RH142.2 UE3.E11 UH4.AW45
SNUB_1VALWP: PC700.1 PR700.2
SNUB_+0.95VSP: PC1004.1 PR1000.2
SNUB_CHG1: PC536.1 PR519.2
SNUB_CHG2: PC537.1 PR520.2
SNUB_VDD08: PC3270.1 PR2328.2
SOC_XDP_TDI: RC13.2 TP_JTAG_TDI.1(TP-1) UC1.DC22 UH4.AP2
SOC_XDP_TDO: RC16.2 UC1.DG20 UH4.AP1
SOC_XDP_TMS: RC11.2 TP_JTAG_TMS.1(TP-1) UC1.DC20 UH4.AR2
SOC_XDP_TRST#: TP_PROC_TRSTN.1(TP-1) UC1.DD22 UH4.AY5
SP7_SDWP: QR1.1 RR41.2 UR1.29
SPK_DET#: JIO1.G8 RH174.1 UH4.AV43
SPKR: JIO1.B9 RH136.2 UH4.BD26
SRCCLKREQ1#: RH102.2 UH4.AW24
SRCCLKREQ2#: RH103.2 UH4.AT24
SRCCLKREQ4#: RH645.2 RT236.2 RT431.2 UH4.BB24
SRCCLKREQ5#: RH101.2 UH4.BE25
SRCCLKREQ9#: RP3.6 UH4.BC32
SRCCLKREQ10#: RP3.8 UH4.BB31
SRCCLKREQ11#: RP4.8 UH4.BC33
SRCCLKREQ12#: RP4.6 UH4.BA33
SRCCLKREQ13#: RP4.5 UH4.AW33
SRCCLKREQ14#: RP4.7 UH4.BB33
SRCCLKREQ15#: RP3.5 UH4.BD33
SSD1_PCIE_SATA#: RD58.1 RH90.1 UH4.AG36
SSD_PCIE_WAKE#: JNGFF2.54 RD18.1 RD19.1
SSD_PWR_EN: RZ17.1 RZ20.1 UH4.M44
SSD_SCP#: RD60.2 RE48.1 RE426.1 UE3.H5
SSD_SCP#_R: JNGFF2.8 RD60.1
SUS_ON_EC: RE291.1 UE3.D2 UZ16.1
SUS_ON_EC_P: PR811.1 PR2303.1 RZ37.1 RZ40.1 UZ15.1 UZ16.4 UZ17.1 UZ24.3
SUS_ON_EC_ST: RZ37.2 RZ39.1 UZ7.4 UZ15.4
SUS_ON_P: RZ41.1 RZ45.1 UZ17.4
SUSACK#: RH636.2 UE3.K12
SUSACK#_R: RH636.1 RH638.2 UH4.BB19
SUSCLK: R5861.1 RD20.2 UH4.AN15
SUSWARN#: RH637.1 RH638.1 UH4.BD19
SVC: PR1801.1 PR1808.2 PR1816.2 PU1800.4
SVD: PR1800.1 PR1806.2 PR1810.2 PU1800.2
SVI2_SVC: PR1816.1 UC1.H9
SVI2_SVD: PR1810.1 UC1.H8
SVI2_SVT: PR1815.1 UC1.K8
SVI2_VR_ON: PR1880.1
SVT: PR1807.2 PR1815.2 PU1800.3
SYNC: PU1100.34 PU1200.10 PU1201.10 PU1202.10 PU1300.10 PU1301.10 PU1302.10
SYS_PRES#: BAT100.7 JIO1.D1 R5865.1 SW5.1
SYS_PRES#_1: JIO1.S13 R5822.1
SYS_PWROK: PR1809.1 RE157.1 UE3.G4 UH4.AY1
SYS_PWROK_1: PC3289.1 PR1809.2 PR2337.1 PR2338.2 PR2339.1 PU78.4
SYS_PWROK_2: PR2337.2 PU1800.1
SYS_RESET#: JAPS1.13 RH132.1 UH4.AW1
TAB_LID#: DZ128.1 R130.2 R5834.2 RE260.1 U20.3
TAB_LID#_IO_R: JIO1.E13 R5834.1 R5835.1
TAB_LID#_R: DZ128.2 RH591.1 UH4.BC19
TABLE_MODE#: QC124.1 RC395.2 RE274.2
TABLE_MODE#_R: QC124.3 RC394.1 RH596.1 UH4.BD18
TACH_FAN1: CE1.1 DE1.2 RE2.2 UE3.E3
TACH_FAN1_D: DE1.1 JFAN1.3 RE3.2
TACH_FAN2: CE2.1 DE3.2 RE7.2 UE3.D1
TACH_FAN2_D: DE3.1 JFAN1.5 RE8.2
TBT_A_AUX_N_C: CT49.1 UT2.W15
TBT_A_AUX_P_C: CT47.1 UT2.Y15
TBT_A_CC1: CP10.1 DT11.1 JUSBC1.B5 UPD1.K2
TBT_A_CC2: CP12.1 DT24.1 JUSBC1.A5 UPD1.H2
TBT_A_SBU1: DT23.1 JUSBC1.B8 UPD1.A3
TBT_A_SBU2: DT12.1 JUSBC1.A8 UPD1.A4
TBT_A_TRX_DTX_N1: DT8.1 JUSBC1.A10 UT2.A21
TBT_A_TRX_DTX_N2: DT27.1 JUSBC1.B10 UT2.B15
TBT_A_TRX_DTX_P1: DT4.1 JUSBC1.A11 UT2.B21
TBT_A_TRX_DTX_P2: DT31.1 JUSBC1.B11 UT2.A15
TBT_A_TTX_C_DRX_N1: CT45.2 DT7.1 JUSBC1.B3
TBT_A_TTX_C_DRX_N2: CT41.2 DT28.1 JUSBC1.A3
TBT_A_TTX_C_DRX_P1: CT43.2 DT3.1 JUSBC1.B2
TBT_A_TTX_C_DRX_P2: CT39.2 DT32.1 JUSBC1.A2
TBT_A_TTX_DRX_N1: CT45.1 UT2.B19
TBT_A_TTX_DRX_N2: CT41.1 UT2.B17
TBT_A_TTX_DRX_P1: CT43.1 UT2.A19
TBT_A_TTX_DRX_P2: CT39.1 UT2.A17
TBT_B_AUX_N_C: CT50.1 UT2.W16
TBT_B_AUX_P_C: CT48.1 UT2.Y16
TBT_B_CC1: CP9.2 DT49.1 JUSBC2.B5 UPD1.K9
TBT_B_CC2: CP11.2 DT62.1 JUSBC2.A5 UPD1.K10
TBT_B_SBU1: DT61.1 JUSBC2.B8 UPD1.E1
TBT_B_SBU2: DT50.1 JUSBC2.A8 UPD1.F1
TBT_B_TRX_DTX_N1: DT46.1 JUSBC2.A10 UT2.B13
TBT_B_TRX_DTX_N2: DT65.1 JUSBC2.B10 UT2.A7
TBT_B_TRX_DTX_P1: DT42.1 JUSBC2.A11 UT2.A13
TBT_B_TRX_DTX_P2: DT67.1 JUSBC2.B11 UT2.B7
TBT_B_TTX_C_DRX_N1: CT46.2 DT45.1 JUSBC2.B3
TBT_B_TTX_C_DRX_N2: CT42.2 DT66.1 JUSBC2.A3
TBT_B_TTX_C_DRX_P1: CT44.2 DT41.1 JUSBC2.B2
TBT_B_TTX_C_DRX_P2: CT40.2 DT68.1 JUSBC2.A2
TBT_B_TTX_DRX_N1: CT46.1 UT2.B11
TBT_B_TTX_DRX_N2: CT42.1 UT2.B9
TBT_B_TTX_DRX_P1: CT44.1 UT2.A11
TBT_B_TTX_DRX_P2: CT40.1 UT2.A9
TBT_BATLOW#: RT30.2 RT426.2 UH4.AJ35
TBT_BATLOW#_R: RT426.1 UT2.F2
TBT_CIO_PLUG_EVENT#: RH610.1 RT29.2 UT2.W2
TBT_CIO_PLUG_EVENT#_R: RH610.2 UH4.U41
TBT_DDC_CLK: RT11.2 UT2.Y2
TBT_DDC_DATA: RT13.2 UT2.Y1
TBT_FORCE_PWR: RH609.2 RT33.2 RT427.2 UT2.H4
TBT_I2C_CLK: RT26.2 RT423.2 UPD1.E2
TBT_I2C_CLK_R: RT423.1 UT2.U2
TBT_I2C_DATA: RT25.2 RT422.2 UPD1.D2
TBT_I2C_DATA_R: RT422.1 UT2.U1
TBT_JTAG_TCK: RT4.2 UT2.T4
TBT_JTAG_TDI: RT6.2 UT2.Y4
TBT_JTAG_TDO: RT3.2 UT2.W4
TBT_JTAG_TMS: RT5.2 UT2.V4
TBT_PERST_N: R164.2 RT235.1 RT428.2 UT2.L4
TBT_PERST_N_R: RT235.2 RT240.2 U4253.4
TBT_PWR_EN: RH190.2 UH4.AU43
TBT_RBIAS: RT28.1 UT2.H6
TBT_RESET_N_EC: RE132.1 RT69.1
TBT_RESET_N_EC_R: RE132.2 RE162.1 UE3.L8
TBT_RESET_N_R: RT14.2 RT17.2 RT69.2 UT2.F4
TBT_ROM_CLK: UT2.AB4 UT3.6
TBT_ROM_CS#: RT45.2 UT2.AC3 UT3.1
TBT_ROM_DI: UT2.AB3 UT3.5
TBT_ROM_DO: RT46.2 UT2.AC4 UT3.2
TBT_ROM_HOLD#: RT44.2 UT3.7
TBT_ROM_WP#: RT47.2 UT2.V1 UT3.3
TBT_RSENSE: RT28.2 UT2.J6
TBT_SLP_S3_N: RT16.1 RT84.2 UT2.D2
TBT_SRC_CFG1: R165.1 UT2.AA1
TBT_SRC_HPD: R166.1 T749.1(TP-1) UT2.G1
TBT_SVR_IND: C1115.1 C1116.1 LT1.1 UT2.C1 UT2.C2 UT2.D1
TBT_TEST_EN: RT18.2 UT2.E1
TBT_TEST_PWRG: RT21.2 UT2.AB5
TBT_TMU_CLK_OUT: C1083.1 RT32.2 UT2.V2
TBTA_DPSRC_AUX_N: CT49.2 RP79.2
TBTA_DPSRC_AUX_N_R: RP79.1 RP85.1 UPD1.C11
TBTA_DPSRC_AUX_P: CT47.2 RP78.2
TBTA_DPSRC_AUX_P_R: RP78.1 RP83.1 UPD1.B11
TBTA_I2C_ALERT#: RT31.2 RT424.2 UPD1.F2
TBTA_I2C_ALERT#_R: RT424.1 UT2.J4
TBTA_LSRX: RT38.2 UPD1.A11 UT2.A4
TBTA_LSTX: RT37.2 UPD1.A10 UT2.A5
TBTA_USB2_D_N: RP131.2 UT2.D20
TBTA_USB2_D_P: RP130.2 UT2.E20
TBTB_DPSRC_AUX_N: CT50.2 RP81.1
TBTB_DPSRC_AUX_N_R: RP81.2 RP86.1 UPD1.E11
TBTB_DPSRC_AUX_P: CT48.2 RP80.1
TBTB_DPSRC_AUX_P_R: RP80.2 RP84.1 UPD1.D11
TBTB_I2C_ALERT#: RT100.2 RT425.2 UPD1.G2
TBTB_I2C_ALERT#_R: RT425.1 UT2.E2
TBTB_LSRX: RT41.2 UPD1.L11 UT2.B5
TBTB_LSTX: RT40.2 UPD1.K11 UT2.B4
TBTB_USB2_D_N: RP127.1 UT2.D19
TBTB_USB2_D_P: RP126.1 UT2.E19
TENT_MODE: QC126.1 RC396.2 RE439.2
TENT_MODE_R: QC126.3 RC397.1 RH660.1 UH4.BD21
THERMDA: UT2.AB23 UT2.AC23
THERMTRIP1#: RE124.1 UE3.B12
THERMTRIP2#: CE86.1 QE16.1 RE215.2 UE3.H3
TOUCH_SCREEN_PD#: CH243.1 QV11.6 RH106.1 RH653.2
TOUCH_SCREEN_PD#_Q: JEDP1.17 QV11.1
TOUCH_SCREEN_PD#_R: RH653.1 UH4.AE44
TOUCHPAD_INTR#: DH1.1 JKB1.22 RE252.2
TOUCHPAD_INTR#_D: DH1.2 RH107.1 UH4.BC23
TOUCHPAD_INTR#_R: RE252.1 UE3.G2
TP_DISABLE#: JKB1.23 UE3.F4
TP_EN: JKB1.10 UE3.H9
TP_GPU_XTAL_OUT: T802.1(TP-1) UC1.N45
TP_KBL_G_BH37: RH561.2 UC1.BH37
TP_KBL_G_BJ37: RH562.2 UC1.BJ37
TPM_PIRQ#: RE14.2 UE2.18 UH4.AN38
TS_I2C_RST#: QV10.1 RH656.2 UH4.AR24
TS_I2C_RST#_R: QV10.3 RR40.1 RR43.2
TYPEC_ID: CE78.1 RE196.1 UE3.F2
UART2_RXD: RH178.2 RP97.2 UH4.AR45
UART2_TXD: RH176.2 RP96.2 UH4.AR39
USB3_PRX_MTX_N1: JIO1.B5 UH4.B7
USB3_PRX_MTX_N2: JIO1.C2 UH4.C8
USB3_PRX_MTX_P1: JIO1.C5 UH4.A7
USB3_PRX_MTX_P2: JIO1.D2 UH4.B8
USB3_PTX_MRX_N1: JIO1.D4 UH4.C11
USB3_PTX_MRX_N2: JIO1.F3 UH4.B12
USB3_PTX_MRX_P1: JIO1.E4 UH4.B11
USB3_PTX_MRX_P2: JIO1.G3 UH4.A12
USB3RN4: JDEBUG1.10 UH4.E11
USB3RP4: JDEBUG1.9 UH4.G11
USB3TN4: CH45.1 UH4.A14
USB3TN4_R: CH45.2 JDEBUG1.7
USB3TP4: CH44.1 UH4.B13
USB3TP4_R: CH44.2 JDEBUG1.6
USB20_N1: LV4.1 UH4.AF5
USB20_N1_R: DV7.2 JCAM1.11 LV4.2
USB20_N2: JIO1.A1 UH4.AD5
USB20_N3: RP133.2 UH4.AG8
USB20_N4: RP129.1 UH4.AE1
USB20_N6: JIO1.H4 UH4.AF2
USB20_N8: D429.2 JDEBUG1.4 UH4.AL8
USB20_N10: ML1.1 UH4.AJ8
USB20_N10_FP: DI5.2 JFP1.3 ML1.2
USB20_N11: JIO1.E1 UH4.W2
USB20_P1: LV4.4 UH4.AG7
USB20_P1_R: DV7.3 JCAM1.10 LV4.3
USB20_P2: JIO1.B1 UH4.AD7
USB20_P3: RP132.2 UH4.AG10
USB20_P4: RP128.1 UH4.AE2
USB20_P6: JIO1.J4 UH4.AF3
USB20_P8: D429.3 JDEBUG1.3 UH4.AL7
USB20_P10: ML1.4 UH4.AJ7
USB20_P10_FP: DI5.3 JFP1.4 ML1.3
USB20_P11: JIO1.F1 UH4.W3
USB_ILIM1: RP121.1 RP122.1 US5.11
USB_ILIM2: RP124.1 RP125.1 US6.11
USB_OC0#: JIO1.F9 RH162.1 UH4.AD43
USB_OC1#: JIO1.J10 RH161.1 UH4.AD42
USB_OC2#: CP18.2 RH160.1 UH4.AD39 US5.8
USB_OC3#: CP19.2 RH159.1 UH4.AC44 US6.8
USB_OC4#: RH650.1 UH4.Y43
USB_OC5#: RH649.1 UH4.Y41
USB_OC6#: RH651.1 UH4.W44
USB_OC7#: RH652.1 UH4.W43
VCI_IN2#: RE142.1 UE3.D4
VCI_IN3#: RE244.1 UE3.E4
VCORE_B+: PC1200.1 PC1201.1 PC1202.1 PC1203.1 PC1204.1 PC1205.1 PC1206.1 PC1211.1 PC1212.1 PC1213.1 PC1214.1 PC1215.1 PC1218.1 PC1219.1 PC1221.1 PC1222.1 PC1223.1 PC1226.1 PC1227.1 PC1228.1 PL1201.2 PL1202.2 PR1100.1 PU1200.1 PU1200.8 PU1201.1 PU1201.8 PU1202.1 PU1202.8
VPP25_PG: PR1813.1 PR2317.1 PR2338.1 QE30.2 QE31.2 QE32.2 R1320.1 U15.5
VR_ON: PR1109.1 RZ30.2 RZ36.1 UE7.2
VR_SVID_ALERT#: PR1127.1 RH47.2 RH49.1
VR_SVID_ALERT#_R: RH49.2 UC1.DG22
VR_SVID_CLK: PR1124.1 UC1.DH22
VR_SVID_DATA: PR1129.1 RH46.2 UC1.DF22
VRA_VDD18: PC1101.1 PR1101.2 PU1100.26
VRACPU_VINSEN: PC1100.1 PR1100.2 PR1103.1 PU1100.47
VRACPU_VTEMP: PR1149.1 PU1200.11 PU1201.11 PU1202.11 PU1300.11 PU1301.11 PU1302.11
VSET_5105: CE79.1 RE199.1 UE3.C9
WLAN_WIGIG60GHZ_DIS#: JIO1.M4 RE119.1 UE3.L13
XDP_BPM#0: T724.1(TP-1) UC1.DG19
XDP_BPM#1: T725.1(TP-1) UC1.DF19
XDP_BPM#2: T726.1(TP-1) UC1.DE19
XDP_BPM#3: T727.1(TP-1) UC1.DF20
XDP_ITP_PMODE: TP_ITP_PMODE.1(TP-1) UH4.AT2
XDP_PRDY#: TP_PROC_PRDYN.1(TP-1) UC1.DG23 UH4.AT4
XDP_PREQ#: RH44.2 UC1.DE23 UH4.AT3
XDP_SPI_SI: RC9.2 RC44.2
XTAL24_IN: RH214.2 UH4.A6
XTAL24_OUT: RH215.2 UH4.A5
XTAL_25_IN: RT72.2 UT2.D22
XTAL_25_IN_R: CT38.1 RT72.1 YT1.1
XTAL_25_OUT: RT24.2 UT2.D23
XTAL_25_OUT_R: CT37.1 RT24.1 YT1.3
N12389: PC1224.2 PL1204.1 PL1204.2 PR1205.1 PU1202.2 PU1202.3 PU1202.4
N12481: PC1225.1 PR1205.2
N12559: PC1220.1 PC3259.1 PR1204.2 PU1202.14
N12635: PC1224.1 PU1202.15
N25790: PC1316.2 PL1303.1 PL1303.2 PR1303.1 PU1301.2 PU1301.3 PU1301.4
N25814: PC1317.1 PR1303.2
N25900: PC1309.1 PR1302.2 PU1301.14
N25968: PC1316.1 PU1301.15
N29706: PC1325.2 PL1305.1 PR1305.1 PU1302.2 PU1302.3 PU1302.4
N54708: PC1307.2 PL1301.1 PL1301.2 PR1301.1 PU1300.2 PU1300.3 PU1300.4
N54789: PC1208.2 PL1200.1 PL1200.2 PR1201.1 PU1200.2 PU1200.3 PU1200.4
N54830: PC1216.2 PL1203.1 PL1203.2 PR1203.1 PU1201.2 PU1201.3 PU1201.4
N104691: PC1105.2 PR1134.2 PR1136.2 PU1100.46
N18408062: T79.1(TP-1) UE3.D6
N19473413: PC2302.2 PR2302.2 PR2304.1 PU2300.4
N19473637: PC2302.1 PC2303.1 PR2300.1 PR2302.1 PU2300.1 PU2300.2 PU2300.3
N29436789: PC1209.1 PR1201.2
N30818241: RD195.1 UD5.F9
N30818347: RD194.1 UD6.F9
N30820408: RD196.1 UD7.F9
N30820514: RD197.1 UD8.F9
N30927710: CD324.2 RD229.1
N39070459: QE13.3 RE219.1 RE222.2
N39070470: QE16.2 RE219.2
N44325406: RE154.1 RE251.1 UE3.B1
N44325565: RE115.2 UE3.N4
N44325691: CE65.1 RE172.2
N46619932: PC1102.1 PR1102.2 PU1100.44
N46621117: PR1131.1 PU1100.6
N46621120: PR1131.2 PR1135.1 PU1100.7
N46621397: PC1106.1 PR1135.2
N46621424: PR1137.1 PU1100.8
N46621427: PR1140.1 PU1100.9
N46621964: PC1107.1 PR1144.2
N46621983: PR1142.1 PU1100.10
N46621986: PR1142.2 PR1144.1 PU1100.11
N46622191: PR1145.1 PU1100.12
N46622194: PR1147.1 PU1100.13
N46622340: PC1103.2 PR1108.2 PR1109.2 PU1100.37
N46622659: PR1107.2 PR1110.2 PU1100.35
N46622666: PR1106.2 PR1113.2 PU1100.33
N46622669: PR1105.2 PR1114.2 PU1100.32
N46623252: PR1112.2 PR1129.2 PR1130.1
N46623254: PR1116.2 PR1127.2 PR1128.1
N46623256: PR1111.2 PR1124.2 PR1125.1
N46623799: PR1104.2 PR1122.2 PU1100.30
N46624101: PR1125.2 PU1100.27
N46624104: PR1128.2 PU1100.29
N46624128: PR1130.2 PU1100.28
N46624575: PR1115.2 PR1120.2 PU1100.31
N46625447: PR1132.2 PR1133.2 PU1100.25
N46626546: PR1138.2 PR1141.2 PU1100.36
N46626820: PR1139.2 PU1100.24
N46626937: PC1108.2 PR1143.2 PU1100.21
N46627867: PC1109.2 PR1146.2 PU1100.22
N46628199: PC1110.2 PR1148.2 PU1100.23
N46634435: PC1111.1 PR1149.2 PR1152.1 PU1100.45
N46635062: PR1151.1 PU1100.14
N46635065: PR1151.2 PR1154.1 PU1100.15
N46635193: PC1112.1 PR1154.2
N46635895: PR1150.1 PU1100.16
N46635936: PR1153.1 PU1100.17
N46642076: PC1207.1 PC3257.1 PR1200.2 PU1200.14
N46643804: PC1208.1 PU1200.15
N46645025: PC1217.1 PR1203.2
N46645111: PC1210.1 PC3258.1 PR1202.2 PU1201.14
N46645235: PC1216.1 PU1201.15
N46647976: PC1308.1 PR1301.2
N46648066: PC1306.1 PR1300.2 PU1300.14
N46648174: PC1307.1 PU1300.15
N46648306: PC1326.1 PR1305.2
N46648510: PC1325.1 PU1302.15
N46648536: PC1324.1 PC3260.1 PR1304.2 PU1302.14
N55155823: CV231.2 QV8.3 RV784.2 RV785.1
N55155827: CV232.1 QV8.1 QV8.2 QV8.5 QV8.6 RV808.1
N55155843: QV9.1 RV785.2
N120109057: CH76.1 RH99.2 RH213.1 YH1.2
N120109063: CH75.1 RH99.1 RH212.1 YH1.1
N120109283: CH77.1 RH105.1 RH214.1 YH2.1
N120109300: CH78.1 RH105.2 RH215.1 YH2.3
N120139517: RH100.2 UH4.E1
N120176782: T59.1(TP-1) UH4.L43
N120176822: T60.1(TP-1) UH4.BD36
N120177456: T61.1(TP-1) UH4.BD17
N120361841: RZ10.1 UZ3.7 UZ3.8
N120361881: CZ11.1 UZ3.6
N121070696: RH163.1 UH4.AG3
N121388945: RH96.1 UH4.AJ4
N122282431: RR10.1 UR1.28
N122517438: RH155.2 SW1.1
N122687725: RZ23.1 RZ29.1 UZ8.4 UZ10.1
N122739033: RZ26.2 UZ10.2
N122739334: RZ30.1 UZ11.4
N122754331: RZ44.1 UZ18.7 UZ18.8
N122754354: CZ31.1 UZ18.6
N122755391: CZ27.1 RZ38.2 UZ14.6
N122912247: CZ20.1 RZ22.1 UZ7.6
N124817422: RH164.1 UH4.AD10
N124817429: RH165.1 UH4.AG2
N125742089: RH117.1 RH118.1 UH5.5
N125836022: RZ43.2 RZ45.2 UZ18.3
N125857121: RZ19.1 UZ6.1
N125861425: QZ9.1 RZ49.1
N126729390: DZ1.1 RZ42.2 UZ17.2
N127291407: CZ14.1 UZ4.6
N127291517: RZ11.1 UZ4.7 UZ4.8
N132190101: PC2304.1 PR2306.2 PR2307.2 PU2300.6
N132200507: PR1002.1 PR1013.2 PU1000.9
N132200681: PR1009.2 PR1011.1 PR1012.1
N132200732: PR1004.2 PR1006.1 PR1007.1
N132640197: PC535.1 PR516.1 PU501.3
N132640209: PD501.1 PR530.2 PR553.1
N132640228: PC530.2 PR510.2
N132640229: PR524.1 PU501.27
N132640234: PD505.1 PR508.1
N132640241: PR525.2 PU501.26
N132640248: PC543.1 PR536.1 PR537.1 PR538.2
N132640310: PR542.2 PU501.24
N132640368: PC525.1 PR505.1
N132640406: PC542.1 PR527.2
N132640440: PR500.3 PR502.1
N132640444: PR500.2 PR503.1
N132640459: PR511.2 PR521.1
N132937298: PC611.1 PR602.2
N132937413: PC635.1 PR615.2
N132938140: PR613.2 PU602.12
N132938170: PC634.1 PR616.2 PU602.9
N132938202: PR614.1 PU602.8
N132938321: PC600.1 PR601.2
N132938373: PR610.1 PR626.1 PU601.3
N132938377: PR607.2 PU601.12
N132938389: PC622.1 PR610.2 PU601.9
N132938405: PC612.1 PR608.2
N132940037: PC814.1 PR806.2 PR810.2 PU800.3
N132940047: PR800.1 PU800.10
N132940049: PC800.1 PR800.2
N132940086: PC801.1 PR801.2
N132940160: PC815.1 PD800.2 PR812.1 PR813.2 PR814.2
N132946479: PC610.1 PU600.9
N132946501: PC623.1 PR609.2
N132946510: PR600.2 PU600.12
N132946538: PR616.1 PR627.1 PU602.3
N132946554: PC624.1 PR614.2
N132946567: PR601.1 PU600.8
N132946609: PR608.1 PU601.8
N132948439: PC812.1 PU800.7
N132948454: PR809.1 PU800.14
N133127797: PC647.1 PR621.2
N133127826: PR622.1 PR629.1 PU603.3
N133127858: PC636.1 PR620.2
N133127913: PC646.1 PR622.2 PU603.9
N133127927: PR619.2 PU603.12
N133127941: PR620.1 PU603.8
N133318440: PC114.2 PQ111.4 PQ112.1 PR128.2 PR131.1
N133318479: PQ112.2 PR127.2 PR129.1
N133318745: PQ144.2 PQ217.5 PR136.2
N133320954: PC124.2 PQ113.4 PQ116.1 PR137.2 PR144.1
N133320966: PC125.2 PQ114.4 PQ117.1 PR138.2 PR140.1
N133321002: PQ139.5 PR151.2 PR155.1 PR276.2
N133321875: PC100.2 PQ100.4 PQ101.1 PR101.2 PR104.1
N133321877: PQ143.2 PQ216.5 PR110.2
N133362817: PC141.1 PD103.1 PQ132.1 PR167.1 PR169.2 PR182.1 PU100.3
N133362852: PQ146.6 PR152.2 PR157.1 PR159.1
N133362857: PR166.2 PR183.1 PU100.1
N133362865: PQ147.6 PR160.1
N133362867: PC140.1 PD102.1 PQ133.1 PR171.2 PR173.1 PR184.1 PU101.3
N133362892: PR172.2 PR185.1 PU101.1
N133362902: PC136.1 PD102.2 PR173.2 PR174.1 PR233.2 PU101.4
N133362952: PQ149.6 PR162.1
N133362963: PQ150.1 PQ150.3 PR179.1
N133362990: PC138.1 PD103.2 PR167.2 PR168.1 PR234.2 PU100.4
N133363065: PQ117.2 PR133.2 PR141.1
N133363071: PQ139.2 PQ139.3 PR145.2
N133363075: PQ139.6 PR141.2
N133363089: PQ154.5 PR143.1 PR147.2
N133363108: PQ116.2 PR132.2 PR142.1
N133363166: PQ105.2 PR105.2 PR114.1
N133363167: PQ136.2 PQ136.3 PR116.2
N133363171: PQ106.2 PR106.2 PR113.1
N133363182: PQ155.5 PR119.1 PR121.2
N133363184: PC112.2 PQ103.4 PQ106.1 PR109.2 PR112.1
N133363191: PC111.2 PQ102.4 PQ105.1 PR108.2 PR118.1
N133363327: PQ152.1 PQ152.3 PR202.1
N133363328: PQ152.6 PR192.1
N133363339: PQ153.1 PQ153.3 PR203.1
N133363347: PQ153.6 PR193.1
N133363373: PQ101.2 PR100.2 PR102.1
N133567403: PR511.3 PR522.1
N134295234: CV248.1 D74.1 JEDP1.18 RR38.2 RR40.2
N134421677: JEDP1.28 RV788.2
N134515266: CP6.2 UPD1.B10
N134825470: PD106.1 PD107.1 PR233.1
N134826142: PD108.1 PD109.1 PR234.1
N134840260: PQ202.2 PR242.2
N134840264: PQ203.2 PR239.2
N134840348: PQ205.2 PR237.2
N134840369: PQ204.2 PR238.2
N134840540: PQ201.2 PR241.2
N134860679: PQ155.2 PR122.2 PR170.1
N134862674: PQ154.2 PR125.2 PR175.1
N134862705: PQ154.6 PR144.2
N134867729: PC546.1 PR539.1 PR540.2 PU501.25
N134888832: PQ200.2 PR240.2
N136079318: PC1807.2 PC1809.1 PR1827.1 PR1830.2 PR1833.1 PU1800.48
N136079319: PC1808.2 PC1809.2 PU1800.47
N136079320: PC1800.1 PR1802.2 PU1800.11
N136079322: PC1826.2 PC1827.2 PR1867.1 PR1869.2 PU1800.24
N136079323: PC1803.2 PC1805.2 PR1817.1 PR1818.2 PU1800.34
N136079324: PC1804.2 PR1820.2 PU1800.5
N136079325: PR1826.1 PR1830.1 PU1800.50
N136079327: PC1801.2 PR1803.2 PU1800.13
N136079328: PC1811.2 PR1834.1 PR1836.2 PR1838.2 PU1800.39
N136079329: PC1815.1 PC1816.1 PH1800.1 PR1843.1 PR1848.2 PR1851.2 PR1853.1 PU1800.44
N136079332: PC1802.2 PR1813.2 PR1880.2 PU1800.10
N136079336: PC1806.2 PR1821.1 PR1822.2 PU1800.38
N136079340: PC1807.1 PR1826.2
N136079349: PC1808.1 PR1827.2
N136079350: PC1819.2 PR1854.2 PR1855.2 PR1857.2 PR1858.2 PU1800.41
N136079351: PC1812.2 PC1813.2 PR1840.2 PU1800.51
N136079355: PC1826.1 PC1827.1 PH1801.1 PR1868.1 PR1871.2 PR1875.2 PR1876.1 PU1800.22
N136079371: PR1823.2 PU1800.9
N136079373: PR1856.2 PU1800.8
N136079381: PC1812.1 PC1814.2 PR1842.2 PU1800.52
N136079383: PC1806.1 PR1822.1 PR1824.2 PU1800.37
N136079389: PC1805.1 PR1818.1 PR1819.2 PU1800.33
N136079393: PC1820.2 PC1822.1 PR1860.1 PR1862.2 PR1864.1 PU1800.16
N136079397: PH1801.2 PR1868.2 PR1869.1
N136079415: PC1815.2 PC1816.2 PR1841.1 PR1844.2 PR1845.1 PR1847.1 PR1849.1 PU1800.43
N136079430: PR1878.2 PU1800.7
N136079431: PR1877.2 PU1800.6
N136079436: PC1823.2 PC1824.2 PR1863.2 PU1800.26
N136079438: PC1823.1 PR1866.1 PU1800.25
N136079473: PR1879.2 PU1800.12
N136079494: PC1825.2 PR1870.2 PU1800.15
N136079497: PC1821.2 PC1822.2 PU1800.19
N136079500: PR1859.1 PR1862.1 PU1800.17
N136079512: PC1821.1 PR1860.2
N136079514: PC1820.1 PR1859.2
N136079517: PC1817.2 PR1850.1 PU1800.42
N136079518: PC1828.2 PR1872.1 PU1800.23
N136079531: PC1811.1 PR1836.1 PR1837.2 PR1839.1 PU1800.40
N136079564: PH1800.2 PR1843.2 PR1844.1
N136079606: PC1810.1 PR1829.1 PR1831.2 PU1800.35
N136079607: PC1810.2 PR1828.1 PR1829.2 PU1800.36
N136081679: PC1909.2 PR1902.1
N136082763: PC2009.2 PR2002.1
N136142149: PQ199.1 PR122.1 PR246.1
N136143941: PQ199.3 PR247.2 PR248.1
N136149398: PQ213.1 PR125.1 PR254.1
N136149487: PQ213.3 PR255.2 PR257.1
N136513978: JFP1.2 R5833.2 R5837.2
N136517178: JNGFF2.60 RD20.1
N136517525: JNGFF2.61 RD58.2 RD59.2
N137153189: PC332.1 PQ322.1 PR363.2 PR367.1 PU300.4
N137153201: PC331.1 PR354.1 PU300.5
N137153247: PC341.1 PQ325.2 PR375.1 PR378.1
N137153255: PC341.2 PQ325.3 PQ328.3 PR375.2 PR383.1 PR384.2
N137153265: PC342.1 PQ330.5 PR392.2
N137153271: PQ328.2 PQ330.2 PR384.1 PR389.1
N138665035: R1090.1 U18.2
N139457740: PC2207.2 PR2202.1
N139473162: QE25.5 QE25.6 R116.2
N139473177: QE25.3 R115.2
N139718579: RH56.2 UC1.DF25
N139726036: RH228.1 RH467.2 UC1.CW46
N139733440: RH74.1 RH75.1 UC1.CD46
N139735474: RH76.1 RH77.1 UC1.CD45
N139809782: RH80.2 RH81.1 UC1.DA45
N139810461: RH465.1 RH466.1 UC1.CW45
N139810762: T117.1(TP-1) UC1.AC6
N139810763: T118.1(TP-1) UC1.AC5
N139810764: T119.1(TP-1) UC1.AB6
N139810769: RH559.2 UC1.Y4
N139810770: RH560.2 UC1.Y3
N139810780: RH540.2 UC1.M41
N139885150: RH78.2 RH79.1 UC1.DA46
N140304666: PC2208.1 PR2251.2 PU2200.4
N140390697: RC21.2 XDP_SPI_IO2.1(TP-1)
N140856784: RD157.1 UD1.F9
N140856890: RD158.1 UD2.F9
N140858392: RD164.1 UD3.F9
N140858498: RD163.1 UD4.F9
N140860614: CD291.2 RD159.1
N141215433: PR1506.1 PU1500.4
N141215514: PR906.1 PU900.4
N141299283: PR2250.2 PU2200.3
N142043368: PD509.2 PR549.2
N142043371: PD508.2 PR548.2
N142043374: PD506.2 PR544.2
N142043377: PD500.2 PR543.2
N142043380: PD500.1 PD506.1 PD508.1 PD509.1 PR552.1 PR555.2 PU503.1
N142043409: PR545.2 PR554.1 PU503.2
N142043653: PR546.1 PU503.4
N142748714: PR624.2 PR628.2 PU600.3
N142919796: CZ17.1 UZ5.6
N142919801: RZ18.1 UZ5.7 UZ5.8
N142919814: RZ16.2 RZ17.2 UZ5.3
N142976385: BAT100.4 PR216.1
N142999005: PC1829.1 PR1876.2 PU1800.21
N142999049: PC1829.2 PR1875.1
N143000945: PC1818.1 PR1853.2 PU1800.45
N143001150: PC1818.2 PR1851.1
N143002608: PR1871.1 PU1800.20
N143002632: PR1848.1 PU1800.46
N143012284: PL500.1 PR500.1
N143161530: QH1.3 RL1.1
N143162018: Q4.1 RL5.1
N143162021: QH2.6 RL4.1
N143162024: QH2.3 RL3.1
N143162027: QH1.6 RL2.1
N143222923: PC905.1 PR903.2
N143225221: PC1505.1 PR1503.2
N143441121: CH223.2 RH547.1
N143441124: CH224.2 RH548.1
N143441520: T780.1(TP-1) UC1.B9
N143441540: T781.1(TP-1) UC1.C9
N143487757: RH38.1 UC1.K38
N143514000: RH568.2 YC1.1
N143614360: PR2301.1 PR2305.1 PU2300.5
N144321040: BAT100.5 PR217.1
N144321105: BAT100.6 PR218.1
N144552000: RTCD1.1 RTCR2.1
N144553377: C3007.1 U736.6
N144678545: QC6.5 RH604.2
N144683203: QC2.5 RH600.2
N144759893: PC502.1 PR550.2
N144759896: PC501.1 PR551.2
N144829640: T816.1(TP-1) UC1.DH45
N144830107: T817.1(TP-1) UC1.DG46
N145583891: PC503.1 PL502.2
N146334871: RZ7.1 UZ2.7 UZ2.8
N146334885: CZ3.1 UZ2.6
N146336831: RZ8.1 UZ23.7 UZ23.8
N146336845: CZ4.1 UZ23.6
N146376252: RE271.2 UE2.3
N146376256: RE27.2 RE29.1 UE2.4
N146376264: RE17.2 UE2.29
N146376360: RE19.2 UE2.21
N146376362: RE18.2 UE2.24
N146376375: RE23.2 UE2.27
N146376404: CE12.1 RE31.2
N146468390: T52.1(TP-1) UH4.AG35
N146468421: T53.1(TP-1) UH4.AD35
N146468481: T54.1(TP-1) UH4.AD31
N146468484: T55.1(TP-1) UH4.AD38
N146468556: T67.1(TP-1) UH4.AJ33
N146468597: T49.1(TP-1) UH4.R44
N146726464: JCCG1.8 RP96.1
N146726467: JCCG1.9 RP97.1
N146924879: CH237.1 RH573.2 RH574.1 UC9.2
N146924926: RH575.1 UZ22.4
N146931353: T824.1(TP-1) UC1.B46
N146931355: T825.1(TP-1) UC1.C46
N146931673: T826.1(TP-1) UC1.C1
N146931999: T827.1(TP-1) UC1.B2
N146932713: T829.1(TP-1) UC1.A4
N146932715: T828.1(TP-1) UC1.A3
N146933033: T822.1(TP-1) UC1.A44
N146933035: T823.1(TP-1) UC1.A45
N146940805: T818.1(TP-1) UC1.DG2
N146940807: T819.1(TP-1) UC1.DG3
N146940809: T820.1(TP-1) UC1.DF1
N146940811: T821.1(TP-1) UC1.DF2
N146941849: T814.1(TP-1) UC1.DH43
N146941851: T815.1(TP-1) UC1.DH44
N146979809: R95.1 U14.8 U14.9
N146979831: C99.1 U14.10
N146979833: R93.1 U14.13 U14.14
N146979857: C97.1 U14.12
N146979907: C3023.1 R1319.1 R1321.1 U15.2 U15.3
N146979931: R1321.2 R1322.1 U15.4
N146979951: DV11.2 DV12.2 R1323.2 U15.6
N146980009: C3313.1 DV14.1 R5840.2 U14.3 U14.5
N147032589: PQ216.6 PR104.2 PR264.1
N147034069: PQ217.6 PR131.2 PR266.1
N147095163: PR708.1 PU700.9
N147128984: PR901.2 PR907.2 PU900.3
N147189904: PR1507.2 PU1500.3
N147237479: PD2300.2 PR2303.2 PR2307.1
N147237510: PD2300.1 PR2306.1
N147264426: PD800.1 PR811.2
N147648876: LED_RST.2 R531.2
N147648878: LED_RUN.2 R530.2
N148537289: RD231.2 UD2.E9
N148539009: RD230.2 UD1.E9
N148539686: RD232.2 UD3.E9
N148539959: RD233.2 UD4.E9
N148540239: RD234.2 UD5.E9
N148540518: RD235.2 UD6.E9
N148541018: RD236.2 UD7.E9
N148541530: RD237.2 UD8.E9
N148566755: RD238.1 RD239.1 UD1.M9
N148569917: RD240.1 RD241.1 UD2.M9
N148572207: RD242.1 RD243.1 UD3.M9
N148574907: RD244.1 RD245.1 UD4.M9
N148577773: RD246.1 RD247.1 UD5.M9
N148578659: RD248.1 RD249.1 UD6.M9
N148580948: RD250.1 RD251.1 UD7.M9
N148582662: RD252.1 RD253.1 UD8.M9
N148592439: PR1900.1 PU1900.5
N148592442: PC1907.2 PR1900.2
N148592463: PC1907.1 PU1900.7
N148593135: PC1906.1 PR1901.1 PU1900.3
N148594236: PU1900.13 PU1900.19
N148596615: PC1919.2 PR1905.1
N148597432: PR1904.1 PU1901.5
N148597434: PC1917.2 PR1904.2
N148597440: PC1917.1 PU1901.7
N148597468: PC1916.1 PR1903.1 PU1901.3
N148597527: PU1901.13 PU1901.19
N148599110: PR2000.1 PU2000.5
N148599112: PC2007.2 PR2000.2
N148599118: PC2007.1 PU2000.7
N148599146: PC2006.1 PR2001.1 PU2000.3
N148599205: PU2000.13 PU2000.19
N148600854: PR2204.1 PU2201.5
N148600856: PC2018.2 PR2204.2
N148600862: PC2018.1 PU2201.7
N148600909: PC2015.1 PR2203.1 PU2201.3
N148600976: PU2201.13 PU2201.19
N148601051: PC2019.2 PR2205.1
N148672855: C4.1 D321.1 QRTC.2 R3.2 R277.1 R5851.1
N148672909: QRTC1.1 R276.2
N148880847: LED7.2 RW1.2
N149074452: JESPI1.8 RE193.1 RE428.1
N149118427: LED_PRI.2 R532.2
N149279356: PR555.1 PT501.1(TP-1)
N149282761: RP102.2 UPD1.H11
N149282764: RP103.2 UPD1.J11
N149282893: RP104.1 UPD1.A8
N149282896: RP105.1 UPD1.A9
N149284474: RTCD2.1 RTCR1.1
N149439645: QP1.1 RP110.2
N149440260: QP2.1 RP111.2
N149551327: JIO1.E8 R5861.2
N149709154: QC3.3 RH633.2
N149709174: QC3.2 RH635.2
N150381253: Q3.1 R5830.2
N150410925: CP15.1 US5.5
N150410947: CP14.2 US5.10
N150411001: RP112.2 US5.12
N150411007: RP114.2 US5.9
N150411478: CP17.1 US6.5
N150411512: CP16.2 US6.10
N150411564: RP115.2 US6.12
N150411570: RP117.2 US6.9
N150412363: RP143.1 UC4.4 US5.2
N150412421: RP144.1 UC5.4 US6.2
N150849033: R5836.1 UZ24.7 UZ24.8
N150886581: C3311.1 UZ24.6
N150930373: QP3.1 RP121.2
N150931521: QP4.1 RP124.2
N151109456: PQ146.5 PR161.1
N151119190: PQ155.6 PR118.2
N151119548: PQ155.3 PR112.2
N151120235: PQ136.5 PR123.2 PR126.1 PR275.2
N151120414: PQ136.6 PR113.2
N151122655: PQ154.3 PR140.2
N151130119: PQ146.2 PR158.2
N151130610: PQ147.2 PR159.2 PR161.2
N151131381: PQ149.2 PR164.2
N151131403: PQ149.1 PQ149.3 PR178.2
N151132228: PQ149.5 PR186.2
N151132921: PQ150.6 PR163.1
N151132926: PQ150.2 PR165.2
N151132940: PQ150.5 PR187.2
N151133179: PQ152.2 PR195.2
N151134696: PQ153.2 PR196.2
N151134710: PQ153.5 PR212.2
N151134873: PQ152.5 PR209.2
N151135547: PQ330.6 PR378.2
N151135923: PQ330.3 PR389.2
N151224419: QE30.5 QE30.6 R5843.2
N151224429: QE30.3 R5848.2
N151224638: QE31.5 QE31.6 R5845.2
N151224640: QE31.3 R5850.2
N151224855: QE32.5 QE32.6 R5847.2
N151224873: QE32.3 R5846.2
N151327329: RE274.1 UE3.H8
N151525675: RT233.1 U4253.1
N151525680: RT234.1 U4253.3
N151525769: RT226.2 RT236.1 U4254.1
N151525780: RT237.1 U4254.3
N151529874: RE429.2 UE3.L9
N151793519: JAPS1.7 R5854.2 R5855.2
N151793539: JAPS1.3 R5852.2 R5853.2
N151919506: LP1.2 UP1.B1
N151919537: RP137.1 RP138.2 UP1.C2
N151922365: LP2.2 UP2.B1
N151922410: RP139.1 RP140.2 UP2.C2
N152653463: RE430.2 UE3.K7
N152653999: RH655.2 UH4.AE45
N153236284: PQ132.2 PR189.1
N153237165: PQ133.2 PR188.1
N153246077: PQ134.2 PR120.2
N153246648: PQ199.2 PR249.1
N153246695: PQ213.2 PR256.1
N153247080: PQ137.2 PR258.2
N153247431: PQ143.1 PR102.2
N153248104: PQ144.1 PR129.2
N153256887: RE433.1 UE3.G5
N153257573: RE434.1 UE3.L6
N153586557: Q6.3 SW5.3
N153659070: Q6.1 R5859.2
N153659804: Q6.2 R5858.2 R5860.2
N153786804: T831.1(TP-1) UE3.L2
N153786824: T832.1(TP-1) UE3.M1
N153786852: T833.1(TP-1) UE3.J10
N153948494: JAPS1.11 R5862.2 R5863.2
N154167476: PR2311.2 PR2313.1 PR2316.1
N154167480: PR2320.2 PR2321.2 PU4255.9
N154167794: PR2312.1 PR2315.1 PR2319.2
N154167819: PC3266.1 PR2308.2
N154167903: PC3287.1 PU4255.8
N154224423: PR2331.1 PU2304.9
N154411599: CV245.2 QV12.4 RV810.1 RV811.2
N154411647: QV13.1 RV810.2
N154419141: QV13.2 R5864.2
N154450732: C3314.2 QZ10.4 R5867.2 R5868.1
N154450766: QZ11.1 R5868.2
N154827175: RE439.1 UE3.D9
N155024407: PR2340.2 PU78.1
N155489719: JIO1.R13 R5869.1
N155489761: JIO1.R12 R5870.1
N1557527231: PR267.2 PU102.2
N1557528950: PR271.2 PU2302.2
N1557533360: PR269.2 PU2301.2
N1557544241: PR273.2 PU2303.2
