# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_A_TTX_C_DRX_P2: length 24.9
  TOP w0.145: v9(21.92,81.96) 21.7,82.08 21.69,82.08 21.6,82.13 arc(21.58,82.14) 21.57,82.15 21.1,82.44 arc(19.61,83.34) 17.9,83.66 arc(17.87,83.66) 17.83,83.66 17.81,83.67 arc(16.84,83.96) 16.02,84.55 15.44,85.13 arc(14.31,85.89) 12.97,86.15 11.55,86.15 arc(11.42,86.18) DT32.1 11.15,86.09 arc(11.1,86.06) 11.04,86.05 10.96,86.05 arc(10.71,86) 10.5,85.85 10.44,85.79 arc(10.27,85.54) 10.21,85.25 10.21,85.21 arc(10.16,84.97) 10.03,84.77 arc(9.93,84.7) 9.81,84.67 9.63,84.67 arc(9.56,84.69) 9.49,84.73 arc(9.42,84.76) 9.34,84.77 JUSBC1.A2
  BOTTOM w0.145: CT39.2 arc(30.37,79.34) 30.12,79.27 28.03,79.27 arc(26.27,79.46) 24.58,80.02 24.18,80.2 arc(23.22,80.7) 22.32,81.31 22.06,81.44 arc(22.02,81.46) 21.99,81.49 arc(21.98,81.5) 21.97,81.5 arc(21.94,81.52) 21.92,81.54 arc(21.85,81.62) 21.81,81.71 arc(21.84,81.85) v9(21.92,81.96)
TBT_A_TTX_DRX_N1: length 2.3
  BOTTOM w0.076: CT45.1 31.15,78.3 arc(31.4,78.14) 31.7,78.08 32.42,78.08 arc(32.48,78.09) 32.52,78.12 32.59,78.18 arc(32.64,78.22) 32.71,78.23 32.88,78.23 arc(33,78.21) 33.11,78.14 UT2.B19
TBT_A_TTX_DRX_N2: length 2.4
  BOTTOM w0.076: CT41.1 31.21,79.02 arc(31.34,79.11) 31.49,79.14 31.61,79.14 arc(31.66,79.13) 31.71,79.1 31.86,78.95 arc(31.99,78.86) 32.14,78.83 32.37,78.83 arc(32.45,78.82) 32.52,78.77 32.57,78.72 arc(32.6,78.7) 32.63,78.7 32.94,78.7 arc(33.03,78.71) 33.1,78.76 UT2.B17
TBT_A_TTX_DRX_P1: length 2.4
  BOTTOM w0.076: UT2.A19 32.9,78 arc(33.02,77.88) 32.9,77.76 32.74,77.76 arc(32.63,77.78) 32.54,77.84 32.5,77.88 arc(32.47,77.9) 32.42,77.91 31.46,77.91 arc(31.31,77.88) 31.18,77.8 CT43.1
TBT_A_TTX_DRX_P2: length 2.4
  BOTTOM w0.076: UT2.A17 32.87,78.92 arc(32.96,78.95) 32.99,79.04 arc(32.96,79.11) 32.88,79.15 32.66,79.15 arc(32.59,79.13) 32.53,79.09 32.48,79.04 arc(32.43,79.01) 32.37,79 32.14,79 arc(32.05,79.01) 31.98,79.06 31.83,79.21 arc(31.73,79.28) 31.61,79.3 31.49,79.3 arc(31.35,79.33) 31.23,79.41 CT39.1
TBT_B_AUX_N_C: length 5
  IN1 w0.086: v2(41.31,75.24) 41.44,75.37 41.44,77.28 41.14,77.58 41.14,78.85 41.27,78.97 41.27,79.1 v6(41.1,79.27)
  GND2 w0.102: v6(41.1,79.27) 41.11,79.27 v5(41.35,79.51)
  GND3 w0.102: v5(41.35,79.51) 41.34,79.51 v6(41.1,79.27)
TBT_B_AUX_P_C: length 5
  IN1 w0.086: v6(41.75,79.27) 41.58,79.1 41.58,78.84 41.45,78.72 41.45,77.71 41.75,77.41 41.75,75.37 v2(41.88,75.24)
  GND2 w0.102: v5(42,79.5) 41.77,79.27 v6(41.75,79.27)
  GND3 w0.102: v5(42,79.5) 41.98,79.5 v6(41.75,79.27)
TBT_B_CC1: length 49.4
  GND2 w0.381: v7(34.37,69.97) v5(34.04,70.31)
  IN2 w0.381: v5(31.18,74.28) 31.18,74.26 32.23,73.21 32.23,72.29 34.04,70.48 v5(34.04,70.31)
  GND3 w0.381: v5(31.18,74.28) 30.86,74.28 v8(30.83,74.25) ; v6(34.68,70.03) 34.32,70.03 v5(34.04,70.31)
  IN3 w0.127: JUSBC2.B5 6.97,97.85 v6(8.12,97.85)
  IN3 w0.381: v3(12.67,98.17) 15.09,98.17 15.63,97.63 15.63,93.36 16.96,92.03 19.62,92.03 23.61,88.04 23.61,86.4 28.71,81.3 28.71,76.22 30.68,74.25 v8(30.83,74.25)
  GND4 w0.127: JUSBC2.B5 6.97,97.85 v6(8.12,97.85)
  BOTTOM w0.127: v6(8.12,97.85) 6.97,97.85 JUSBC2.B5
  BOTTOM w0.381: v3(12.67,98.17) 12.6,98.07 v16(12.34,97.81) 11.97,97.45 11.97,97.43 11.62,97.43 ; v6(8.12,97.85) 10.28,97.85 10.7,97.43 10.97,97.43
TBT_B_CC2: length 48
  TOP w0.127: v1(12.75,100.66) 13.18,100.23 v9(13.18,99.59)
  TOP w0.305: 9.9,99.47 JUSBC2.A5
  TOP w0.381: 10.85,100.02 10.67,100.02 10.13,99.47 9.9,99.47 ; v9(13.18,99.59) 12.67,100.1 11.83,100.1
  GND2 w0.381: v7(35.28,70.11) 35.32,70.15 v5(35.6,70.15)
  IN2 w0.381: v5(35.6,70.15) 35.6,71.83 34.34,73.09 34.34,74.37 32.8,75.91 31.52,75.91 31.1,76.33 31.1,79.7 29.22,81.58 v5(29.22,83.39)
  GND3 w0.381: v8(28.67,83.39) v5(29.22,83.39) ; v5(35.6,70.15) 35.31,70.15 v6(35.18,70.03)
  IN3 w0.381: v9(13.18,99.59) 14.32,99.59 16.09,97.82 16.09,95.7 17.47,94.32 17.47,93.27 18.26,92.49 19.81,92.49 24.1,88.19 24.1,86.58 27.29,83.39 v8(28.67,83.39)
TBT_B_SBU1: length 51
  IN1 w0.064: v4(13.05,88.78) 13.38,89.11 13.38,97.97 13.66,98.25 13.66,99.8 13.43,100.03 v4(12.42,100.03)
  GND2 w0.102: v4(13.05,88.78) v5(13.05,88.42) ; v5(12.08,100.03) v4(12.42,100.03)
  GND3 w0.102: v5(12.08,100.03) 12,100.11 v6(11.31,100.11) ; v5(13.05,88.42) v8(13.05,88.02)
  IN3 w0.064: v8(13.05,88.02) 13.05,87.02 16.81,83.27 16.81,80.93 18.4,79.34 18.4,72.87 20.82,70.45 23.15,70.45 23.67,69.93 27.82,69.93 30.23,67.53 v3(30.68,67.53)
  BOTTOM w0.127: v6(11.31,100.11) 10.53,100.11 v1(10.44,100.02) 10.02,99.6 6.98,99.6 JUSBC2.B8
TBT_B_SBU2: length 45
  TOP w0.127: v9(12.73,97.05) 12.4,97.38 v1(12.25,97.38) 11.33,97.38 DT50.1 11.31,97.36 10.59,97.36 9.98,97.97 JUSBC2.A8
  IN3 w0.064: v3(30.68,68.03) 29.92,68.03 27.77,70.18 23.7,70.18 23.24,70.64 20.96,70.64 18.73,72.88 18.73,79.48 17.16,81.05 17.16,83.41 13.82,86.76 13.82,90.03 12.54,91.31 12.54,96.85 v9(12.73,97.05)
TBT_B_TRX_DTX_N1: length 34.1
  TOP w0.145: JUSBC2.A10 9.42,96.97 arc(9.49,96.96) 9.56,96.94 arc(9.62,96.89) 9.7,96.87 arc(9.72,96.87) 9.73,96.87 9.86,96.87 arc(10.09,96.8) 10.28,96.66 10.4,96.54 arc(10.53,96.35) 10.57,96.12 arc(10.6,96) 10.67,95.89 10.67,95.88 arc(10.8,95.8) 10.96,95.77 arc(10.96,95.77) 10.96,95.77 arc(11,95.77) 11.04,95.78 arc(11.16,95.82) 11.26,95.89 DT46.1 11.31,95.95 arc(11.51,95.81) 11.74,95.77 12.09,95.8 12.13,95.8 arc(12.59,95.74) 13.03,95.58 arc(13.3,95.42) 13.54,95.21 arc(14,94.53) 14.16,93.71 14.16,90.12 arc(14.26,89.31) 14.56,88.55 arc(14.74,88.25) 14.97,87.99 17.24,85.72 arc(18.57,84.83) 20.14,84.52 21.65,84.52 arc(22.25,84.44) 22.8,84.2 arc(23.03,84.05) 23.23,83.87 25.31,81.79 arc(25.74,81.42) 26.23,81.13 arc(26.88,80.9) 27.56,80.81 arc(27.62,80.81) 27.68,80.81 27.69,80.8 31.15,80.8 arc(31.44,80.84) v9(31.7,80.96)
  BOTTOM w0.076: UT2.B13 33.07,80.93 arc(33,80.98) 32.92,81 32.64,81 arc(32.61,80.99) 32.58,80.97 32.53,80.92 arc(32.44,80.86) 32.33,80.84 31.99,80.84 arc(31.83,80.87) v9(31.7,80.96)
TBT_B_TRX_DTX_N2: length 39.3
  BOTTOM w0.076: UT2.A7 32.89,83.52 arc(33,83.4) 32.89,83.28 32.72,83.28 arc(32.62,83.3) 32.53,83.36 arc(32.47,83.4) 32.39,83.42 arc(32.39,83.42) 32.39,83.42 arc(32.15,83.47) 31.94,83.6 31.92,83.63 arc(31.89,83.65) 31.86,83.65 30.91,83.65 30.84,83.59
  BOTTOM w0.145: 30.84,83.59 30.83,83.6 28.24,83.6 arc(27.73,83.7) 27.3,83.98 24.1,87.18 arc(22.65,88.15) 20.94,88.49 17.57,88.49 arc(16.7,88.67) 15.97,89.15 arc(15.48,89.88) 15.31,90.75 15.31,96.48 arc(14.92,98.66) 13.8,100.57 13.48,100.93 13.4,101.01 13.14,101.28 arc(12.66,101.6) 12.09,101.71 11.82,101.71 arc(11.79,101.71) 11.77,101.71 11.75,101.71 arc(11.51,101.66) DT65.1 arc(11.12,101.66) 10.89,101.71 arc(10.83,101.7) 10.77,101.69 arc(10.62,101.64) 10.49,101.54 9.97,101.02 arc(9.93,100.98) 9.9,100.95 arc(9.89,100.94) 9.88,100.94 arc(9.48,100.74) 9.04,100.63 arc(8.89,100.61) 8.74,100.61 7.47,100.61 arc(7.15,100.53) JUSBC2.B10
TBT_B_TRX_DTX_P1: length 34.1
  TOP w0.145: v9(31.7,80.35) 31.6,80.41 arc(31.48,80.47) 31.35,80.49 27.56,80.49 27.55,80.5 arc(26.81,80.6) 26.1,80.86 arc(25.56,81.17) 25.09,81.57 23.01,83.65 arc(22.84,83.8) 22.64,83.93 arc(22.17,84.14) 21.65,84.21 20.14,84.21 arc(18.45,84.55) 17.02,85.5 14.75,87.77 arc(14.49,88.07) 14.28,88.4 arc(13.96,89.23) 13.85,90.12 13.85,93.71 arc(13.71,94.41) 13.32,95 arc(12.78,95.36) 12.13,95.49 12.11,95.49 11.77,95.46 arc(11.53,95.41) DT42.1 11.26,95.35 arc(11.18,95.42) 11.09,95.45 11,95.46 arc(10.98,95.46) 10.96,95.46 arc(10.68,95.51) 10.46,95.67 10.45,95.67 arc(10.31,95.88) 10.26,96.12 arc(10.24,96.23) 10.18,96.32 10.07,96.44 arc(9.95,96.52) 9.82,96.56 arc(9.79,96.56) 9.76,96.57 9.6,96.57 arc(9.52,96.55) 9.46,96.51 arc(9.38,96.48) 9.31,96.47 JUSBC2.A11
  BOTTOM w0.076: v9(31.7,80.35) 31.87,80.53 arc(32.03,80.63) 32.22,80.67 32.34,80.67 arc(32.43,80.65) 32.52,80.6 arc(32.6,80.54) 32.69,80.52 32.85,80.52 arc(32.96,80.64) 32.85,80.76 UT2.A13
TBT_B_TRX_DTX_P2: length 39.3
  BOTTOM w0.076: 30.83,83.85 30.84,83.85 arc(30.88,83.83) 30.93,83.82 31.86,83.82 arc(31.95,83.8) 32.04,83.74 32.06,83.72 arc(32.21,83.62) 32.39,83.58 arc(32.46,83.6) 32.53,83.64 32.59,83.71 arc(32.63,83.73) 32.66,83.74 32.93,83.74 arc(33.02,83.72) 33.1,83.66 UT2.B7
  BOTTOM w0.145: 30.83,83.85 30.78,83.91 28.24,83.91 arc(27.85,83.98) 27.52,84.2 24.7,87.02 24.32,87.4 arc(22.77,88.44) 20.94,88.8 17.57,88.8 arc(16.82,88.95) 16.19,89.37 arc(15.77,90) 15.62,90.75 15.62,96.48 arc(15.21,98.77) 14.03,100.77 13.71,101.14 13.55,101.3 13.36,101.5 arc(12.77,101.88) 12.09,102.02 11.61,102.02 arc(11.49,102.05) 11.39,102.11 DT67.1 arc(11.12,102.06) 10.89,102.02 arc(10.83,102.01) 10.77,102.01 arc(10.5,101.92) 10.27,101.76 9.75,101.24 arc(9.73,101.22) 9.71,101.2 arc(9.37,101.03) 9,100.94 arc(8.87,100.92) 8.74,100.92 7.19,100.92 arc(7.11,100.93) 7.04,100.98 JUSBC2.B11
TBT_B_TTX_C_DRX_N1: length 33.2
  BOTTOM w0.145: CT46.2 30.43,81.74 arc(30.3,81.68) 30.16,81.66 27.18,81.66 arc(26.6,81.74) 26.06,81.97 arc(26.04,81.98) 26.02,82 24.39,83.63 arc(22.56,84.85) 20.4,85.28 18.27,85.28 arc(17.64,85.36) 17.06,85.6 arc(17.02,85.62) 16.98,85.65 arc(15.96,86.38) 15.03,87.24 arc(14.47,87.96) 14.1,88.81 arc(13.95,89.37) 13.9,89.95 13.9,94.55 arc(13.83,94.91) 13.62,95.22 arc(13.61,95.23) 13.6,95.24 arc(13.6,95.24) 13.6,95.25 arc(13.57,95.27) 13.55,95.3 13.36,95.49 arc(13.05,95.69) 12.7,95.78 arc(12.67,95.78) 12.65,95.78 11.54,95.78 arc(11.49,95.79) 11.44,95.82 DT45.1 11.19,95.83 arc(11.14,95.79) 11.07,95.76 11.07,95.76 arc(10.99,95.74) 10.92,95.73 arc(10.88,95.72) 10.84,95.72 arc(10.64,95.76) 10.46,95.88 10.05,96.29 arc(9.62,96.6) 9.1,96.77 arc(9.06,96.77) 9.01,96.78 arc(8.94,96.79) 8.88,96.8 arc(8.47,96.83) 8.06,96.85 7.54,96.85 arc(7.41,96.86) 7.28,96.88 arc(7.07,96.98) JUSBC2.B3
TBT_B_TTX_C_DRX_N2: length 34.9
  TOP w0.145: JUSBC2.A3 9.41,100.47 arc(9.47,100.48) 9.52,100.49 arc(9.59,100.53) 9.66,100.55 9.78,100.55 arc(10.04,100.6) 10.26,100.75 10.35,100.84 arc(10.48,101.03) 10.52,101.25 10.52,101.47 arc(10.54,101.54) 10.58,101.6 10.63,101.66 arc(10.68,101.69) 10.74,101.7 10.93,101.7 arc(11.14,101.66) DT66.1 11.38,101.64 arc(11.53,101.77) 11.72,101.82 11.72,101.82 arc(11.84,101.81) 11.96,101.8 11.97,101.8 arc(12.18,101.73) 12.41,101.7 12.67,101.7 arc(12.79,101.69) 12.89,101.65 arc(12.96,101.62) 13.03,101.58 arc(13.09,101.53) 13.15,101.48 13.19,101.43 13.2,101.43 14.47,100.15 arc(15.05,99.3) 15.25,98.29 15.25,93.56 arc(15.26,93.23) 15.28,92.9 15.28,92.9 arc(15.38,92.31) 15.53,91.74 arc(15.91,90.81) 16.45,89.95 16.69,89.64 arc(16.71,89.61) 16.73,89.59 17.93,88.39 arc(18.86,87.77) 19.95,87.55 20.58,87.55 arc(20.96,87.48) 21.28,87.26 21.72,86.82 arc(21.8,86.72) 21.84,86.6 arc(21.82,86.47) v9(21.76,86.34)
  BOTTOM w0.145: v9(21.76,86.34) arc(21.86,86.33) 21.95,86.29 arc(21.98,86.28) 22,86.26 22.29,86.06 arc(22.46,85.99) 22.64,85.96 22.87,85.96 arc(23.53,85.83) 24.1,85.45 26.24,83.31 26.52,83.08 arc(27.24,82.67) 28.05,82.53 30.13,82.53 arc(30.34,82.5) CT42.2
TBT_B_TTX_C_DRX_P1: length 33.2
  BOTTOM w0.145: JUSBC2.B2 arc(7,96.48) 7.17,96.54 8.06,96.54 arc(8.45,96.52) 8.84,96.49 arc(8.91,96.48) 8.97,96.47 8.97,96.47 arc(9.01,96.47) 9.06,96.46 arc(9.48,96.33) 9.83,96.07 10.23,95.68 arc(10.5,95.49) 10.83,95.43 arc(10.9,95.42) 10.96,95.42 10.99,95.42 arc(11.16,95.39) DT41.1 arc(11.51,95.42) 11.75,95.47 12.65,95.47 arc(12.67,95.47) 12.68,95.47 12.68,95.47 arc(12.69,95.47) 12.7,95.47 arc(12.94,95.41) 13.14,95.27 13.33,95.08 arc(13.34,95.07) 13.34,95.06 arc(13.35,95.05) 13.36,95.04 arc(13.38,95.02) 13.4,94.99 13.4,95 arc(13.54,94.79) 13.59,94.55 13.59,89.95 arc(13.64,89.32) 13.8,88.71 arc(14.2,87.8) 14.81,87.02 arc(15.76,86.14) 16.82,85.39 arc(16.86,85.36) 16.91,85.33 arc(17.56,85.06) 18.27,84.97 20.4,84.97 arc(22.44,84.56) 24.17,83.41 25.8,81.78 arc(25.86,81.73) 25.92,81.69 arc(26.53,81.44) 27.18,81.35 30.08,81.35 arc(30.33,81.31) CT44.2
TBT_B_TTX_C_DRX_P2: length 34.9
  TOP w0.145: v9(22.25,86.83) 22.22,86.83 arc(22.16,86.84) 22.11,86.87 22.11,86.87 21.5,87.48 arc(21.08,87.77) 20.58,87.86 19.95,87.86 arc(18.97,88.06) 18.15,88.61 17.22,89.53 arc(17.07,89.7) 16.92,89.87 arc(16.27,90.8) 15.82,91.83 15.82,91.84 arc(15.68,92.38) 15.59,92.93 15.59,92.93 arc(15.57,93.25) 15.56,93.56 15.56,98.29 arc(15.33,99.42) 14.69,100.37 13.41,101.65 13.37,101.7 arc(13.29,101.77) 13.19,101.84 arc(13.11,101.89) 13.03,101.93 arc(12.85,101.99) 12.67,102.01 12.41,102.01 arc(12.25,102.03) 12.1,102.08 12.01,102.11 arc(11.87,102.12) 11.72,102.13 11.72,102.13 arc(11.51,102.14) 11.31,102.19 DT68.1 11.27,102.15 arc(11.14,102.06) 10.98,102.01 arc(10.96,102.01) 10.93,102.01 10.74,102.01 arc(10.56,101.98) 10.41,101.88 10.36,101.82 arc(10.25,101.66) 10.21,101.47 10.21,101.25 arc(10.19,101.15) 10.13,101.06 10.04,100.97 arc(9.92,100.89) 9.78,100.86 9.71,100.86 arc(9.64,100.87) 9.57,100.92 arc(9.48,100.96) 9.38,100.97 JUSBC2.A2
  BOTTOM w0.145: CT40.2 30.36,82.9 arc(30.33,82.87) 30.28,82.86 30.13,82.84 30.13,82.83 28.05,82.83 arc(27.34,82.96) 26.72,83.31 26.44,83.54 24.31,85.67 arc(23.65,86.11) 22.87,86.27 22.64,86.27 arc(22.55,86.28) 22.47,86.32 22.23,86.48 arc(22.17,86.55) 22.15,86.65 22.16,86.74 arc(22.19,86.8) v9(22.25,86.83)
TBT_B_TTX_DRX_N1: length 2.4
  BOTTOM w0.076: CT46.1 31.29,81.64 arc(31.36,81.59) 31.45,81.58 31.54,81.58 arc(31.63,81.59) 31.72,81.65 arc(31.82,81.72) 31.95,81.74 32.38,81.74 arc(32.39,81.74) 32.39,81.74 arc(32.44,81.75) 32.49,81.77 arc(32.51,81.79) 32.52,81.8 32.57,81.85 arc(32.63,81.89) 32.68,81.9 32.98,81.9 arc(33.02,81.89) 33.06,81.87 UT2.B11
TBT_B_TTX_DRX_N2: length 2.4
  BOTTOM w0.076: CT42.1 31.27,82.59 arc(31.37,82.66) 31.49,82.68 31.62,82.68 arc(31.65,82.67) 31.68,82.65 31.75,82.58 arc(31.84,82.52) 31.95,82.5 32.28,82.5 arc(32.4,82.48) 32.51,82.41 arc(32.55,82.38) 32.6,82.37 32.93,82.37 arc(33.02,82.39) 33.09,82.44 UT2.B9
TBT_B_TTX_DRX_P1: length 2.4
  BOTTOM w0.076: CT44.1 31.3,81.35 arc(31.37,81.39) 31.45,81.41 31.54,81.41 arc(31.7,81.44) 31.83,81.53 arc(31.88,81.57) 31.95,81.58 32.38,81.58 arc(32.46,81.56) 32.52,81.52 32.53,81.51 arc(32.61,81.46) 32.7,81.44 32.89,81.44 arc(33,81.56) 32.89,81.68 UT2.A11
TBT_B_TTX_DRX_P2: length 2.4
  BOTTOM w0.076: CT40.1 31.26,82.94 arc(31.37,82.87) 31.49,82.85 31.62,82.85 arc(31.72,82.83) 31.8,82.77 31.87,82.7 arc(31.91,82.68) 31.95,82.67 32.26,82.67 arc(32.35,82.69) 32.43,82.74 32.47,82.78 arc(32.53,82.82) 32.59,82.83 32.87,82.83 arc(32.99,82.71) 32.87,82.6 UT2.A9
TBT_BATLOW#: length 60.3
  IN2 w0.074: v5(33.69,52.58) 32.72,53.55 32.23,53.55 31.79,53.99 31.79,56.3 32.61,57.13 32.61,58.5 31.83,59.29 31.83,62.79 27.34,67.28 26.46,67.28 25.76,67.98 25.76,78.15 26.59,78.99 26.59,86.4 26.03,86.97 26.03,88.4 25.64,88.78 25.64,89.93 27.27,91.56 27.27,92.11 28.3,93.14 32.05,93.14 32.31,93.4 33.21,93.4 33.68,92.93 v5(33.68,92.6)
  GND3 w0.102: v6(33.76,52.25) 33.76,52.52 v5(33.69,52.58) ; v5(33.68,92.6) v8(33.68,92.07)
  IN3 w0.064: v8(33.68,92.07) 33.68,91.36 34.25,90.8 36.39,90.8 36.99,90.2 v3(36.99,89.2)
  BOTTOM w0.127: RT426.2 v3(36.99,89.2)
TBT_BATLOW#_R: length 3.3
  BOTTOM w0.076: UT2.F2 35.32,86.05 35.32,86.54 36.12,87.33 36.8,87.33 36.99,87.52 RT426.1
TBT_CIO_PLUG_EVENT#: length 30
  IN1 w0.064: v4(40.81,86.77) 40.89,86.7 40.89,81.38 40.23,80.72 40.23,74.64 39.93,74.35 39.93,71.86 39.01,70.94 39.01,68.35 38.85,68.19 38.85,63.8 38.17,63.12 v4(38.17,62.58)
  GND2 w0.102: v4(38.17,62.58) v5(38.57,62.18) ; v4(40.81,86.77) 40.66,86.92 40.51,86.92 v5(40.5,86.91)
  GND3 w0.102: v5(40.5,86.91) 40.58,86.99 v6(40.98,86.99) ; v6(38.58,61.42) 38.58,61.84 38.57,61.85 v5(38.57,62.18)
  BOTTOM w0.076: UT2.W2 40.84,86.05 40.84,86.85 v6(40.98,86.99) 41.31,87.32 RT29.2
TBT_CIO_PLUG_EVENT#_R: length 8.1
  IN2 w0.074: v5(38.78,59.16) 39.15,58.79 39.15,55.21 v5(39.49,54.87)
  GND3 w0.102: v6(38.41,59.35) 38.43,59.35 38.62,59.16 v5(38.78,59.16) ; v5(39.49,54.87) 39.49,55.03 v6(39.66,55.2)
  BOTTOM w0.127: v1(39.46,61.32) 38.97,60.84 RH610.2 38.45,60.71 38.45,59.65 38.41,59.62 v6(38.41,59.35)
TBT_DDC_CLK: length 4
  BOTTOM w0.076: 42.23,88.25 42.23,87.44 41.3,86.51 41.3,86.05 UT2.Y2
  BOTTOM w0.122: 42.23,88.25 42.23,88.25
  BOTTOM w0.127: 42.23,88.25 42.23,88.85 RT11.2
TBT_DDC_DATA: length 3.3
  BOTTOM w0.076: 42.47,88.02 42.47,87.42 41.53,86.49 UT2.Y1
  BOTTOM w0.127: RT13.2 42.47,89.15 42.47,88.02
TBT_FORCE_PWR: length 43.1
  TOP w0.127: v7(41.69,61.55) 42.32,60.92 42.32,60.6 v1(43.37,59.55) v7(43.84,59.09) ; RT427.2 35.47,85.77 v7(36.1,85.77)
  GND2 w0.102: v7(43.84,59.09) 43.76,59.01 v5(43.76,58.76) ; v7(36.1,85.77) v5(36.1,85.39) ; v7(41.69,61.55) v5(41.69,61.88)
  IN2 w0.074: v5(41.69,61.88) 40.67,62.9 40.67,68.26 37.12,71.81 37.12,72.41 36.99,72.54 36.99,74.56 37.83,75.4 37.83,75.84 38.34,76.35 41.01,76.35 43.07,78.42 43.07,81.42 41.37,83.13 41.37,85.16 39.83,86.7 37.41,86.7 v5(36.1,85.39)
  GND3 w0.102: v5(36.1,85.39) 35.9,85.19 v6(35.9,85.12) ; v6(43.54,58.52) 43.53,58.53 43.76,58.76 v5(43.76,58.76)
  BOTTOM w0.127: v6(43.54,58.52) 43.82,58.81 RH609.2
TBT_I2C_CLK: length 41.6
  IN2 w0.074: v5(38.92,91.61) 38.81,91.5 36.54,91.5 36.03,92.02 35.24,92.02 34.72,91.5 32.89,91.5 32.38,92.01 31.54,92.01 31.06,91.53 29.19,91.53 27.53,89.87 27.53,87.65 28.25,86.93 28.25,78.07 27.41,77.23 27.41,73.34 27.63,73.12 27.77,73.12 28.49,72.41 28.49,71.5 28.22,71.23 28.22,70.01 30.53,67.7 v5(30.53,67.6)
  GND3 w0.102: v6(31.18,67.53) 30.6,67.53 v5(30.53,67.6) ; v8(39.34,91.42) 39.11,91.42 v5(38.92,91.61)
  IN3 w0.064: v3(39.34,89.2) v8(39.34,91.42)
  BOTTOM w0.127: RT423.2 v3(39.34,89.2)
TBT_I2C_CLK_R: length 2.4
  BOTTOM w0.076: UT2.U2 39.92,86.05 39.92,86.75 39.34,87.33 RT423.1
TBT_I2C_DATA: length 46.9
  TOP w0.127: v9(39.82,91.17) 39.98,91.01 v1(39.98,90.7)
  IN2 w0.074: v9(39.82,91.17) 39.82,91.27 38.77,92.32 36.64,92.32 36.3,92.65 35.03,92.65 34.91,92.65 34.36,92.1 33.15,92.1 32.63,92.62 32.63,92.62 31.29,92.62 30.81,92.13 28.93,92.13 26.93,90.13 26.93,87.34 27.64,86.63 27.64,78.32 26.81,77.48 26.81,73.65 26.81,73.65 26.81,73.09 27.38,72.52 27.52,72.52 27.88,72.16 27.88,71.75 27.59,71.46 27.59,69.07 27.95,68.72 27.95,68.41 29.32,67.04 31.33,67.04 v5(31.33,67.03)
  GND3 w0.102: v6(31.53,66.38) 31.53,66.83 v5(31.33,67.03)
  IN3 w0.064: v3(39.91,89.2) 39.91,91.08 v9(39.82,91.17)
  BOTTOM w0.076: v6(31.53,66.38) 31.53,66.57 31.18,66.92 UPD1.D2
  BOTTOM w0.127: RT422.2 v3(39.91,89.2)
TBT_I2C_DATA_R: length 1.9
  BOTTOM w0.076: UT2.U1 40.15,86.95 39.77,87.33 39.77,87.79 RT422.1
TBT_JTAG_TCK: length 3.9
  TOP w0.127: RT4.2 v1(39.72,87.08)
  GND2 w0.102: v5(39.77,87.71) 39.75,87.74 v7(39.75,88.04)
  GND3 w0.102: v5(39.77,87.71) v8(39.77,87.36)
  IN3 w0.064: v8(39.77,87.36) 39.8,87.33 v3(39.8,85.12)
TBT_JTAG_TDI: length 4.3
  TOP w0.127: RT6.2 43.33,88.02 v1(43.41,88.09)
  GND2 w0.102: v7(42.47,88.07) 42.47,87.76 v5(42.49,87.74)
  GND3 w0.102: v5(42.49,87.74) v8(42.49,87.38)
  IN3 w0.064: v3(41.75,85.12) 41.75,86.18 42.49,86.92 v8(42.49,87.38)
TBT_JTAG_TDO: length 5.3
  TOP w0.127: v7(41.5,88.02) 41.61,88.02 v1(42.63,87)
  GND2 w0.102: v7(41.5,88.02) v5(41.83,88.02)
  GND3 w0.102: v8(42.06,87.76) 41.83,87.99 v5(41.83,88.02)
  IN3 w0.064: v8(42.06,87.76) 42.08,87.74 42.08,87.16 41.04,86.12 41.04,85.18 v3(41.1,85.12)
TBT_JTAG_TMS: length 4.3
  TOP w0.127: RT5.2 40.61,87.46 v1(41.12,86.95)
  GND2 w0.102: v7(40.69,88.02) 40.69,87.71 v5(40.71,87.69)
  GND3 w0.102: v5(40.71,87.69) v8(40.71,87.33)
  IN3 w0.064: v3(40.45,85.12) 40.45,87.07 v8(40.71,87.33)
TBT_PERST_N: length 22.6
  TOP w0.127: v7(37.56,88.02) 37.42,88.02 36.93,87.52 36.18,87.52 RT428.2
  GND2 w0.102: v5(37.59,87.69) 37.56,87.71 v7(37.56,88.02)
  GND3 w0.102: v5(37.59,87.69) v8(37.59,87.33)
  IN3 w0.064: v8(37.59,87.33) 37.59,86.78 37.2,86.4 v3(37.2,85.12) 37.78,84.54 38.64,84.54 39.02,84.16 41.89,84.16 42.44,84.7 44.88,84.7 45.44,85.25 45.44,85.93 45.75,86.25 45.88,86.25 46.39,86.76 46.39,87.64 45.46,88.58 45.46,89.58 47.34,91.46 v3(47.76,91.46)
TBT_PERST_N_R: length 2.2
  BOTTOM w0.127: U4253.4 46.82,90.97 47.02,90.76 RT240.2 47.33,91.31 RT235.2
TBT_PWR_EN: length 3.6
  BOTTOM w0.076: UH4.AU43 29.79,56.16 30.04,56.4 30.04,56.96 30.13,57.06 30.13,57.35 30.03,57.45 30.03,57.98 29.44,58.58 29.44,58.76
  BOTTOM w0.127: RH190.2 29.44,58.76
TBT_RBIAS: length 1
  GND2 w0.152: v7(35.58,84.73) 35.58,84.14 v5(35.58,84.14)
  GND3 w0.152: v6(35.9,83.82) v5(35.58,84.14)
TBT_RESET_N_EC: length 152.9
  TOP w0.127: v7(73,22.5) 73,22.35 71.5,20.85 71.5,17.48 71.05,17.04 71.05,13.37 67.48,9.8 v1(67.22,9.8) 66.29,9.8 62.63,6.14 61.41,6.14 v2(61.32,6.05) ; v7(50.09,88.8) 47.52,91.37 40.38,91.37 38.53,93.22 36.6,93.22 36.04,92.67 RT69.1
  IN1 w0.064: v2(61.32,6.05) 60.85,6.51 56.37,6.51 56.01,6.88 55.01,6.88 54.94,6.81 54.66,6.81 54.22,7.24 51.74,7.24 50.8,8.18 48.98,8.18 48.22,7.42 48.22,5.85 47.18,4.81 46.52,4.81 v2(46.26,4.55)
  GND2 w0.102: v7(73,22.5) v5(73,23.12) ; v5(49.93,88.42) 49.93,88.65 v7(50.09,88.8)
  IN2 w0.074: v5(49.93,88.42) 50.31,88.04 50.31,82.4 49.6,81.69 49.6,77.88 52.3,75.19 53.69,75.19 54.28,74.61 54.28,69.62 52.78,68.12 52.78,66.6 50.22,64.04 49.31,64.04 47.98,62.71 47.98,57.28 47.65,56.95 47.65,53.01 50.03,50.62 50.03,46.52 50.52,46.03 50.52,33.25 50.69,33.08 50.69,27.21 53.53,24.37 57.32,24.37 58.32,23.37 72.75,23.37 v5(73,23.12)
TBT_RESET_N_EC_R: length 5.2
  TOP w0.127: UE3.L8 46.81,8.93 46.81,6.72 46.53,6.44 v1(46.53,5.99) 46.26,5.72 RE132.2 RE162.1
TBT_RESET_N_R: length 7
  TOP w0.127: RT14.2 v7(36.04,90.47) RT17.2
  GND2 w0.102: v7(36.04,90.47) v5(36.04,90.11)
  GND3 w0.102: v5(36.04,90.11) 36.2,89.95 v8(36.2,89.76)
  IN3 w0.064: v8(36.2,89.76) 36.2,88.51 35.79,88.09 35.79,86.99 35.25,86.45 v3(35.25,85.12)
TBT_ROM_CLK: length 27
  IN3 w0.064: v3(44.27,85.49) 44.27,86.24 45.12,87.09 45.12,87.65 44.36,88.4 44.36,89.77 42.58,91.55 42.58,93.11 41.97,93.72 41.97,97.15 49.2,104.39 v3(50.63,104.39)
  BOTTOM w0.076: v3(44.27,85.49) 43.98,85.49 43.61,85.13 42.68,85.13 UT2.AB4
TBT_ROM_CS#: length 20.4
  IN3 w0.064: v3(44.73,101.85) 44.73,100.31 41.69,97.27 41.69,93.61 42.3,93 42.3,90.98 43.57,89.71 43.57,85.78 v3(43.7,85.65)
  BOTTOM w0.076: UT2.AC3 43.4,85.36 v3(43.7,85.65) 43.96,85.65 44.13,85.82 44.5,85.82 RT45.2
TBT_ROM_DI: length 26.2
  IN3 w0.064: v3(43.99,86.07) 43.72,86.35 43.72,89.76 42.44,91.04 42.44,93.05 41.83,93.66 41.83,97.21 50.27,105.66 v3(50.63,105.66)
  BOTTOM w0.076: v3(43.99,86.07) 43.74,86.07 43.25,85.59 42.68,85.59 UT2.AB3
TBT_ROM_DO: length 23.2
  IN3 w0.064: v3(44.76,84.97) 44.59,85.13 43.64,85.13 43.37,85.4 43.37,89.72 42.16,90.92 42.16,92.94 41.55,93.55 41.55,97.33 44.34,100.12 44.34,102.74 44.72,103.12 v3(44.73,103.12)
  BOTTOM w0.076: v3(44.76,84.97) 44.69,84.9 UT2.AC4
TBT_ROM_HOLD#: length 3.3
  BOTTOM w0.127: v1(53.32,103.99) 52.8,103.47 RT44.2 52.8,103.11 50.63,103.11 UT3.7
TBT_ROM_WP#: length 20.3
  IN3 w0.064: v3(41.31,89.2) 41.31,90.21 42.02,90.93 42.02,92.88 41.41,93.49 41.41,97.44 44.14,100.17 44.14,103.8 v3(44.73,104.39)
  BOTTOM w0.076: 40.96,88.35 40.96,87.52 40.61,87.17 UT2.V1
  BOTTOM w0.127: v3(41.31,89.2) 40.96,88.85 40.96,88.35
TBT_RSENSE: length 1.1
  GND2 w0.152: v7(36.5,84.73) 36.5,84.4 v5(36.32,84.22)
  GND3 w0.152: v5(36.32,84.22) 36.32,84.05 36.55,83.82 v6(36.55,83.82)
TBT_SLP_S3_N: length 4
  TOP w0.127: v7(35.47,88.51) RT84.2
  GND2 w0.102: v7(35.47,88.51) 35.34,88.51 v5(35.15,88.32)
  GND3 w0.102: v8(35.2,87.99) 35.15,88.04 v5(35.15,88.32)
  IN3 w0.064: v3(34.17,85.82) 35.2,86.85 v8(35.2,87.99)
TBT_SRC_CFG1: length 2.9
  BOTTOM w0.076: 42.64,86.93 UT2.AA1
  BOTTOM w0.127: 42.64,86.93 42.87,87.15 43.61,87.15 43.98,87.52 R165.1
TBT_SRC_HPD: length 5.4
  BOTTOM w0.076: UT2.G1 35.55,86.51 36.18,87.14 37.12,87.14 37.56,87.59 37.56,88.35
  BOTTOM w0.127: 37.56,88.35 37.56,88.64 R166.1 T749.1
TBT_TEST_EN: length 1.9
  BOTTOM w0.076: RT18.2 35.28,87.28 34.63,86.63 UT2.E1
TBT_TEST_PWRG: length 2.5
  BOTTOM w0.076: UT2.AB5 42.68,84.67 44.17,84.67 44.43,84.41 RT21.2
TBT_TMU_CLK_OUT: length 3.9
  BOTTOM w0.076: 40.26,88.35 40.26,88.28 C1083.1 40.61,87.55 40.38,87.32 40.38,86.05 UT2.V2
  BOTTOM w0.127: RT32.2 40.26,88.85 40.26,88.35
TBTA_DPSRC_AUX_N: length 11.8
  IN1 w0.086: v2(42.45,74.66) 42.38,74.66 42.28,74.55 42.28,74.44 42.35,74.37 42.63,74.37 42.71,74.28 42.71,73.92 41.56,72.77 41.56,71.37 40.51,70.32 40.51,66.46 39.78,65.73 39.64,65.73 v4(39.61,65.77)
  GND2 w0.102: v5(39.29,65.84) 39.46,65.68 39.52,65.68 v4(39.61,65.77)
  GND3 w0.102: v6(38.89,65.87) 38.89,65.85 39.04,65.69 39.14,65.69 v5(39.29,65.84)
TBTA_DPSRC_AUX_N_R: length 3.2
  BOTTOM w0.145: UPD1.C11 35.78,66.43 36.05,66.43 36.74,65.74 37.38,65.74 37.49,65.86 37.49,65.92 RP85.1 37.94,65.87 RP79.1
TBTA_DPSRC_AUX_P: length 11.8
  IN1 w0.086: v4(39.61,65.39) 39.65,65.42 39.91,65.42 40.82,66.34 40.82,70.19 41.87,71.24 41.87,72.64 43.02,73.8 v2(43.02,74.66)
  GND2 w0.102: v4(39.61,65.39) 39.52,65.47 39.46,65.47 v5(39.29,65.31)
  GND3 w0.102: v5(39.29,65.31) 39.11,65.49 39.04,65.49 38.89,65.34 v6(38.89,65.31)
TBTA_DPSRC_AUX_P_R: length 3.2
  BOTTOM w0.145: RP78.1 37.94,65.31 RP83.1 37.54,65.22 37.54,65.28 37.39,65.43 36.61,65.43 35.92,66.12 35.77,66.12 UPD1.B11
TBTA_I2C_ALERT#: length 43.5
  TOP w0.127: RT424.2 RT31.2 36.95,89.2 37.5,89.75 v1(37.5,90.32) 37.5,91.2 v7(37.19,91.51)
  GND2 w0.102: v7(37.19,91.51) 37.04,91.66 v5(37.04,91.95)
  IN2 w0.074: v5(30.81,68.08) 31.01,67.87 31.01,67.51 30.71,67.2 30.35,67.2 29.61,67.94 28.62,67.94 28.1,68.47 28.1,68.78 27.74,69.13 27.74,71.4 28.03,71.69 28.03,72.22 27.58,72.67 27.45,72.67 26.96,73.15 26.96,77.42 27.79,78.26 27.79,86.72 27.08,87.44 27.08,90.07 28.99,91.98 30.87,91.98 31.36,92.47 32.19,92.47 32.57,92.47 33.08,91.95 34.42,91.95 34.97,92.5 36.23,92.5 36.78,91.95 v5(37.04,91.95)
  GND3 w0.102: v6(31.18,68.03) 30.86,68.03 v5(30.81,68.08)
TBTA_I2C_ALERT#_R: length 2.8
  GND2 w0.102: v7(36.61,87.93) v5(36.61,87.59)
  GND3 w0.102: v5(36.61,87.59) v8(36.61,87.23)
  IN3 w0.064: v3(36.55,85.12) 36.55,87.17 v8(36.61,87.23)
TBTA_LSRX: length 27.4
  TOP w0.127: v9(36.08,65.24) v1(36.6,65.24)
  GND2 w0.102: v7(31.57,84.98) v5(31.95,84.98)
  IN2 w0.074: v5(31.95,84.98) 32.66,84.98 32.97,84.68 32.97,76.6 34.94,74.62 34.94,73.34 36.38,71.9 36.38,71.51 37.18,70.72 37.18,70.21 38.81,68.58 38.81,67.29 37.69,66.17 37.69,65.6 37.5,65.4 37.14,65.4 36.86,65.68 36.5,65.68 36.08,65.26 v9(36.08,65.24)
  GND3 w0.102: v5(31.95,84.98) 31.98,85.01 v6(32.37,85.01)
  BOTTOM w0.127: UT2.A4 32.48,84.9 v6(32.37,85.01) ; v9(36.08,65.24) 35.8,65.53 UPD1.A11
TBTA_LSTX: length 29.4
  IN1 w0.064: v4(36.19,70.03) 36.33,70.03 36.93,69.43 36.93,68.6 36.76,68.43 36.76,67.04 36.38,66.66 v4(36.38,65.68)
  GND2 w0.102: v5(36.62,65.32) 36.38,65.56 v4(36.38,65.68) ; v4(36.19,70.03) 35.88,69.72 v5(35.88,69.71) ; v7(31.59,83.94) v5(31.59,84.31)
  GND3 w0.102: v6(31.31,84.59) v5(31.59,84.31) ; v8(35.51,69.71) v5(35.88,69.71) ; v6(35.96,64.7) 36.23,64.7 36.62,65.09 v5(36.62,65.32)
  IN3 w0.064: v6(31.31,84.59) 31.46,84.74 32.5,84.74 33.08,84.15 33.08,74.74 33.02,74.68 33.02,73.47 33.9,72.59 33.9,72.06 34.18,71.79 34.18,70.59 34.4,70.37 34.4,69.94 34.66,69.68 35.48,69.68 v8(35.51,69.71)
  BOTTOM w0.127: UPD1.A10 35.18,65.31 35.79,64.7 v6(35.96,64.7) ; v1(30.9,84.59) v6(31.31,84.59) 32.49,84.59 32.64,84.44 UT2.A5
TBTA_USB2_D_N: length 38.3
  IN3 w0.086: v3(33.95,77.32) 34.06,77.32 34.14,77.23 34.14,77.05 33.96,76.88 33.96,74.07 33.88,73.99 33.78,73.99 33.69,74.07 v3(33.69,74.19) ; v3(32.04,74.11) 32.1,74.11 32.35,73.86 32.35,73.24 33.08,72.51 33.08,71.84 33.21,71.71 33.34,71.71 33.57,71.48 33.57,70.46 33.3,70.19 32.7,70.19 32.61,70.11 32.61,69.42 32.31,69.13 31.89,69.13 31.76,68.99 31.76,68.04 31.85,67.96 32.05,67.96 32.1,68 32.1,68.28 32.43,68.61 35.01,68.61 35.29,68.33 35.29,67.66 35.02,67.39 34.89,67.39 34.82,67.33 34.82,66.71 34.56,66.44 33.35,66.44 33.26,66.36 33.26,65.83 33.35,65.74 34.12,65.74 34.39,65.47 34.39,65.09 33.82,64.51 33.82,64.12 33.92,64.02 34.38,64.02 34.48,64.11 35.21,64.11 35.48,63.85 35.48,63.43 35.59,63.31 35.59,62.92 34.98,62.31 34.58,62.31 34.05,62.84 33.92,62.84 33.68,62.61 33.68,62.26 34,61.94 34,61.56 33.67,61.23 32.81,61.23 32.55,61.5 32.55,64.41 32.46,64.49 31.57,64.49 31.48,64.4 31.48,64.04 31.98,63.54 v3(32.04,63.54)
  BOTTOM w0.145: v3(33.69,74.19) 33.56,74.06 32.09,74.06 v3(32.04,74.11)
TBTA_USB2_D_P: length 38.3
  IN3 w0.086: v3(33.69,73.62) 33.75,73.68 34.01,73.68 34.27,73.95 34.27,76.75 34.45,76.93 34.45,77.17 v3(34.6,77.32) ; v3(32.04,73.73) 32.04,73.11 32.77,72.38 32.77,71.71 33.08,71.4 33.22,71.4 33.26,71.36 33.26,70.59 33.17,70.5 32.57,70.5 32.3,70.24 32.3,69.55 32.18,69.44 31.76,69.44 31.45,69.12 31.45,67.91 31.72,67.65 32.18,67.65 32.41,67.88 32.41,68.15 32.56,68.3 34.88,68.3 34.98,68.2 34.98,67.79 34.89,67.7 34.76,67.7 34.52,67.46 34.52,66.84 34.43,66.75 33.22,66.75 32.95,66.49 32.95,65.7 33.22,65.43 33.99,65.43 34.08,65.34 34.08,65.21 33.51,64.64 33.51,63.99 33.79,63.71 34.51,63.71 34.6,63.8 35.08,63.8 35.17,63.72 35.17,63.3 35.28,63.18 35.28,63.05 34.86,62.62 34.71,62.62 34.18,63.15 33.79,63.15 33.37,62.74 33.37,62.13 33.69,61.81 33.69,61.69 33.54,61.54 32.94,61.54 32.86,61.62 32.86,64.54 32.59,64.8 31.44,64.8 31.17,64.53 31.17,64.04 30.97,63.84 30.62,63.84 30.32,63.55 v3(30.32,63.54)
  BOTTOM w0.145: v3(33.69,73.62) 33.56,73.75 32.06,73.75 v3(32.04,73.73)
TBTB_DPSRC_AUX_N: length 9.2
  IN1 w0.086: v4(39.66,67.47) 39.81,67.62 39.81,70.61 40.86,71.66 40.86,73.08 41,73.22 41,73.75 41.57,74.32 41.57,74.63 41.48,74.71 41.37,74.71 v2(41.31,74.66)
  GND2 w0.102: v4(39.66,67.47) v5(39.32,67.47)
  GND3 w0.102: v6(38.86,67.48) 39.04,67.3 39.15,67.3 v5(39.32,67.47)
TBTB_DPSRC_AUX_N_R: length 3
  BOTTOM w0.145: RP81.2 37.94,67.48 RP86.1 37.69,67.6 37.44,67.34 36.59,67.34 36.5,67.43 35.77,67.43 UPD1.E11
TBTB_DPSRC_AUX_P: length 9.6
  IN1 w0.086: v4(39.65,66.93) 40.12,67.41 40.12,70.48 41.17,71.53 41.17,72.95 41.31,73.09 41.31,73.62 41.88,74.19 v2(41.88,74.66)
  GND2 w0.102: v4(39.65,66.93) v5(39.32,66.93)
  GND3 w0.102: v5(39.32,66.93) 39.15,67.1 39.04,67.1 v6(38.86,66.92)
TBTB_DPSRC_AUX_P_R: length 3
  BOTTOM w0.145: RP80.2 37.94,66.92 RP84.1 37.69,66.81 37.47,67.03 36.46,67.03 36.37,67.12 35.78,67.12 UPD1.D11
TBTB_I2C_ALERT#: length 34.3
  IN2 w0.074: v5(31.98,91.22) 31.68,90.92 29.44,90.92 28.14,89.62 28.14,87.93 28.88,87.19 28.88,79.55 30.34,78.08 30.34,73.04 29.23,71.93 29.23,69.64 30.4,68.47 v5(31.53,68.47)
  GND3 w0.102: v6(31.18,68.53) 31.23,68.47 v5(31.53,68.47) ; v5(31.98,91.22) 32.03,91.22 32.25,90.99 v8(32.33,90.99)
  IN3 w0.064: v8(32.33,90.99) 33.37,89.95 35.02,89.95 35.28,89.69 v3(35.28,89.2)
  BOTTOM w0.127: v3(35.28,89.2) 35.28,89.14 35.85,88.57 RT425.2
TBTB_I2C_ALERT#_R: length 2.6
  BOTTOM w0.076: UT2.E2 34.86,86.05 34.86,86.58 35.85,87.57 RT425.1
TBTB_LSRX: length 18
  TOP w0.127: v1(33.63,85.3) 33.25,84.92 v7(33.25,83.88)
  GND2 w0.102: v5(33.47,84.13) 33.47,84.11 v7(33.25,83.88)
  GND3 w0.102: v6(33.54,84.64) 33.47,84.58 v5(33.47,84.13)
  IN3 w0.064: v3(35.68,70.53) 35.68,70.68 34.21,72.15 34.21,72.68 33.31,73.57 33.31,74.58 33.36,74.63 33.36,84.46 v6(33.54,84.64)
  BOTTOM w0.127: UT2.B5 v6(33.54,84.64)
TBTB_LSTX: length 18.1
  TOP w0.127: v1(32.29,85.81) 32.78,85.32 v7(32.78,84.98)
  GND2 w0.102: v7(32.78,84.98) 33.02,85.22 v5(33.02,85.25)
  GND3 w0.102: v5(33.02,85.25) 33.25,85.01 v6(33.25,84.9)
  IN3 w0.064: v6(33.25,84.9) 33.22,84.87 33.22,74.68 33.17,74.63 33.17,73.52 34.04,72.64 34.04,72.12 34.32,71.84 34.32,70.93 34.38,70.86 34.94,70.86 35.68,70.12 v3(35.68,70.03)
TBTB_USB2_D_N: length 38.3
  IN1 w0.086: v4(39.56,78) 39.52,77.96 39.52,76.79 38.96,76.23 38.51,76.23 37.51,77.23 37.51,78.17 37.42,78.26 36.68,78.26 36.1,77.68 34.67,77.68 34.17,77.18 34.17,76.42 34.26,76.34 37.09,76.34 37.62,75.81 37.62,75.53 38.01,75.13 38.9,75.13 39.27,74.76 39.27,73.46 39.01,73.2 39.01,72.07 38.21,71.27 38.21,70.9 37.88,70.57 37.75,70.57 37.54,70.35 37.54,70.23 37.83,69.94 37.95,69.94 38.21,69.67 38.21,68.93 38.02,68.74 38.02,68.36 37.57,67.91 37.57,67.44 37.65,67.36 37.79,67.36 38.05,67.1 38.05,66.42 37.78,66.15 37.44,66.15 37.25,65.96 37.25,65.04 37.36,64.93 37.78,64.93 38.05,64.66 38.05,64.22 37.73,63.9 36.95,63.9 36.77,63.71 36.77,63.41 v4(36.8,63.38)
  GND2 w0.102: v5(39.21,78.19) 39.28,78.19 39.47,78 v4(39.56,78) ; v4(36.8,63.38) 36.97,63.54 v5(37.12,63.54)
  GND3 w0.102: v6(37.46,63.54) v5(37.12,63.54) ; v8(38.77,78.31) 39.09,78.31 v5(39.21,78.19)
  IN3 w0.086: v3(33.95,77.97) 33.95,78.36 34.22,78.63 34.83,78.63 35.22,78.24 36.29,78.24 36.99,78.94 37.76,78.94 38.46,78.24 38.7,78.24 v8(38.77,78.31)
TBTB_USB2_D_P: length 38.3
  IN1 w0.086: v4(38.89,77.86) 39.03,77.86 39.21,77.68 39.21,76.92 38.83,76.54 38.64,76.54 37.82,77.36 37.82,78.3 37.55,78.57 36.55,78.57 35.97,77.99 34.54,77.99 33.86,77.31 33.86,76.3 34.13,76.03 36.96,76.03 37.31,75.68 37.31,75.4 37.89,74.82 38.78,74.82 38.96,74.63 38.96,73.59 38.7,73.33 38.7,72.2 37.9,71.4 37.9,71.03 37.75,70.88 37.63,70.88 37.23,70.48 37.23,70.1 37.7,69.63 37.82,69.63 37.9,69.54 37.9,69.06 37.71,68.87 37.71,68.49 37.26,68.04 37.26,67.32 37.52,67.05 37.66,67.05 37.74,66.97 37.74,66.54 37.65,66.46 37.31,66.46 36.94,66.09 36.94,64.91 37.23,64.62 37.65,64.62 37.74,64.53 37.74,64.35 37.6,64.21 36.82,64.21 36.43,63.81 36.43,63.42 v4(36.39,63.39)
  GND2 w0.102: v5(36.1,63.54) 36.24,63.54 v4(36.39,63.39) ; v5(39.21,77.65) 39,77.86 v4(38.89,77.86)
  GND3 w0.102: v8(38.77,77.93) 38.9,77.93 39.18,77.65 v5(39.21,77.65) ; v6(35.75,63.54) v5(36.1,63.54)
  IN3 w0.086: v3(34.6,77.97) 34.47,77.83 34.35,77.83 34.26,77.92 34.26,78.24 34.35,78.32 34.7,78.32 35.09,77.93 36.42,77.93 37.12,78.63 37.63,78.63 38.33,77.93 v8(38.77,77.93)
TENT_MODE: length 3.5
  BOTTOM w0.127: v1(53.17,10.76) 53.98,11.57 QC126.1 54.75,11.09 54.69,11.03 RE439.2 55.31,10.63 RC396.2
TENT_MODE_R: length 77.4
  IN3 w0.064: v3(24.51,45.7) 24.51,46.04 23.75,46.81 21.3,46.81 20.66,46.16 17.36,46.16 16.78,45.59 16.78,45.35 15.88,44.45 15.88,38.76 15.63,38.52 15.63,37.72 15.93,37.43 15.93,33.96 17.25,32.64 17.25,27.43 19.39,25.29 v3(19.39,25.11)
  BOTTOM w0.076: UH4.BD21 26.31,45.13 26.04,45.41 24.8,45.41 v3(24.51,45.7) 23.85,46.36 RH660.1
  BOTTOM w0.127: v3(19.39,25.11) 20.57,25.11 20.86,25.39 21.43,25.39 21.66,25.62 22.77,25.62 23.19,25.21 25.91,25.21 26.15,25.44 28.67,25.44 36.87,17.24 37.41,17.24 37.71,17.55 39.44,17.55 39.79,17.2 42.37,17.2 42.64,17.47 46.82,17.47 47.44,16.85 53.29,16.85 v1(54.54,15.59) 54.89,15.24 RC397.1 55.4,14.07 QC126.3
THERMDA: length 0.5
  BOTTOM w0.122: UT2.AB23 UT2.AC23
THERMTRIP1#: length 4.6
  TOP w0.127: RE124.1 52.35,16.3 52.35,16.04 52.08,15.78 51.76,15.78 51.23,16.31 51.23,16.57 50.82,16.97 49.93,16.97 UE3.B12
THERMTRIP2#: length 13.8
  TOP w0.127: v2(36.34,12.35) 36.6,12.1 36.6,11.52 36.74,11.39 37.53,11.39 37.86,11.06 RE215.2 37.86,11 38.02,10.84 CE86.1 38.61,10.28 v1(38.93,10.61) 39.27,10.61 39.49,10.38 40.32,10.38 40.48,10.55 40.92,10.55 41.12,10.75 41.12,11.13 41.33,11.34 41.62,11.34 42.07,11.79 UE3.H3
  IN1 w0.064: v2(36.34,12.35) 36.13,12.14 35.46,12.14 34.77,12.83 34.77,14.81 34.01,15.58 v2(33.81,15.58)
TOUCH_SCREEN_PD#: length 62.5
  TOP w0.127: v2(56.28,99.05) v1(56.28,100.4) QV11.6
  IN1 w0.064: v2(56.28,99.05) 56.25,99.02 53.38,99.02 52.21,97.84 43.02,97.84 41.92,96.74 41.92,91.75 42.74,90.93 42.74,86.09 43.81,85.02 43.81,73.76 42.25,72.19 42.25,71.08 41.2,70.03 41.2,66.18 39.4,64.38 39.4,62.66 38.08,61.33 37.18,61.33 36.11,60.26 v4(35.39,60.26)
  GND2 w0.102: v4(35.39,60.26) 35.03,59.9 v5(35.02,59.9)
  GND3 w0.102: v6(34.58,59.99) 34.93,59.99 v5(35.02,59.9)
  BOTTOM w0.127: CH243.1 34.48,60.09 v6(34.58,59.99) 34.29,59.7 RH653.2
TOUCH_SCREEN_PD#_Q: length 15.4
  TOP w0.127: v7(50.95,96.69) 51.05,96.78 51.05,98.38 54.39,101.72 54.39,104.48 54.72,104.82 v1(55.28,104.82) 55.69,104.82 56.28,104.23 QV11.1
  GND2 w0.102: v7(50.95,96.69) v5(51.54,96.69)
  GND3 w0.102: v6(51.92,96.3) v5(51.54,96.69)
  BOTTOM w0.127: v6(51.92,96.3) 52.41,95.82 JEDP1.17
TOUCH_SCREEN_PD#_R: length 3
  BOTTOM w0.076: UH4.AE44 35.7,56.88 35.7,56.97 35.72,56.99 35.72,58.26 35.22,58.76
  BOTTOM w0.127: RH653.1 34.87,59.11 35.22,58.76
TOUCHPAD_INTR#: length 88.5
  TOP w0.127: v9(28.09,6.93) v1(28.8,6.93)
  IN1 w0.064: v2(33.77,12.59) 31.85,12.59 28.09,8.83 v9(28.09,6.93)
  IN3 w0.064: v3(14.89,51.34) 14.54,51.69 14.54,54.88 12.92,56.51 10.18,56.51 6.78,53.1 6.78,37.99 6.9,37.87 6.9,37.39 7.62,36.67 7.62,28.07 7.79,27.89 7.79,25.63 8.65,24.78 12.88,24.78 14.83,22.83 14.83,21.16 19.03,16.96 19.17,16.96 22.12,14.01 22.12,12.66 24.65,10.13 25.85,10.13 28.09,7.9 v9(28.09,6.93)
  BOTTOM w0.127: v3(14.89,51.34) 15.68,50.55 15.68,47.49 DH1.1 ; JKB1.22 27.42,7.39 27.66,7.15 27.72,7.15 27.94,6.93 v9(28.09,6.93)
TOUCHPAD_INTR#_D: length 9.9
  BOTTOM w0.076: 22.07,46.86 22.39,47.18 24.27,47.18 24.98,46.48 25.66,46.48 25.77,46.59 26.05,46.59 26.13,46.51 26.73,46.51 UH4.BC23
  BOTTOM w0.127: 22.07,46.86 21.99,46.78 20.96,46.78 v1(20.96,46.79) 20.86,46.88 RH107.1 19.86,46.74 19.55,46.44 18.23,46.44 DH1.2
TOUCHPAD_INTR#_R: length 10.4
  TOP w0.127: UE3.G2 41.17,12.21 41.17,11.54 40.99,11.36 39.49,11.36 38.11,12.74 34.5,12.74 RE252.1 34.35,12.43 34.13,12.21 v1(32.93,12.21)
TP_DISABLE#: length 24.6
  TOP w0.127: v9(27.55,6.76) v1(26.9,6.76)
  IN1 w0.064: v9(27.55,6.76) 27.55,10.35 33.04,15.84 33.95,15.84 36.24,13.54 36.81,13.54 37.06,13.29 40.72,13.29 40.82,13.39 v2(43.15,13.39)
  BOTTOM w0.127: v9(27.55,6.76) 27.51,6.76 26.92,7.35 JKB1.23
TP_EN: length 22.2
  TOP w0.127: UE3.H9 47.15,11.68 46.71,11.23 46.71,10.45 v2(46.77,10.38) ; v1(36.29,2.81) 35.53,3.57 v9(35.53,4.59)
  IN1 w0.064: v9(35.53,4.59) 36.11,4.59 36.73,5.21 42.28,5.21 43.79,6.72 44.33,6.72 45.18,7.57 45.18,8.28 46.5,9.6 46.5,10.12 46.5,10.12 v2(46.77,10.38)
  BOTTOM w0.127: v9(35.53,4.59) 35.53,4.65 33.42,6.77 JKB1.10
TP_GPU_XTAL_OUT: length 0.7
  GND2 w0.107: v5(83.12,57.53) v6(83.35,57.29)
  GND3 w0.127: v6(83.35,57.29) v5(83.12,57.53)
TP_KBL_G_BH37: length 2.6
  GND2 w0.102: v5(107.37,64.2) 107.64,64.2 v7(107.86,64.42)
  GND3 w0.102: v5(107.37,64.2) 106.92,63.75 v6(106.85,63.75)
  BOTTOM w0.127: UC1.BH37 106.71,63.08 106.71,63.61 v6(106.85,63.75)
TP_KBL_G_BJ37: length 3.5
  TOP w0.127: v7(108.49,64.42) 108.52,64.42 108.76,64.66 v1(109.38,64.66)
  GND2 w0.102: v5(108.04,64.03) 108.43,64.42 v7(108.49,64.42)
  GND3 w0.102: v6(107.67,63.86) 107.87,63.86 v5(108.04,64.03)
  BOTTOM w0.127: UC1.BJ37 107.67,63.12 v6(107.67,63.86)
TPM_PIRQ#: length 64.4
  TOP w0.127: v9(19.76,10.42) v1(19.22,10.42)
  IN1 w0.064: v4(25.53,50.89) 24.98,50.34 24.98,44.6 24.37,43.99 24.37,36.91 24.74,36.53 24.74,35.5 27.3,32.94 28.91,32.94 31.16,30.69 31.16,27.8 31.71,27.25 31.71,21.65 30.17,20.12 30.17,20.12 28.17,18.12 27.38,18.12 25.76,16.5 25.76,15.01 22.34,11.59 20.93,11.59 v9(19.76,10.42)
  GND2 w0.102: v4(25.53,50.89) 25.47,50.96 v5(25.47,51.25)
  GND3 w0.102: v5(25.47,51.25) 25.13,51.25 v8(25.11,51.27)
  IN3 w0.064: v6(30.12,52.66) 30.12,52.36 29.8,52.04 29.34,52.04 28.65,51.34 25.18,51.34 v8(25.11,51.27)
  BOTTOM w0.076: v6(30.12,52.66) 30.5,52.66 31.43,53.59 UH4.AN38
  BOTTOM w0.127: UE2.18 20.45,11.11 v9(19.76,10.42) 19.66,10.32 19.66,8.21 19.28,7.83 RE14.2
TS_I2C_RST#: length 77.8
  IN1 w0.064: v4(30.75,47.74) 30.75,49.15 31.46,49.85 31.93,49.85 32.28,50.21 32.28,50.76 32.5,50.97 33.13,50.97 33.33,51.17 34.04,51.17 34.31,51.44 34.31,52.37 35.5,53.56 35.5,53.8 36.5,54.8 36.5,55.43 38.9,57.83 38.9,57.83 40.51,59.44 41.19,59.44 42.68,60.93 42.68,61.86 44.23,63.41 44.23,68.5 47.11,71.37 47.11,87.34 47.37,87.6 47.37,89.02 48.37,90.02 49.11,90.02 50.65,91.57 50.65,91.74 51.28,92.37 51.28,93.48 53.36,95.55 54.33,95.55 54.61,95.83 55.34,95.83 v4(55.6,96.09)
  GND2 w0.102: v5(55.41,96.48) 55.41,96.28 v4(55.6,96.09) ; v7(31.42,47.49) 31.16,47.76 v5(31.11,47.76) 31.09,47.74 v4(30.75,47.74)
  GND3 w0.102: v5(55.41,96.48) 55.41,96.32 v6(55.18,96.09) ; v6(31.02,47.37) 31.11,47.47 v5(31.11,47.76)
  BOTTOM w0.076: v6(31.02,47.37) 30.82,47.18 UH4.AR24
  BOTTOM w0.127: QV10.1 64.23,101.36 63.98,101.11 63.47,101.11 62.98,100.62 v1(62.98,99.24) 62.98,97.6 61.99,96.61 55.7,96.61 v6(55.18,96.09)
TS_I2C_RST#_R: length 22.7
  TOP w0.127: RR40.1 52.1,91.67 v1(51.28,91.67) v2(50.39,91.67)
  IN1 w0.064: v4(55.18,96.09) 54.68,96.09 54.28,95.69 53.3,95.69 51.14,93.54 51.14,92.42 v2(50.39,91.67)
  GND2 w0.102: v5(55.41,95.71) 55.41,95.87 v4(55.18,96.09)
  GND3 w0.102: v5(55.41,95.71) 55.41,95.9 v6(55.6,96.09)
  BOTTOM w0.127: QV10.3 63.84,99.91 RR43.2 63.84,98.18 62.07,96.41 55.91,96.41 v6(55.6,96.09)
TYPEC_ID: length 7.8
  TOP w0.127: UE3.F2 41.55,13.21 v2(41.33,12.99) ; CE78.1 v2(35.14,13.28)
  IN1 w0.064: v2(41.33,12.99) 36.24,12.99 36.04,12.79 35.62,12.79 v2(35.14,13.28)
UART2_RXD: length 83.7
  IN2 w0.074: v5(62.33,22.62) 62.33,22.09 60.69,20.45 57.1,20.45 56.21,21.34 53.12,21.34 52.62,21.84 50.65,21.84 50.52,21.96 45.23,21.96 43.71,23.49 43.13,23.49 41.51,25.11 41.51,36.94 42.64,38.08 44.73,38.08 45.15,38.5 45.15,40.09 45.15,40.1 45.15,40.72 45.89,41.46 45.89,49.42 42.55,52.76 40.99,52.76 40.16,51.93 39.19,51.93 39.03,51.77 38.19,51.77 37.45,52.51 34.64,52.51 34.23,52.09 33.49,52.09 33.49,52.09 33.48,52.09 33.01,52.57 32.46,52.57 30.26,54.77 30.26,55.26 31.15,56.15 31.15,56.79 30.56,57.38 30.56,58.9 v5(30.91,59.25)
  GND3 w0.102: v5(62.33,22.62) 62.35,22.64 v6(62.35,22.97) ; v6(30.58,59.25) v5(30.91,59.25)
  BOTTOM w0.076: 30.58,58.76 30.58,58.25 30.98,57.84 30.98,57.22 UH4.AR45
  BOTTOM w0.127: RP97.2 58.86,24.53 61.38,24.53 v1(62.35,23.56) v6(62.35,22.97) ; v6(30.58,59.25) 30.58,58.76
UART2_TXD: length 74.6
  TOP w0.127: RH176.2 30.64,53.99 v7(30.64,54.5)
  GND2 w0.102: v5(30.64,54.87) v7(30.64,54.5)
  IN2 w0.074: v5(30.64,54.87) 30.64,54.85 32.77,52.72 33.07,52.72 33.54,52.24 34.16,52.24 34.58,52.66 37.52,52.66 38.25,51.93 38.97,51.93 39.13,52.08 40.1,52.08 40.93,52.91 42.61,52.91 46.04,49.48 46.04,41.4 45.3,40.65 45.3,40.16 45.3,38.44 44.79,37.93 42.71,37.93 41.66,36.88 41.66,25.17 43.19,23.64 43.77,23.64 45.15,22.26 47.85,22.26 48.23,22.65 50.05,22.65 50.71,21.99 52.68,21.99 53.19,21.49 56.28,21.49 57.16,20.6 60.63,20.6 61.52,21.49 v5(61.52,22.32)
  GND3 w0.102: v6(61.19,22.32) v5(61.52,22.32) ; v6(30.64,54.52) v5(30.64,54.87)
  BOTTOM w0.127: RP96.2 60.58,24.06 v1(60.87,23.77) 60.87,22.64 v6(61.19,22.32)
USB3_PRX_MTX_N1: length 82.9
  IN3 w0.086: v3(51.69,37.68) 51.72,37.65 51.72,36.52 51.49,36.3 51.49,29.84 53.18,28.16 54.14,28.16 66.45,15.85 76.09,15.85 76.67,15.27 79.21,15.27 79.34,15.14 85.49,15.14 85.67,15.33 89.45,15.33 89.67,15.12 94.3,15.12 94.83,15.65 96.85,15.65 97.47,16.27 105.31,16.27 105.47,16.12 108.71,16.12 110.39,17.79 110.39,18.81 110.02,19.19 109.6,19.19 v3(109.57,19.21)
  BOTTOM w0.076: UH4.B7 47.31,38.71 48.58,38.71 49.57,37.71 49.68,37.71 49.69,37.69
  BOTTOM w0.145: 49.69,37.69 50.29,37.09 51.53,37.09 51.72,37.29 51.72,37.65 v3(51.69,37.68) ; JIO1.B5 v3(109.57,19.21)
USB3_PRX_MTX_N2: length 95.5
  IN3 w0.086: v3(46.12,38.7) 45.83,38.33 45.85,37.86 45.85,36.34 44.28,34.77 44.05,34.77 42.84,33.57 42.84,27.7 45.48,25.06 51.49,25.06 64.08,12.47 77.85,12.47 78.03,12.28 81.07,12.28 81.66,11.69 93.72,11.69 94.21,11.19 97.69,11.19 98.66,12.17 104.58,12.17 104.62,12.2 110.33,12.2 112.19,14.07 112.19,14.9 113.8,16.5 113.8,17.42 113.32,17.9 v3(113.06,17.9)
  BOTTOM w0.076: UH4.C8 46.42,39 v3(46.12,38.7)
USB3_PRX_MTX_P1: length 82.9
  IN3 w0.086: v3(52.07,37.68) 52.03,37.65 52.03,37.31 52.13,37.21 52.45,37.21 52.55,37.11 52.55,36.97 52.45,36.87 52.13,36.87 52.03,36.77 52.03,36.4 51.8,36.17 51.8,29.97 53.31,28.47 54.27,28.47 66.58,16.16 76.21,16.16 76.79,15.58 79.34,15.58 79.47,15.45 85.36,15.45 85.54,15.64 89.58,15.64 89.8,15.43 94.17,15.43 94.7,15.96 96.72,15.96 97.34,16.58 105.44,16.58 105.6,16.43 108.59,16.43 110.08,17.92 110.08,18.69 109.89,18.88 109.55,18.88 109.46,18.79 109.46,18.58 v3(109.6,18.44)
  BOTTOM w0.076: UH4.A7 47.6,38.54 48.51,38.54 49.46,37.59 49.46,37.49 49.47,37.48
  BOTTOM w0.145: JIO1.C5 v3(109.6,18.44) ; 49.47,37.48 50.16,36.79 51.66,36.79 52.03,37.16 52.03,37.65 v3(52.07,37.68)
USB3_PRX_MTX_P2: length 95.4
  IN3 w0.086: v3(113.06,16.9) 112.8,16.9 112.67,17.02 112.67,17.41 112.85,17.59 113.19,17.59 113.49,17.29 113.49,16.63 111.88,15.03 111.88,14.2 110.2,12.51 104.49,12.51 104.46,12.48 98.53,12.48 97.56,11.5 94.34,11.5 93.84,12 81.79,12 81.2,12.59 78.16,12.59 77.98,12.78 64.21,12.78 51.62,25.37 45.61,25.37 43.15,27.83 43.15,33.44 44.17,34.46 44.41,34.46 46.16,36.21 46.16,37.87 46.14,38.23 46.29,38.42 v3(46.45,38.44)
  BOTTOM w0.076: UH4.B8 47.14,39.07 46.5,38.44 v3(46.45,38.44)
USB3_PTX_MRX_N1: length 83.4
  IN3 w0.086: v3(50.96,39.26) 50.96,35.45 51.1,35.31 51.1,29.65 53.18,27.57 54.17,27.57 66.75,15 72.85,15 73.31,15.46 75.92,15.46 76.5,14.88 79.03,14.88 79.16,14.74 84.11,14.74 84.2,14.66 88.87,14.66 88.93,14.73 97.04,14.73 97.42,15.1 100.71,15.1 101.48,15.87 108.93,15.87 109.68,16.63 110.17,16.63 110.55,17.01 v3(110.55,17.32)
  BOTTOM w0.076: UH4.C11 46.84,39.91 47.48,39.91 47.9,39.49 47.9,39.27 48.12,39.05 49.27,39.05 49.44,38.87
  BOTTOM w0.145: v3(50.96,39.26) 50.96,38.88 50.58,38.5 49.82,38.5 49.44,38.87 ; JIO1.D4 v3(110.55,17.32)
USB3_PTX_MRX_N2: length 92.9
  IN3 w0.086: v3(111.57,15.35) 111.57,15.02 111.49,14.94 110.66,14.94 109.34,13.63 103.97,13.63 103.51,13.18 98.21,13.18 97.74,12.7 82.22,12.7 81.99,12.93 81.62,13.3 78.45,13.3 78.27,13.48 65.25,13.48 59.35,19.38 58.92,19.38 56.47,21.84 56.47,21.88 52.27,26.07 45.9,26.07 44.19,27.78 44.19,32.01 45.01,32.82 45.81,32.82 46.91,33.93 46.91,37.83 48,38.91 48.6,38.91 48.87,39.18 48.87,39.56 48.51,39.92 v3(48.35,39.92)
  BOTTOM w0.089: UH4.B12 47.15,40.63 47.28,40.63 47.3,40.63 47.39,40.53 47.67,40.53 47.76,40.62 48.06,40.61 48.12,40.61 48.43,40.3 48.43,40.01 v3(48.35,39.92)
  BOTTOM w0.102: JIO1.F3 v3(111.57,15.35)
USB3_PTX_MRX_P1: length 83.3
  IN3 w0.086: v3(50.58,39.26) 50.65,39.19 50.65,35.32 50.79,35.18 50.79,29.52 53.05,27.26 54.05,27.26 66.62,14.69 72.98,14.69 73.44,15.15 75.79,15.15 76.37,14.57 78.9,14.57 79.03,14.43 83.99,14.43 84.07,14.35 89,14.35 89.06,14.42 97.17,14.42 97.55,14.79 100.84,14.79 101.61,15.56 109.05,15.56 109.81,16.32 110.3,16.32 110.62,16.63 110.76,16.63 110.88,16.52 110.88,16.42 v3(110.79,16.34)
  BOTTOM w0.076: UH4.B11 47.1,40.34 47.16,40.4 47.27,40.4 47.38,40.29 47.38,40.15 47.46,40.07 47.55,40.07 48.07,39.55 48.07,39.34 48.19,39.21 49.34,39.21 49.48,39.07 49.69,39.07 49.69,39.07
  BOTTOM w0.145: JIO1.E4 110.82,16.1 v3(110.79,16.34) ; v3(50.58,39.26) 50.65,39.19 50.65,39.01 50.45,38.81 49.95,38.81 49.69,39.07
USB3_PTX_MRX_P2: length 92.9
  IN3 w0.086: v3(48.35,39.54) 48.45,39.54 48.56,39.43 48.56,39.31 48.47,39.22 47.87,39.22 46.6,37.96 46.6,34.05 45.68,33.13 44.88,33.13 43.88,32.14 43.88,27.65 45.78,25.76 52.14,25.76 56.16,21.75 56.16,21.71 58.79,19.07 59.22,19.07 65.12,13.17 78.14,13.17 78.32,12.99 81.49,12.99 81.68,12.8 82.09,12.39 97.87,12.39 98.34,12.87 103.64,12.87 104.09,13.32 109.47,13.32 110.79,14.63 111.45,14.63 111.57,14.51 v3(111.57,14.35)
  BOTTOM w0.089: UH4.A12 47.64,40.89 47.79,40.89 47.88,40.79 48,40.79 48,40.79 48.06,40.79 48.2,40.79 48.61,40.38 48.61,39.81 v3(48.35,39.54)
  BOTTOM w0.102: JIO1.G3 v3(111.57,14.35)
USB3RN4: length 10.3
  IN3 w0.086: v3(45.6,40.18) 45.39,40.21 45.32,40.31 45.34,40.43 45.34,40.69 45.2,40.84 45.2,41.43 45.67,41.9 45.94,41.9 46.04,41.8 46.04,41.39 46.14,41.29 46.28,41.29 46.39,41.39 46.39,41.8 46.49,41.9 50.65,41.9 51.86,40.69 51.86,40.39 v3(51.76,40.3)
USB3RP4: length 10.3
  IN3 w0.086: v3(52.26,40.3) 52.17,40.39 52.17,40.82 50.78,42.21 45.54,42.21 44.89,41.56 44.89,40.71 45.03,40.57 45.03,40.46 45.01,40.36 44.91,40.29 v3(44.71,40.32)
USB3TN4: length 6.4
  IN3 w0.086: v3(48.19,41.52) 48.28,41.43 50.05,41.43 50.64,40.85 50.64,40.37 50.65,40.35 v3(50.69,40.35)
  BOTTOM w0.076: UH4.A14 47.58,41.75 47.86,41.75 48.05,41.94 48.16,41.94 48.33,41.77 48.33,41.66 v3(48.19,41.52)
  BOTTOM w0.145: v3(50.69,40.35) 50.66,40.39 50.66,41.29 50.97,41.61 51.31,41.61 CH45.1
USB3TN4_R: length 3.1
  BOTTOM w0.145: JDEBUG1.7 53.26,40.7 53.45,40.89 53.45,41.04 53.2,41.29 52.88,41.29 52.52,41.65 52.43,41.65 52.35,41.56 52.35,41.33 52.28,41.26 52.08,41.26 51.95,41.4 CH45.2
USB3TP4: length 6.3
  IN3 w0.086: v3(50.31,40.35) 50.33,40.37 50.33,40.72 49.93,41.12 48.15,41.12 47.97,41.3 47.97,41.3 v3(47.77,41.5)
  BOTTOM w0.076: UH4.B13 47.7,41.43 v3(47.77,41.5)
  BOTTOM w0.145: v3(50.31,40.35) 50.35,40.39 v10(50.35,41.04) 50.35,41.42 50.85,41.92 51.11,41.92 CH44.1
USB3TP4_R: length 3.1
  BOTTOM w0.145: CH44.2 52.16,41.97 52.64,41.97 53.01,41.6 53.33,41.6 53.76,41.17 JDEBUG1.6
USB20_N1: length 238.9
  TOP w0.145: LV4.1 150.35,104.55 150.35,104.18 150.28,104.11 150.28,104.09 v9(150.12,103.94)
  IN3 w0.061: v3(34.99,37.47) 35.02,37.45 35.33,37.45 35.45,37.56 35.45,37.76 35.32,37.89 34.85,37.89 34.66,37.7 34.66,37.19 33.97,36.49 33.97,36.12 34.05,36.04 34.05,36.02
  IN3 w0.086: v9(150.12,103.94) 150.22,103.84 150.22,101.57 150.71,101.07 150.71,95.18 152.44,93.46 152.44,81.41 147.9,76.87 147.9,74.17 149.91,72.16 150.61,72.16 152.47,70.3 152.47,45.71 150.5,43.74 150.5,35.46 148.12,33.07 148.12,29.74 147.19,28.81 141.61,28.81 140.82,28.02 140.82,26.82 139.85,25.84 139.85,23.43 138.88,22.46 133.52,22.46 132.46,21.4 131.24,21.4 130.48,20.63 126.64,20.63 124.33,18.32 124.33,14.59 123.44,13.7 123.44,11.09 118.9,6.56 111.89,6.56 110.26,4.92 109.35,4.92 109.03,4.89 108.56,4.8 108.3,4.69 107.85,4.39 106.78,3.32 106.78,2.77 106.27,2.26 102.44,2.26 100.92,3.77 95.96,3.77 94.81,2.63 91.42,2.63 90.44,3.6 85.22,3.6 82.18,6.64 69.64,6.64 68.93,7.36 62.99,7.36 50.88,19.47 39.06,19.47 37.9,20.63 37.9,28.71 35.02,31.58 35.02,33.97 34.05,34.95 34.05,36.02
USB20_N1_R: length 9.3
  TOP w0.145: LV4.2 150.34,105.41 150.34,105.68 150.2,105.83 149.78,105.83 149.09,105.14 v10(148.69,105.14) 148.39,105.14 148.24,104.99 148.24,104.72 147.97,104.45 DV7.2 147.46,104.75 147.25,104.75 v9(147.09,104.59)
  BOTTOM w0.145: v9(147.09,104.59) 146.92,104.76 146.68,104.76 145.73,103.8 145.73,102.98 144.9,102.15 144.71,102.15 144.61,102.05 JCAM1.11
USB20_N2: length 119.1
  IN3 w0.061: 34.52,36.02 34.6,36.11 34.6,36.64 34.92,36.96 35.69,36.96 35.96,36.68 36.29,36.68 36.53,36.92 36.53,37.47 36.42,37.59 36.21,37.59 v3(36.04,37.42)
  IN3 w0.086: v3(114.06,19.9) 114.28,19.68 114.55,19.68 115.5,18.74 115.5,14.84 114.86,14.21 114.86,11.78 114.34,11.25 114.34,8.08 113.2,6.95 111.68,6.95 110.04,5.31 109.33,5.31 109.13,5.29 109.12,5.31 108.45,5.17 108.11,5.04 108.11,5.03 106.98,4.28 103.67,4.28 103.56,4.17 95.68,4.17 94.61,3.1 91.49,3.1 90.6,3.99 85.38,3.99 82.34,7.03 70.57,7.03 69.48,8.12 62.79,8.12 50.89,20.01 39.23,20.01 38.37,20.87 38.37,28.83 35.58,31.63 35.58,34.07 34.52,35.13 34.52,36.02
