# Allegro board LA-F211P R10-0105.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RE431  100K_0201_1%  [R_0201]  46.8 10.51 0 bottom
RE433  0_0201_5%  [R0201_0OHM]  42.67 12.58 270 bottom
RE434  0_0201_5%  [R0201_0OHM]  44.25 10.68 0 bottom
RE435  10K_0201_5%  [R_0201]  43.02 10.68 270 bottom
RE436  0_0603_5%  [R0603_0OHM]  143.16 31.79 90 bottom
RE437  10K_0201_5%  [R_0201]  44.39 12 90 bottom
RE438  100K_0201_5%  [R_0201]  44.97 12 90 bottom
RE439  0_0201_5%  [R_0201]  54.11 10.63 0 bottom
RH35  24.9_0402_1%  [R_0402]  87.73 81.03 90 top
RH36  0_0201_5%  [R_0201]  77.35 53.55 180 bottom
RH37  24.9_0402_1%  [R_0402]  82.29 62.74 90 top
RH38  20_0402_5%  [R_0402]  81.38 62.74 90 top
RH42  1K_0201_5%  [R_0201]  135.18 70.31 180 bottom
RH43  1K_0201_5%  [R_0201]  148.13 95.46 90 top
RH44  51_0402_5%  [R_0402]  139.1 70.74 90 bottom
RH45  1K_0201_5%  [R_0201]  82.27 54.22 270 bottom
RH46  100_0402_5%  [R_0402]  138.22 72.09 180 bottom
RH47  56.2_0402_1%  [R_0402]  138.22 71.2 180 bottom
RH48  49.9_0402_1%  [R_0402]  137.33 70.31 180 bottom
RH49  220_0402_5%  [R_0402]  136.43 71.19 90 bottom
RH50  499_0201_1%  [R_0201]  146.76 73.04 180 top
RH51  1K_0201_5%  [R_0201]  146.17 73.74 0 top
RH52  60.4_0402_1%  [R_0402]  81.51 53.55 90 bottom
RH54  20_0201_5%  [R_0201]  147.1 76.07 270 top
RH55  0_0201_5%  [R0201_0OHM]  135.14 71.46 180 bottom
RH56  0_0201_5%  [R_0201]  135.14 72.09 180 bottom
RH57  49.9_0201_1%  [R_0201]  146.4 75.48 90 top
RH58  1K_0201_5%  [R_0201]  148.74 95.46 90 top
RH59  220K_0402_5%  [R_0402]  82.14 109.86 90 bottom
RH60  1K_0201_5%  [R_0201]  149.37 95.46 90 top
RH61  1K_0201_5%  [R_0201]  150 95.46 90 top
RH62  30_0402_5%  [R_0402]  69.15 52.66 0 top
RH63  30_0402_5%  [R_0402]  69.15 53.49 0 top
RH64  1K_0201_5%  [R_0201]  150.62 95.48 0 top
RH66  100K_0402_5%~D  [R_0402]  30.86 51.56 0 top
RH67  100K_0402_5%~D  [R_0402]  30.86 52.36 0 top
RH68  SHORT PADS  [SHORTPADS]  31.34 50.5 0 top
RH69  SHORT PADS  [SHORTPADS]  29.76 53.36 90 top
RH74  100_0402_1%  [R_0402]  115.81 54.44 180 bottom
RH75  0_0402_5%  [R0402_0OHM]  114.91 53.5 270 bottom
RH76  0_0402_5%  [R0402_0OHM]  115.8 53.5 270 bottom
RH77  100_0402_1%  [R_0402]  116.68 53.5 270 bottom
RH78  100_0402_1%  [R_0402]  133.23 50.74 180 bottom
RH79  0_0402_5%  [R0402_0OHM]  132.32 51.57 90 bottom
RH80  0_0402_5%  [R0402_0OHM]  133.47 52.49 270 bottom
RH81  100_0402_1%  [R_0402]  134.33 51.57 90 bottom
RH90  10K_0201_5%  [R_0201]  32.76 61.5 0 bottom
RH91  10K_0201_5%  [R_0201]  42.52 60.11 90 bottom
RH92  10K_0201_5%  [R_0201]  35.45 60.72 90 bottom
RH93  10K_0201_5%  [R_0201]  33.66 59.26 180 bottom
RH94  620_0402_5%  [R_0402]  38.07 32.42 270 bottom
RH95  0_0201_5%  [R0201_0OHM]  31.67 36.4 180 top
RH96  30_0201_5%  [R_0201]  36.42 32.12 270 bottom
RH97  10K_0201_5%  [R_0201]  39.4 59.63 90 bottom
RH98  10K_0201_5%  [R_0201]  38.83 59.63 90 bottom
RH99  10M_0402_5%  [R_0402]  22.27 38.63 90 bottom
RH100  2.7K_0201_1%  [R_0201]  43.37 32.59 0 bottom
RH101  10K_0201_5%  [R_0201]  20.72 48.09 0 bottom
RH102  10K_0201_5%  [R_0201]  22.18 48.6 0 top
RH103  10K_0201_5%  [R_0201]  22.18 49.36 0 top
RH104  10K_0201_5%  [R_0201]  21.52 51.14 0 top
RH105  1M_0402_5%  [R_0402]  47.8 30.97 180 bottom
RH106  10K_0201_5%  [R_0201]  34.58 59.99 90 bottom
RH107  10K_0201_5%  [R_0201]  19.86 46.88 180 bottom
RH109  3.3K_0402_5%  [R_0402]  18.94 53.68 0 bottom
RH110  1K_0402_5%  [R_0402]  19.86 51.9 180 bottom
RH111  1K_0402_5%  [R_0402]  18.94 52.79 0 bottom
RH112  10K_0201_5%  [R_0201]  33.94 60.92 90 bottom
RH113  10K_0201_5%  [R_0201]  31.72 54.36 90 top
RH114  1K_0402_5%  [R_0402]  19.64 60.53 0 bottom
RH115  330K_0402_5%  [R_0402]  17.61 42.87 180 bottom
RH116  33_0402_5%  [R_0402]  19.64 59.65 0 bottom
RH117  0_0402_1%  [R0402_0OHM]  17.75 51.72 90 top
RH118  0_0402_5%  [R_0402]  16.99 51.72 90 top
RH122  0_0603_5%  [R0603_0OHM]  19.66 58.57 0 bottom
RH123  100K_0402_5%  [R_0402]  18.82 51.67 0 top
RH124  1K_0201_5%  [R_0201]  21.35 42.12 180 bottom
RH125  8.2K_0402_5%  [R_0402]  19.61 42.88 180 bottom
RH126  10K_0201_5%  [R_0201]  21.38 43.01 180 bottom
RH128  10K_0201_5%  [R_0201]  19.61 41.67 180 bottom
RH129  1M_0402_5%  [R_0402]  17.83 44.71 180 bottom
RH130  30_0201_5%  [R_0201]  32.99 31.54 90 bottom
RH131  20K_0402_5%  [R_0402]  16.91 41.04 0 bottom
RH132  8.2K_0201_5%  [R_0201]  28.65 30.31 90 bottom
RH133  30_0201_5%  [R_0201]  32.36 31.54 90 bottom
RH134  8.2K_0402_5%  [R_0402]  21.26 48.85 180 top
RH135  20K_0402_5%  [R_0402]  16.91 38.82 0 bottom
RH136  4.7K_0201_5%  [R_0201]  18.94 49.42 0 bottom
RH137  0_0201_5%  [R0201_0OHM]  19.47 35.96 0 bottom
RH138  0_0201_5%  [R0201_0OHM]  29.88 39.29 90 top
RH139  1K_0201_5%  [R_0201]  27.09 60.86 270 bottom
RH140  1K_0201_5%  [R_0201]  27.28 59.34 270 top
RH141  1K_0201_5%  [R_0201]  28.8 60.86 270 bottom
RH142  1K_0201_5%  [R_0201]  28.23 60.86 270 bottom
RH148  10K_0201_5%  [R_0201]  31.77 53.42 0 top
RH151  4.7K_0201_5%  [R_0201]  27.66 60.86 270 bottom
RH152  100K_0201_5%  [R_0201]  29.31 39.29 90 top
RH153  100K_0201_5%  [R_0201]  23.09 27.86 90 bottom
RH154  4.7K_0201_5%  [R_0201]  30.07 46.74 90 top
RH155  1K_0402_5%  [R_0402]  3.04 9.84 0 top
RH156  1K_0402_5%  [R_0402]  3.04 8.06 0 top
RH157  0_0402_5%  [R0402_0OHM]  3.04 8.95 0 top
RH158  100_0402_1%  [R_0402]  49.67 43.95 90 bottom
RH159  10K_0201_5%  [R_0201]  36.38 59.54 90 bottom
RH160  10K_0201_5%  [R_0201]  32.76 60.85 0 bottom
RH161  10K_0201_5%  [R_0201]  36.38 60.72 90 bottom
RH162  10K_0201_5%  [R_0201]  35.45 59.56 90 bottom
RH163  113_0201_1%  [R_0201]  39.47 32.25 270 bottom
RH164  0_0201_5%  [R0201_0OHM]  40.23 32.25 270 bottom
RH165  0_0201_5%  [R0201_0OHM]  38.83 32.25 270 bottom
RH166  10K_0201_5%  [R_0201]  21.76 42.94 180 top
RH167  10K_0201_5%  [R_0201]  19.88 43.01 180 top
RH168  15_0402_5%  [R_0402]  17.61 43.76 180 bottom
RH169  22_0402_5%  [R_0402]  19.86 43.71 180 top
RH174  100K_0201_5%  [R_0201]  30.01 59.25 90 bottom
RH175  10K_0201_5%  [R_0201]  22.18 50.25 0 top
RH176  49.9K_0201_1%  [R_0201]  30.71 53.35 90 top
RH177  100K_0201_5%  [R_0201]  33.11 59.91 180 top
RH178  49.9K_0201_1%  [R_0201]  30.58 59.84 270 bottom
RH179  10K_0201_5%  [R_0201]  34.6 51.45 0 top
RH180  10K_0201_5%  [R_0201]  19.44 56.28 180 top
RH181  1K_0201_5%  [R_0201]  34.6 50.82 0 top
RH182  100K_0201_5%  [R_0201]  18.94 50.37 0 bottom
RH189  10K_0201_5%  [R_0201]  28.25 61.55 0 bottom
RH190  10K_0201_5%  [R_0201]  29.44 59.84 270 bottom
RH191  10K_0201_5%  [R_0201]  18.42 5.61 180 top
RH192  10K_0201_5%  [R_0201]  31.87 59.26 0 bottom
RH193  100K_0201_5%  [R_0201]  21.64 49.42 180 bottom
RH194  4.7K_0201_5%  [R_0201]  30.83 46.91 90 top
RH195  100K_0201_5%  [R_0201]  22.43 56.08 0 top
RH196  100K_0201_5%  [R_0201]  22.43 55.19 0 top
RH197  4.7K_0201_5%  [R_0201]  20.72 50.37 0 bottom
RH198  100K_0201_5%  [R_0201]  23.34 56.97 180 top
RH199  100K_0201_5%  [R_0201]  23.34 54.3 180 top
RH201  0_0402_5%  [R_0402]  29.63 50.18 180 top
RH202  0_0603_5%  [R0603_0OHM]  39.91 47.71 0 top
RH203  0_0603_5%  [R0603_0OHM]  35.59 38.31 180 top
RH204  0_0603_5%  [R0603_0OHM]  22.51 59.84 270 bottom
RH205  0_0603_5%  [R0603_0OHM]  40.61 33.55 90 top
RH206  0_0603_5%  [R_0603]  40.19 42.6 90 top
RH212  0_0201_5%  [R0201_0OHM]  23.17 39.2 0 bottom
RH213  0_0201_5%  [R0201_0OHM]  23.17 39.77 0 bottom
RH214  33_0201_1%  [R_0201]  47.79 31.73 90 bottom
RH215  33_0201_1%  [R_0201]  46.96 31.73 90 bottom
RH216  0_0402_5%  [R_0402]  108.3 78.36 90 top
RH218  10K_0201_5%  [R_0201]  37.18 52.57 270 top
RH219  10K_0201_5%  [R_0201]  37.94 51.3 270 top
RH220  10K_0201_5%  [R_0201]  38.71 51.3 270 top
RH221  10K_0201_5%  [R_0201]  37.94 52.57 270 top
RH222  10K_0201_5%  [R_0201]  37.9 61.36 270 bottom
RH223  10K_0201_5%  [R_0201]  37.18 51.3 270 top
RH224  10K_0201_5%  [R_0201]  37.09 61.23 270 bottom
RH225  10K_0201_5%  [R_0201]  38.71 52.57 270 top
RH226  10K_0201_5%  [R_0201]  37.09 59.47 90 bottom
RH227  10K_0201_5%  [R_0201]  37.9 59.57 90 bottom
RH228  0_0402_5%  [R0402_0OHM]  130.32 51.57 90 bottom
RH465  0_0402_5%  [R0402_0OHM]  131.46 51.57 90 bottom
RH466  100_0402_1%  [R_0402]  131.46 50.74 180 bottom
RH467  100_0402_1%  [R_0402]  128.57 52.46 0 bottom
RH468  0_0201_5%  [R0201_0OHM]  20.1 61.93 180 bottom
RH469  0_0201_5%  [R0201_0OHM]  20.1 61.32 180 bottom
RH480  200_0402_1%  [R_0402]  81.89 60.84 90 top
RH481  200_0402_1%  [R_0402]  70.98 86.19 180 bottom
RH482  150_0402_1%  [R_0402]  70.98 85.3 180 bottom
RH483  200_0402_1%  [R_0402]  79.46 81.11 0 top
RH484  100_0402_1%  [R_0402]  83.98 62.72 180 top
RH485  100_0402_1%  [R_0402]  84.38 61.8 180 top
RH486  5.1K_0201_1%  [R_0201]  87.54 90.23 270 bottom
RH488  5.1K_0201_1%  [R_0201]  88.17 90.23 270 bottom
RH491  5.1K_0201_1%  [R_0201]  88.81 90.23 270 bottom
RH492  5.1K_0201_1%  [R_0201]  88.36 88.44 90 bottom
RH493  5.1K_0201_1%  [R_0201]  92.11 90.09 90 bottom
RH494  5.1K_0201_1%  [R_0201]  84.13 90.23 0 bottom
RH495  5.1K_0201_1%  [R_0201]  78.52 90.89 270 bottom
RH496  5.1K_0201_1%  [R_0201]  79.68 90.87 270 bottom
RH497  5.1K_0201_1%  [R_0201]  70.48 86.95 0 bottom
RH498  5.1K_0201_1%  [R_0201]  79.09 90.89 270 bottom
RH499  5.1K_0201_1%  [R_0201]  77.95 90.89 270 bottom
RH500  5.1K_0201_1%  [R_0201]  77.38 90.89 270 bottom
RH501  5.1K_0201_1%  [R_0201]  76.81 90.89 270 bottom
RH502  5.1K_0201_1%  [R_0201]  70.48 87.52 0 bottom
RH503  5.1K_0201_1%  [R_0201]  89.13 88.44 90 bottom
RH504  5.1K_0201_1%  [R_0201]  91.47 90.09 90 bottom
RH505  5.1K_0201_1%  [R_0201]  86.9 90.23 270 bottom
RH506  5.1K_0201_1%  [R_0201]  86.27 89.02 270 bottom
RH517  5.1K_0201_1%  [R_0201]  90.84 90.09 90 bottom
RH521  5.1K_0201_1%  [R_0201]  90.84 91.88 270 bottom
RH522  5.1K_0201_1%  [R_0201]  90.08 91.88 270 bottom
RH523  5.1K_0201_1%  [R_0201]  92.11 91.88 270 bottom
RH524  5.1K_0201_1%  [R_0201]  85.92 90.23 180 bottom
RH525  5.1K_0201_1%  [R_0201]  87.73 88.44 90 bottom
RH526  5.1K_0201_1%  [R_0201]  91.47 91.88 270 bottom
RH527  5.1K_0201_1%  [R_0201]  90.08 90.09 90 bottom
RH528  5.1K_0201_1%  [R_0201]  86.97 89.02 270 bottom
RH530  1K_0201_5%  [R_0201]  69.82 9.75 270 bottom
RH531  1K_0201_5%  [R_0201]  70.42 9.16 0 bottom
RH532  1K_0201_5%  [R_0201]  89.44 90.23 270 bottom
RH533  1K_0201_5%  [R_0201]  89.89 88.44 90 bottom
RH534  33_0201_1%  [R_0201]  91.41 93.13 90 bottom
RH535  33_0201_1%  [R_0201]  92.11 93.07 90 bottom
RH536  10K_0201_5%  [R_0201]  90.65 93.13 90 bottom
RH537  10K_0201_5%  [R_0201]  92.74 93.07 90 bottom
RH538  1K_0201_5%  [R_0201]  84.81 81.45 90 top
RH539  1K_0201_5%  [R_0201]  78.65 53.93 90 bottom
RH540  0_0402_5%  [R0402_0OHM]  84.81 53.47 90 bottom
RH541  16.2K_0402_1%  [R_0402]  79.46 82 0 top
RH542  16.2K_0402_1%  [R_0402]  80.36 62.74 90 top
RH543  0_0603_5%  [R0603_0OHM]  85.7 69.23 180 top
RH544  1K_0402_5%  [R_0402]  83.98 63.61 180 top
RH545  0_0603_5%  [R0603_0OHM]  110.59 68.24 90 top
RH546  0_0603_5%  [R0603_0OHM]  109.32 68.24 90 top
RH547  51.1_0402_1%  [R_0402]  79.47 62.74 90 top
RH548  51.1_0402_1%  [R_0402]  80.93 60.84 90 top
RH549  0_0402_5%  [R0402_0OHM]  86.2 53.47 90 bottom
RH550  0_0201_5%  [R0201_0OHM]  85.51 53.64 90 bottom
RH553  10K_0201_5%  [R_0201]  81.76 81.45 90 top
RH554  10K_0201_5%  [R_0201]  81.12 81.45 90 top
RH559  0_0402_5%  [R_0402]  86.71 81.03 90 top
RH560  0_0402_5%  [R_0402]  85.7 81.03 90 top
RH561  0_0201_5%  [R0201_0OHM]  107.86 65 270 top
RH562  0_0201_5%  [R0201_0OHM]  108.49 65 270 top
RH567  0_0201_5%  [R0201_0OHM]  83.28 53.64 90 bottom
RH568  1K_0201_5%  [R_0201]  81.38 51.8 90 bottom
RH569  10K_0201_5%  [R_0201]  104.91 90.51 180 bottom
RH570  10K_0201_5%  [R_0201]  93.82 89.78 270 bottom
RH571  0_0402_5%  [R_0402]  104.62 92.86 270 bottom
RH572  100K_0201_5%  [R_0201]  60.59 24.34 180 top
RH573  100K_0402_5%  [R_0402]  58.77 18.67 90 top
RH574  300K_0402_1%  [R_0402]  60.55 19.59 270 top
RH575  1K_0402_5%  [R_0402]  64.63 20.15 180 top
RH576  10K_0201_5%  [R_0201]  63.86 24.34 0 top
RH581  100K_0402_5%  [R_0402]  62.63 16.85 0 top
RH582  10K_0402_5%  [R_0402]  61.69 15.14 270 top
RH583  100K_0402_5%  [R_0402]  63.34 12.78 180 top
RH584  2.2K_0402_5%  [R_0402]  18.46 33.93 180 bottom
RH586  2.2K_0402_5%  [R_0402]  18.46 34.82 180 bottom
RH587  1K_0201_5%  [R_0201]  24.02 60.92 270 bottom
RH588  1K_0201_5%  [R_0201]  23.44 60.92 270 bottom
RH589  0_0402_5%  [R0402_0OHM]  57.93 16.59 0 top
RH591  10K_0201_5%  [R_0201]  21.6 44.91 180 bottom
RH592  10K_0201_5%  [R_0201]  21.6 45.61 180 bottom
RH593  10K_0201_5%  [R_0201]  19.08 45.84 270 bottom
RH594  10K_0201_5%  [R_0201]  19.74 45.61 0 bottom
RH596  10K_0201_5%  [R_0201]  21.6 44.15 180 bottom
RH600  0_0201_5%  [R0201_0OHM]  56.96 13.16 0 top
RH601  0_0201_5%  [R0201_0OHM]  57.54 12.53 180 top
RH602  0_0201_5%  [R_0201]  55.56 13.29 0 top
RH603  100K_0402_5%  [R_0402]  58.26 9.99 90 top
RH604  0_0402_5%  [R0402_0OHM]  59.58 10.24 0 top
RH605  100K_0402_5%  [R_0402]  54.96 18.55 90 top
RH606  10K_0402_5%  [R_0402]  60.63 16.59 180 top
RH607  10K_0201_5%  [R_0201]  93.82 91.23 90 bottom
RH608  5.1K_0201_1%  [R_0201]  83.16 81.45 90 top
RH609  0_0201_5%  [R0201_0OHM]  43.24 59.26 0 bottom
RH610  0_0201_5%  [R0201_0OHM]  38.58 61.42 270 bottom
RH611  4.7K_0201_5%  [R_0201]  26.51 60.86 270 bottom
RH612  100K_0201_5%  [R_0201]  33.1 59.3 180 top
RH613  10K_0201_5%  [R_0201]  56.74 67.1 90 bottom
RH614  10K_0201_5%  [R_0201]  53.82 67.1 90 bottom
RH617  100K_0201_5%  [R_0201]  27.15 30.69 270 bottom
RH618  100K_0201_5%  [R_0201]  27.15 32.34 270 bottom
RH619  100K_0201_5%  [R_0201]  29.18 32.34 270 bottom
RH620  100K_0201_5%  [R_0201]  25.59 37.61 0 top
RH621  15_0402_5%  [R_0402]  25.83 45.42 180 top
RH622  15_0402_5%  [R_0402]  25.83 46.31 180 top
RH623  15_0402_5%  [R_0402]  25.83 44.53 180 top
RH624  15_0402_5%  [R_0402]  25.83 43.64 180 top
RH625  10K_0201_5%  [R_0201]  21.35 41.48 180 bottom
RH626  0_0201_5%  [R_0201]  20.67 36.28 0 bottom
RH627  10K_0201_5%  [R_0201]  58.26 65.02 270 bottom
RH628  10K_0201_5%  [R_0201]  54.62 65.11 180 bottom
RH633  0_0201_5%  [R0201_0OHM]  63.61 83.79 0 top
RH634  4.7K_0402_5%  [R_0402]  62.89 87.71 0 top
RH635  2.2K_0201_5%  [R_0201]  62.43 83.79 0 top
RH636  0_0201_5%  [R_0201]  23.64 45.7 180 bottom
RH637  0_0201_5%  [R_0201]  22.46 45.12 270 bottom
RH638  0_0201_5%  [R_0201]  23.05 45.13 0 bottom
RH639  100K_0201_5%  [R_0201]  31.56 60.28 0 bottom
RH640  100K_0201_5%  [R_0201]  31.63 60.92 180 bottom
RH641  0_0603_5%  [R0603_0OHM]  33.37 44.15 90 top
RH642  0_0603_5%  [R_0603]  33.25 43.01 0 top
RH643  10K_0201_5%  [R_0201]  21.56 60.45 270 bottom
RH644  10K_0201_5%  [R_0201]  22.28 60.6 0 bottom
RH645  10K_0201_5%  [R_0201]  19.36 48.09 0 bottom
RH646  0_0201_5%  [R0201_0OHM]  45.97 20.59 0 top
RH647  0_0201_5%  [R0201_0OHM]  42.58 24.57 270 top
RH648  0_0402_1%  [R0402_0OHM]  25.82 60.34 90 bottom
RH649  10K_0201_5%  [R_0201]  40.22 60.11 90 bottom
RH650  10K_0201_5%  [R_0201]  40.8 60.11 90 bottom
RH651  10K_0201_5%  [R_0201]  41.37 60.11 90 bottom
RH652  10K_0201_5%  [R_0201]  41.94 60.11 90 bottom
RH653  0_0201_5%  [R0201_0OHM]  34.87 59.26 180 bottom
RH654  100K_0201_5%  [R_0201]  36.02 55.71 90 top
RH655  0_0201_5%  [R_0201]  38.78 57.32 180 top
RH656  10K_0201_5%  [R_0201]  31.41 46.91 90 top
RH657  10K_0201_5%  [R_0201]  31.93 59.3 90 top
RH658  10K_0201_5%  [R_0201]  31.36 59.3 90 top
RH659  0_0201_5%  [R0201_0OHM]  48.93 12.67 180 bottom
RH660  10K_0201_5%  [R_0201]  23.63 46.36 180 bottom
RL1  820_0402_5%  [R_0402]  5.27 30.77 180 bottom
RL2  820_0402_5%  [R_0402]  5.06 34.14 180 bottom
RL3  820_0402_5%  [R_0402]  5.36 38.14 180 bottom
RL4  820_0402_5%  [R_0402]  5.24 41.06 180 bottom
RL5  820_0402_5%  [R_0402]  4.95 45.22 180 bottom
RP1  2.2K_0804_8P4R_5%  [RP_0804_8P4R]  24.3 31.96 270 bottom
RP2  10K_0804_8P4R_5%  [RP_0804_8P4R]  16.35 47.97 0 bottom
RP3  10K_0804_8P4R_5%  [RP_0804_8P4R]  21.24 52.99 0 bottom
RP4  10K_0804_8P4R_5%  [RP_0804_8P4R]  21.24 55.78 0 bottom
RP5  33_0804_8P4R_5%  [RP_0804_8P4R]  16.41 52.1 0 bottom
RP6  33_0804_8P4R_5%  [RP_0804_8P4R]  55.41 32.4 180 bottom
RP29  4.7K_0402_5%  [R_0402]  32.27 68.1 0 top
RP30  10K_0201_5%  [R_0201]  37.09 68.46 0 bottom
RP31  10K_0201_5%  [R_0201]  33.05 69.75 90 top
RP32  1K_0402_5%  [R_0402]  30.76 66.21 90 top
RP33  1K_0402_5%  [R_0402]  29.94 66.24 90 top
RP66  1.3K_0402_1%  [R_0402]  36.22 69.98 0 top
RP67  9.1K_0402_5%  [R_0402]  37.13 70.77 180 top
RP68  1.3K_0402_1%  [R_0402]  36.07 69.03 180 top
RP69  9.1K_0402_5%  [R_0402]  34.85 68.14 180 top
RP71  100K_0201_1%  [R_0201]  33.61 70.03 90 top
RP73  100K_0201_1%  [R_0201]  38.87 68.07 180 bottom
RP78  0_0201_5%  [R0201_0OHM]  38.3 65.31 0 bottom
RP79  0_0201_5%  [R0201_0OHM]  38.3 65.87 0 bottom
RP80  0_0201_5%  [R0201_0OHM]  38.86 66.92 180 bottom
RP81  0_0201_5%  [R0201_0OHM]  38.86 67.48 180 bottom
RP83  100K_0201_5%  [R_0201]  37.69 65.07 180 bottom
RP84  100K_0201_5%  [R_0201]  37.69 66.67 180 bottom
RP85  100K_0201_5%  [R_0201]  37.69 66.12 180 bottom
RP86  100K_0201_5%  [R_0201]  37.69 67.72 180 bottom
RP88  33_0804_8P4R_5%  [RP_0804_8P4R]  91.22 94.71 0 bottom
RP90  49.9K_0201_1%  [R_0201]  28.66 71.09 270 bottom
RP91  49.9K_0201_1%  [R_0201]  20.94 92.27 180 top
RP92  49.9K_0201_1%  [R_0201]  28.03 71.09 270 bottom
RP93  49.9K_0201_1%  [R_0201]  42.1 101.81 270 top
RP94  0_0603_5%  [R_0603]  32.23 65.19 180 top
RP96  0_0201_5%  [R0201_0OHM]  59.03 23.48 90 bottom
RP97  0_0201_5%  [R0201_0OHM]  58.39 23.48 90 bottom
RP98  0_0201_5%  [R0201_0OHM]  37.69 65.4 270 top
RP99  0_0603_5%  [R0603_0OHM]  33.42 64.61 270 top
RP102  0_0201_5%  [R0201_0OHM]  37.72 69.63 180 bottom
RP103  0_0201_5%  [R0201_0OHM]  37.72 70.21 180 bottom
RP104  0_0201_5%  [R0201_0OHM]  33.28 63.9 0 bottom
RP105  0_0201_5%  [R0201_0OHM]  35.06 63.9 180 bottom
RP108  100K_0201_5%  [R_0201]  42.72 68.28 180 bottom
RP109  100K_0201_5%  [R_0201]  43.02 70.66 270 bottom
RP110  100_0603_5%  [R_0603]  39.79 65.79 90 bottom
RP111  100_0603_5%  [R_0603]  38.9 70.77 270 bottom
RP112  54.9K_0201_1%  [R_0201]  19.48 70.06 90 bottom
RP114  100K_0201_5%  [R_0201]  22.05 69.07 180 bottom
RP115  54.9K_0201_1%  [R_0201]  21.17 99.57 0 top
RP117  100K_0201_5%  [R_0201]  21.61 101.49 0 top
RP118  0.01_0603_1%  [R_0603]  24.71 75.13 180 bottom
RP119  0.01_0603_1%  [R_0603]  28.62 99 90 top
RP120  100K_0201_5%  [R_0201]  36.75 68.66 0 top
RP121  56K_0201_1%  [R_0201]  39.68 65.55 0 top
RP122  56K_0201_1%  [R_0201]  39.06 65.55 180 top
RP123  100K_0201_5%  [R_0201]  36.75 69.3 0 top
RP124  56K_0201_1%  [R_0201]  36.76 71.77 0 top
RP125  56K_0201_1%  [R_0201]  36.14 71.77 180 top
RP126  0_0201_5%  [R_0201]  35.75 63.54 90 bottom
RP127  0_0201_5%  [R_0201]  37.46 63.54 90 bottom
RP128  0_0201_5%  [R0201_0OHM]  36.32 63.54 90 bottom
RP129  0_0201_5%  [R0201_0OHM]  36.89 63.54 90 bottom
RP130  0_0201_5%  [R_0201]  30.32 64.13 270 bottom
RP131  0_0201_5%  [R_0201]  32.04 64.13 270 bottom
RP132  0_0201_5%  [R0201_0OHM]  30.9 64.13 270 bottom
RP133  0_0201_5%  [R0201_0OHM]  31.47 64.13 270 bottom
RP137  887K_0402_1%  [R_0402]  26.83 69.06 270 bottom
RP138  200K_0402_1%  [R_0402]  26.07 69.06 270 bottom
RP139  887K_0402_1%  [R_0402]  31.61 94.82 180 bottom
RP140  200K_0402_1%  [R_0402]  32.56 95.71 180 bottom
RP141  0_0402_5%  [R0402_0OHM]  23.9 65.8 0 bottom
RP142  0_0402_5%  [R0402_0OHM]  28.93 95.79 270 bottom
RP143  0_0201_5%  [R_0201]  16.87 70.36 0 top
RP144  0_0201_5%  [R_0201]  25.1 90 180 top
RPE7  10K_0804_8P4R_5%  [RP_0804_8P4R]  54.89 8.16 0 bottom
RR1  0_0402_5%  [R0402_0OHM]  18.21 69.42 180 top
RR2  0_0402_5%  [R0402_0OHM]  18.21 68.66 180 top
RR3  0_0402_5%  [R0402_0OHM]  18.21 67.77 180 top
RR4  0_0402_5%  [R0402_0OHM]  18.21 63.33 180 top
RR5  0_0402_5%  [R0402_0OHM]  18.21 62.57 180 top
RR6  0_0402_5%  [R0402_0OHM]  18.21 61.8 180 top
RR7  0_0402_5%  [R0402_0OHM]  24.61 60.39 90 top
RR8  10K_0402_5%  [R_0402]  23.72 60.39 90 top
RR9  6.2K_0402_1%  [R_0402]  26.97 67.42 180 top
RR10  10K_0402_5%  [R_0402]  22.83 61.31 270 top
RR15  0_0201_5%  [R0201_0OHM]  54.68 96.45 270 top
RR16  0_0201_5%  [R0201_0OHM]  54.11 96.45 270 top
RR17  0_0201_5%  [R0201_0OHM]  53.53 96.55 270 top
RR20  0_0201_5%  [R0201_0OHM]  18.02 47.33 180 top
RR21  0_0201_5%  [R0201_0OHM]  18.02 46.69 180 top
RR34  0_0201_5%  [R0201_0OHM]  12.93 21.16 90 top
RR35  0_0201_5%  [R0201_0OHM]  12.93 23.07 270 top
RR38  0_0201_5%  [R_0201]  52.58 92.79 90 top
RR40  0_0201_5%  [R0201_0OHM]  53.21 92.79 90 top
RR41  10K_0402_5%  [R_0402]  19.34 58.6 90 top
RR43  100K_0201_5%  [R_0201]  64.42 99.14 180 bottom
RR44  100K_0201_5%  [R_0201]  55.57 101.1 180 top
RT3  10K_0402_5%  [R_0402]  41.5 88.93 270 top
RT4  10K_0402_5%  [R_0402]  39.72 88.93 270 top
RT5  10K_0402_5%  [R_0402]  40.61 88.93 270 top
RT6  10K_0402_5%  [R_0402]  42.39 88.93 270 top
RT7  3.01K_0402_1%  [R_0402]  38.88 76.22 90 top
RT9  14K_0402_1%  [R_0402]  38.83 86.39 270 top
RT10  10K_0201_1%  [R_0201]  45.95 84.97 270 bottom
RT11  2.2K_0201_5%  [R_0201]  41.88 89.78 270 bottom
RT13  2.2K_0201_5%  [R_0201]  42.52 89.78 270 bottom
RT14  10K_0201_1%  [R_0201]  35.47 91.05 270 top
RT16  0_0201_5%  [R0201_0OHM]  35.47 88.51 270 top
RT17  0_0201_5%  [R_0201]  36.61 91.05 270 top
RT18  100_0201_1%  [R_0201]  35.28 88.51 270 bottom
RT19  10K_0201_1%  [R_0201]  36.42 89.78 270 bottom
RT20  10K_0201_1%  [R_0201]  34.9 89.78 270 top
RT21  100_0201_1%  [R_0201]  45.34 84.41 180 bottom
RT23  14K_0402_1%  [R_0402]  41.75 78.61 0 top
RT24  33_0201_1%  [R_0201]  30.54 75.01 0 bottom
RT25  2.2K_0201_5%  [R_0201]  39.91 89.78 270 bottom
RT26  2.2K_0201_5%  [R_0201]  39.34 89.78 270 bottom
RT27  10K_0201_1%  [R_0201]  41.88 88.51 270 bottom
RT28  4.75K_0402_0.5%  [R_0402]  35.58 84.73 0 top
RT29  10K_0201_1%  [R_0201]  41.31 88.51 270 bottom
RT30  10K_0201_1%  [R_0201]  36.99 89.78 270 bottom
RT31  10K_0201_1%  [R_0201]  36.61 89.78 270 top
RT32  100K_0201_5%  [R_0201]  40.61 89.78 270 bottom
RT33  10K_0201_1%  [R_0201]  36.1 86.35 270 top
RT34  10K_0201_1%  [R_0201]  35.85 89.78 270 bottom
RT35  100K_0201_5%  [R_0201]  34.32 89.78 270 top
RT36  100K_0201_5%  [R_0201]  37.27 85.93 0 top
RT37  1M_0201_1%  [R_0201]  31.59 83.36 90 top
RT38  1M_0201_1%  [R_0201]  30.98 84.98 0 top
RT39  100K_0201_5%  [R_0201]  38.13 88.51 270 bottom
RT40  1M_0201_1%  [R_0201]  32.19 84.98 0 top
RT41  1M_0201_1%  [R_0201]  33.25 83.29 90 top
RT42  499_0201_1%  [R_0201]  35.89 77.09 270 top
RT43  499_0201_1%  [R_0201]  35.25 76.51 90 top
RT44  2.2K_0201_1%  [R_0201]  52.8 102.53 90 bottom
RT45  2.2K_0201_1%  [R_0201]  45.34 85.56 180 bottom
RT46  2.2K_0201_1%  [R_0201]  45.34 84.97 180 bottom
RT47  2.2K_0201_1%  [R_0201]  41.31 89.78 270 bottom
RT49  0_0603_5%  [R0603_0OHM]  27.72 86.32 90 bottom
RT50  0_0603_5%  [R0603_0OHM]  29.94 88.92 270 top
RT69  0_0201_5%  [R_0201]  36.04 91.05 270 top
RT71  0_0201_5%  [R0201_0OHM]  46.53 84.38 90 bottom
RT72  33_0201_1%  [R_0201]  30.54 75.58 0 bottom
RT80  100K_0201_5%  [R_0201]  43.32 85.11 180 top
RT81  100K_0201_5%  [R_0201]  38.96 88.51 270 top
RT82  100K_0201_5%  [R_0201]  43.32 83.84 180 top
RT83  100K_0201_5%  [R_0201]  38.96 89.72 270 top
RT84  10K_0201_1%  [R_0201]  35.47 89.78 270 top
RT91  0_0201_5%  [R_0201]  42.73 85.68 0 top
RT92  0_0201_5%  [R_0201]  38.39 87.93 90 top
RT93  0_0201_5%  [R_0201]  42.73 83.27 0 top
RT94  0_0201_5%  [R_0201]  38.39 89.13 90 top
RT100  10K_0201_1%  [R_0201]  35.28 89.78 270 bottom
RT226  0_0201_5%  [R_0201]  46.2 86.86 270 top
RT233  0_0201_5%  [R0201_0OHM]  43.09 89.78 270 bottom
RT234  0_0201_5%  [R0201_0OHM]  43.09 90.79 90 bottom
RT235  0_0201_5%  [R0201_0OHM]  47.76 91.46 180 bottom
RT236  0_0201_5%  [R0201_0OHM]  45.56 86.28 90 top
RT237  0_0201_5%  [R0201_0OHM]  44.74 88.51 270 bottom
RT238  10K_0201_5%  [R_0201]  47.7 89.05 0 bottom
RT239  10K_0201_5%  [R_0201]  48.27 85.83 180 bottom
RT240  1M_0402_5%  [R_0402]  48.24 90.76 180 bottom
RT241  1M_0402_5%  [R_0402]  47.01 88.09 0 top
RT242  0_0201_5%  [R0201_0OHM]  47.32 89.05 0 top
RT415  0_0201_5%  [R0201_0OHM]  42.83 87.93 90 bottom
RT418  0_0201_5%  [R0201_0OHM]  37.86 86.51 180 top
RT419  0_0201_5%  [R0201_0OHM]  38.71 88.51 270 bottom
RT420  0_0201_5%  [R0201_0OHM]  36.42 87.93 90 bottom
RT421  0_0201_5%  [R0201_0OHM]  34.9 87.93 90 top
RT422  0_0201_5%  [R0201_0OHM]  39.91 87.93 90 bottom
RT423  0_0201_5%  [R0201_0OHM]  39.34 87.93 90 bottom
RT424  0_0201_5%  [R0201_0OHM]  36.61 87.93 90 top
RT425  0_0201_5%  [R0201_0OHM]  35.85 87.93 90 bottom
RT426  0_0201_5%  [R0201_0OHM]  36.99 87.93 90 bottom
RT427  0_0201_5%  [R_0201]  34.86 85.74 0 top
RT428  0_0402_5%  [R_0402]  34.88 87.14 0 top
RT429  0_0201_5%  [R_0201]  44.74 88.51 270 top
RT430  0_0201_5%  [R_0201]  46.2 88.51 270 top
RT431  0_0201_5%  [R_0201]  45.56 88.51 270 top
RTCD1  RB751S40T1G_SOD523-2  [AZ5125-01HPR7G_SOD523-2]  161.27 9.62 0 bottom
RTCD2  RB751S40T1G_SOD523-2  [AZ5125-01HPR7G_SOD523-2]  160.6 16.31 270 top
RTCR1  1K_0402_5%  [R_0402]  161.58 16.31 270 top
RTCR2  0_0402_5%  [R_0402]  161.97 8.65 0 bottom
RV783  10K_0402_5%  [R_0402]  61.46 93.8 180 top
RV784  1M_0402_5%  [R_0402]  61.2 99.68 0 top
RV785  100K_0402_5%  [R_0402]  63.56 98.44 0 top
RV786  4.7K_0402_5%  [R_0402]  62.43 93.77 0 top
RV787  220K_0402_5%  [R_0402]  66.67 95.69 90 top
RV788  0_0402_5%  [R_0402]  58.33 94.52 270 top
RV789  0_0402_5%  [R0402_0OHM]  49.95 93.76 270 top
RV790  0_0402_5%  [R0402_0OHM]  49.06 93.76 270 top
RV791  0_0402_5%  [R0402_0OHM]  48.17 93.76 270 top
RV792  0_0402_5%  [R0402_0OHM]  47.28 93.76 270 top
RV793  0_0402_5%  [R0402_0OHM]  46.39 93.76 270 top
RV794  0_0402_5%  [R0402_0OHM]  45.5 93.76 270 top
RV795  0_0402_5%  [R0402_0OHM]  44.6 93.33 270 top
RV796  0_0402_5%  [R0402_0OHM]  43.71 93.33 270 top
RV797  0_0402_5%  [R0402_0OHM]  51.72 93.76 270 top
RV798  0_0402_5%  [R0402_0OHM]  58.15 98.01 270 top
RV800  0_0402_5%  [R0402_0OHM]  50.83 93.76 270 top
RV808  0_0603_5%  [R0603_0OHM]  65.76 94.8 270 top
RV810  100K_0201_5%  [R_0201]  119.78 19.87 0 top
RV811  1M_0201_1%  [R_0201]  119.01 18.97 90 top
RW1  820_0402_5%  [R_0402]  99.44 17.1 180 top
RW2  10K_0201_5%  [R_0201]  66.58 2.11 270 bottom
RZ7  0_0603_5%  [R0603_0OHM]  91.86 28.15 180 bottom
RZ8  0_0805_5%  [R_0805]  27.31 29.29 0 top
RZ10  0_0603_5%  [R0603_0OHM]  21.31 33.74 0 bottom
RZ11  0_0603_5%  [R0603_0OHM]  54.62 101.8 270 bottom
RZ13  100K_0402_5%  [R_0402]  57.34 105.43 180 bottom
RZ14  0_0603_5%  [R0603_0OHM]  20.55 57.74 90 top
RZ16  0_0402_5%  [R0402_0OHM]  76.86 22.82 0 bottom
RZ17  0_0402_5%  [R_0402]  76.86 21.93 0 bottom
RZ18  0_0805_5%  [R_0805]  83.41 21.84 90 bottom
RZ19  0_0603_5%  [R0603_0OHM]  63.71 89.34 90 bottom
RZ20  100K_0402_5%  [R_0402]  76.86 21.04 0 bottom
RZ21  100K_0402_5%  [R_0402]  68.37 91.7 270 bottom
RZ22  0_0603_5%  [R0603_0OHM]  112.39 29.31 0 top
RZ23  0_0402_5%  [R0402_0OHM]  36.99 30.13 270 top
RZ26  0_0402_5%  [R_0402]  32.93 29.09 90 top
RZ28  100K_0402_5%  [R_0402]  37 28.02 180 top
RZ29  100K_0402_5%  [R_0402]  34.06 28.02 0 top
RZ30  0_0402_5%  [R0402_0OHM]  41.3 29.17 0 top
RZ36  100K_0402_5%  [R_0402]  42.21 30.05 180 top
RZ37  0_0402_5%  [R0402_0OHM]  50.39 25.05 270 top
RZ38  0_0603_5%  [R0603_0OHM]  84.81 28.09 270 bottom
RZ39  100K_0402_5%  [R_0402]  50.39 23.02 270 top
RZ40  100K_0402_5%  [R_0402]  43.84 27.64 0 top
RZ41  100K_0402_5%  [R_0402]  46.33 25.41 90 top
RZ42  0_0402_5%  [R_0402]  40.03 24.53 0 top
RZ43  0_0402_5%  [R0402_0OHM]  116.67 100.54 0 top
RZ44  0_0603_5%  [R0603_0OHM]  118.53 95.4 180 top
RZ45  0_0402_5%  [R_0402]  116.61 101.49 0 top
RZ49  0_0402_1%  [R0402_0OHM]  147.18 102.25 180 top
RZ50  100K_0402_5%  [R_0402]  149.58 99.04 0 top
RZ57  0_0201_5%  [R_0201]  19.19 31.32 180 bottom
RZ58  0_0201_5%  [R0201_0OHM]  18.6 30.69 0 bottom
RZ60  10K_0402_5%  [R_0402]  56.24 21.51 90 top
RZ61  10K_0402_5%  [R_0402]  56.25 24.09 270 top
RZ62  100K_0201_5%  [R_0201]  56.95 23.19 90 top
SW1  SSAL120100_3P  [SW_SSAL120100_3P]  2.63 14.57 90 top
SW3  NTC311-EA1T-A160T_4P  [SW_NTC311-EA1T-A160T_4P]  4.79 52.43 270 top
SW4  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  64.3 2.32 180 bottom
SW5  MSS3-Q-T-R_3P  [SW_MSS3-Q-T-R_3P]  6.11 15.5 90 bottom
T49  PAD~D  [TPC12]  42.39 59.33 180 bottom
T52  PAD~D  [TPC12]  34.78 52.28 0 top
T53  PAD~D  [TPC12]  36.08 52.28 0 top
T54  PAD~D  [TPC12]  36.04 50.17 0 top
T55  PAD~D  [TPC12]  36.04 53.78 0 top
T59  PAD~D  [TPC12]  44.68 60.34 180 bottom
T60  PAD~D  [TPC12]  24.86 53.23 180 bottom
T61  PAD~D  [TPC12]  23.72 43.52 180 bottom
T62  PAD~D  [TPC12]  28.84 51.15 0 top
T67  PAD~D  [TPC12]  33.75 51.49 0 top
T79  PAD~D  [TPC12]  45.55 14.41 180 bottom
T117  PAD~D  [TPC12]  89.89 83.17 0 top
T118  PAD~D  [TPC12]  90.02 84.56 0 top
T119  PAD~D  [TPC12]  88.57 82.89 0 top
T551  PAD~D  [TPC12]  105.38 65.87 0 top
T556  PAD~D  [TPC12]  107.16 65.87 0 top
T724  PAD~D  [TPC12]  132.07 75.32 0 top
T725  PAD~D  [TPC12]  131.1 74.46 0 top
T726  PAD~D  [TPC12]  129.64 74.41 0 top
T727  PAD~D  [TPC12]  130.43 73.37 0 top
T748  PAD~D  [TPC12]  131.04 78.44 0 top
T749  PAD~D  [TPC12]  38.16 90.06 180 bottom
T766  PAD~D  [TPC12]  83.75 59.98 0 top
T778  PAD~D  [TPC12]  79.28 60.6 0 top
T779  PAD~D  [TPC12]  80.17 62.06 0 top
T780  PAD~D  [TPC12]  75.34 81.19 0 top
T781  PAD~D  [TPC12]  76.65 81.23 0 top
T801  PAD~D  [TPC12]  84.2 58.74 0 top
T802  PAD~D  [TPC12]  83.35 57.29 0 top
T810  PAD~D  [TPC12]  24.61 38.63 180 bottom
T812  PAD~D  [TPC12]  42.47 33.52 180 bottom
T813  PAD~D  [TPC12]  41.07 33.47 180 bottom
T814  PAD~D  [TPC12]  131.44 58.83 0 top
T815  PAD~D  [TPC12]  132.4 57.96 0 top
T816  PAD~D  [TPC12]  131.41 57.15 0 top
T817  PAD~D  [TPC12]  132.44 56.33 0 top
T818  PAD~D  [TPC12]  131.48 90.44 180 bottom
T819  PAD~D  [TPC12]  132.81 90.44 180 bottom
T820  PAD~D  [TPC12]  130.15 90.44 180 bottom
T821  PAD~D  [TPC12]  128.81 90.44 180 bottom
T822  PAD~D  [TPC12]  73.12 53.74 180 bottom
T823  PAD~D  [TPC12]  74.01 53.74 180 bottom
T824  PAD~D  [TPC12]  74.9 53.74 180 bottom
T825  PAD~D  [TPC12]  75.79 53.74 180 bottom
T826  PAD~D  [TPC12]  76.88 89.46 180 bottom
T827  PAD~D  [TPC12]  75.6 89.54 180 bottom
T828  PAD~D  [TPC12]  74.3 89.59 180 bottom
T829  PAD~D  [TPC12]  73.03 89.48 180 bottom
T831  PAD~D  [TPC12]  38.51 9.35 0 top
T832  PAD~D  [TPC12]  38.55 8.39 0 top
T833  PAD~D  [TPC12]  48.69 10.45 180 bottom
T834  PAD~D  [TPC12]  137.83 81.49 0 top
TP_CFG1  PAD~D  [TPC12]  141.94 80.87 0 top
TP_CFG2  PAD~D  [TPC12]  138.2 84.45 0 top
TP_CFG3  PAD~D  [TPC12]  138.22 83.7 0 top
TP_CFG8  PAD~D  [TPC12]  142.72 80.17 0 top
TP_CFG9  PAD~D  [TPC12]  144.11 79.45 0 top
TP_CFG10  PAD~D  [TPC12]  140.63 80.29 0 top
TP_CFG11  PAD~D  [TPC12]  138.2 82.86 0 top
TP_CFG12  PAD~D  [TPC12]  143.23 81.31 0 top
TP_CFG13  PAD~D  [TPC12]  142.71 80.78 0 top
TP_CFG14  PAD~D  [TPC12]  143.72 80.7 0 top
TP_CFG15  PAD~D  [TPC12]  141.27 80.32 0 top
TP_CFG16  PAD~D  [TPC12]  144.09 80.1 0 top
TP_CFG17  PAD~D  [TPC12]  140.63 81 0 top
TP_CFG18  PAD~D  [TPC12]  141.92 80.24 0 top
TP_CFG19  PAD~D  [TPC12]  141.27 80.97 0 top
TP_ITP_PMODE  PAD~D  [TPC12]  143.43 79.68 0 top
TP_JTAG_TCK  PAD~D  [TPC12]  139.9 80.41 0 top
TP_JTAG_TDI  PAD~D  [TPC12]  138.63 80.42 0 top
TP_JTAG_TMS  PAD~D  [TPC12]  139.28 80.43 0 top
TP_PROC_PRDYN  PAD~D  [TPC12]  144.6 78.91 0 top
TP_PROC_TRSTN  PAD~D  [TPC12]  28.16 32.28 180 bottom
U14  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  66.14 86.05 0 top
U15  -  [G9661-25ADJRE1U_TDFN10_3X3]  57.79 71.7 270 bottom
U18  -  [LNG2DMTR_LGA12_2X2]  66.28 18.02 270 bottom
U20  APX8131AI-TRG SOT-23  [APX8131AI-TRG_SOT23-3]  14.55 76.78 270 top
U736  -  [APE8937GN2_DFN8_2X2]  15.92 28.51 0 top
U4253  -  [TS5A3159ADCKR_SC70-6]  44.25 89.67 90 bottom
U4254  -  [TS5A3159ADCKR_SC70-6]  45.96 86.74 90 bottom
UC1  INS139440466  [KABYLAKE-G_BGA_2270P-T]  75.27 86.42 90 bottom
UC4  -  [74AUP1G02GW_TSSOP5]  37.51 73.22 90 top
UC5  -  [74AUP1G02GW_TSSOP5]  29.35 63.39 270 top
UC6  -  [74AUP1G07GW_TSSOP5]  78.96 109.41 90 bottom
UC8  SST25VF020B-80-4C-QAE_WSON8  [W25Q80DVZPIG_WSON8]  96.08 89.24 90 bottom
UC9  -  [74AUP1G07GW_TSSOP5]  58.76 21.16 0 top
UC10  74AUP1G86GW_SOT353-1  [74AUP1G86GW_TSSOP5]  58.51 15.46 270 top
UD1  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  138.67 96.29 180 top
UD2  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  128.27 96.29 180 top
UD3  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  132.27 96.29 0 bottom
UD4  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  121.87 96.29 0 bottom
UD5  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  112.77 96.29 180 top
UD6  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  102.38 96.29 180 top
UD7  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  106.37 96.29 0 bottom
UD8  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  95.98 96.29 0 bottom
UE2  NPCT750JAAYX_QFN32_5X5  [NPCT650JAAYX_QFN32_5X5-S]  25.89 14.11 180 bottom
UE3  MEC5105_WFBGA169_11X11  [MEC5105_WFBGA_169P]  40.75 17.39 0 top
UE7  74AUP1G07SE-7 SOT353  [74AUP1G07GW_TSSOP5]  43.65 30.7 270 top
UE12  APX8131AI-TRG SOT-23  [APX8131AI-TRG_SOT23-3]  9.47 66.79 90 bottom
UE13  -  [74AUP1G07GW_TSSOP5]  32.09 7.95 0 top
UH4  SKY-H-PCH_BGA837  [SKY-S-PCH_BGA_837P-T]  47.52 35.55 270 bottom
UH5  -  [MC74VHC1G08DFT2G_SC70-5]  17.57 48.71 0 top
UH6  W25Q256FVEIQ_WSON8  [W25Q256FVEIG_WSON8]  10 57.74 90 bottom
UH7  -  [MC74VHC1G08DFT2G_SC70-5]  25.94 29.19 270 bottom
UP1  TPS61099_DSBGA6  [TPS61099YFFR_DSBGA_6P]  24.15 66.99 0 bottom
UP2  TPS61099_DSBGA6  [TPS61099YFFR_DSBGA_6P]  29.79 96.29 270 bottom
UPD1  CYPD5225-96BZXI_BGA96_6X6  [CYPD5256-96BZXI_BGA_96P]  30.68 65.53 0 bottom
UR1  RTS5242-GR_QFN32_4X4  [RTS5242-GR_QFN32_4X4-S]  24.54 63.64 180 top
US5  -  [DPS1113FIA-13_QFN18_4X4]  24.44 73.07 180 bottom
US6  -  [DPS1113FIA-13_QFN18_4X4]  27.13 99.11 180 top
UT2  AR-4C_BGA337  [AR-4C_BGA_337P-T]  32.79 86.28 90 bottom
UT3  -  [W25Q80DVZPIG_WSON8]  44.73 101.85 90 bottom
UV14  -  [MC74VHC1G09DFT2G_SC70-5]  53.31 23.72 270 top
UZ2  -  [APE8937GN2_DFN8_2X2]  95.69 28.33 270 bottom
UZ3  -  [APE8937GN2_DFN8_2X2]  21.61 30.1 180 bottom
UZ4  -  [APE8937GN2_DFN8_2X2]  55.79 103.96 0 bottom
UZ5  -  [APE8937GN2_DFN8_2X2]  79.39 21.87 90 bottom
UZ6  -  [SY6288C20AAC_SOT23-5]  64.9 89.76 90 bottom
UZ7  -  [TPS22961DNYR_WSON8]  111.8 24.19 0 top
UZ8  -  [MC74VHC1G08DFT2G_SC70-5]  35.97 25.53 90 top
UZ10  -  [MC74VHC1G08DFT2G_SC70-5]  34.01 30.51 270 top
UZ11  -  [MC74VHC1G08DFT2G_SC70-5]  38.14 30.51 270 top
UZ14  -  [TPS22961DNYR_WSON8]  79.58 26.03 90 bottom
UZ15  -  [MC74VHC1G08DFT2G_SC70-5]  47.54 23.85 270 top
UZ16  -  [MC74VHC1G08DFT2G_SC70-5]  49.44 25.21 90 top
UZ17  -  [MC74VHC1G08DFT2G_SC70-5]  43.41 26.51 270 top
UZ18  -  [APE8937GN2_DFN8_2X2]  118.58 99.16 180 top
UZ22  -  [MC74VHC1G08DFT2G_SC70-5]  61.76 22.39 270 top
UZ23  -  [APE8937GN2_DFN8_2X2]  23.51 29.28 270 top
UZ24  -  [APE8937GN2_DFN8_2X2]  156.87 23.22 180 top
XDP_SPI_IO2  PAD~D  [TPC12]  18.29 55.37 180 bottom
YC1  100MHZ_15PF_7XA0000600  [X_7XA0000600_4P]  82.61 52.2 0 bottom
YE2  32.768KHZ_9PF_X1A000141000200  [Y_X1A000141000200_2P]  39.62 21.86 0 top
YH1  32.768KHZ_X1A000141000300  [Y_CM31532768DZFT_2P]  20.67 37.9 90 bottom
YH2  24MHZ 12PF_10PPM_7M24090001  [Y_X3G024000DC1H_4P]  48.63 27.93 180 bottom
YT1  25MHZ_20PF_FL2500123Z  [Y_7M25000016_4P]  29.51 76.21 270 bottom

## Library data of the parts
BAT100 = DEREN_40-42507-01001RHF_10P-T: room: ETY-ROOM
C2-C4 C3007 C3311 C3313 C3314 CC171 CD111-CD113 CD256 CD264 CD273 CD275-CD278 CD281 CD284 CD287 CD290-CD292 CD295 CD297 CD298 CD301 CD310 CD318 CD320 CD321 CD324 CD326 CD328 CD329 CD331-CD333 CD338-CD342 CD344 CD347-CD354 CD357-CD359 CD363 CD365 CD366 CD368 CD369 CD371-CD376 CE78 CH125 CH141 CH142 CH181-CH187 CH232-CH234 CH237 CH239 CH241 CH243 CP20 CP21 CP24 CP25 CT129 CT130 CV245 CV247 CV248 PC114 PC117 PC120 PC121 PC124 PC125 PC127-PC129 PC143-PC146 PC331 PC332 PC510 PC512 PC513 PC540-PC542 PC544 PC546 PC547 PC622-PC626 PC629 PC700-PC702 PC800-PC802 PC808 PC809 PC1000 PC1001 PC1004 PC1010-PC1012 PC1110 PC1112 PC1220 PC1223 PC1224 PC1322-PC1325 PC1467-PC1470 PC1802 PC1803 PC1805-PC1809 PC1900-PC1903 PC1909 PC1921 PC1922 PC2011 PC2013 PC2014 PC2016 PC2019-PC2021 PC2229 PC2256 PC2257 PC2259 PC2260 PC2284 PC2291-PC2295 PC2300 PC2302 PC2304 PC3010 PC3011 PC3218-PC3261 PC3266 PC3269 PC3270 PC3277 PC3278 = C_0402
C93 C96 C97 C99 C101 C103 = C_0402: room: +3VS_AUDIO
C185 C186 = C_0201: room: 2ND ACCELEROMETER
C190 = C_0603: room: FP
C191 = C_0402: room: FP
C225 C3310 C3315 CC139 CC170 CD114 CD263 CD265-CD272 CD274 CD279 CD280 CD282 CD283 CD285 CD286 CD288 CD289 CD293 CD296 CD299 CD300 CD302-CD309 CD311-CD317 CD319 CD322 CD323 CD325 CD327 CD334-CD337 CD343 CD345 CD346 CD355 CD356 CD360-CD362 CD364 CD367 CD370 CD377-CD401 CE105 CH44 CH45 CH117-CH124 CH126 CH131-CH134 CH137 CH138 CH188-CH193 CH204-CH213 CH223 CH224 CH236 CH238 CH240 CH242 CP14-CP19 CV246 PC118 PC122 PC511 PC543 PC705 PC1002 PC1460-PC1466 PC2223-PC2225 PC2227 PC2252 PC2253 PC2280 PC2281 PC3012 PC3128 PC3129 PC3150-PC3159 PC3180 PC3264 PC3272 PC3274 PC3285 PC3287 PC3289 = C_0201
C375-C377 C3021 = C_0402: room: KB/TP
C1068 = C_0603: room: CCD+SENSOR
C1083 C1089-C1112 C1115 C1116 CT27-CT61 CT66-CT78 CT82-CT84 CT87-CT91 PC1457-PC1459 = C_0201: room: ETY-ROOM
C2984 CV235 CZ33 = C_0201: room: CCD+SENSOR
C3002 = C_0201: room: NB LID
C3003 C3004 = C_0201: room: EDP+TS
C3005 CV229 CV232-CV234 CV237-CV244 = C_0402: room: EDP+TS
C3022 C3023 = C_0402: room: +VPP_2.5V
C3024 = C_0201: room: +VPP_2.5V
C3312 CH127 CH128 CH130 CH135 CH136 CH139 CH140 CH194 CH195 CH198-CH203 CH214 CH215 CH228-CH231 CP22 CP23 PC119 PC123 PC330 PC514-PC519 PC548-PC550 PC620 PC621 PC627 PC628 PC703 PC704 PC803-PC807 PC816 PC817 PC1006-PC1009 PC1014 PC1111 PC1202 PC1212 PC1221 PC1222 PC1225-PC1228 PC1300 PC1321 PC1326 PC1380-PC1389 PC1391-PC1393 PC1402-PC1409 PC1430-PC1437 PC1800 PC1801 PC1804 PC1904-PC1908 PC2010 PC2012 PC2015 PC2017 PC2018 PC2222 PC2258 PC2283 PC2285 PC2286 PC2301 PC2303 PC3040-PC3059 PC3120-PC3127 PC3195-PC3217 PC3262 PC3265 PC3273 PC3276 PC3282-PC3284 = C_0603
CD58 CD60-CD63 = C_0402: room: NGFF SSD
CD59 CD64-CD70 CH75-CH82 CH84 CH86 CH88 CH89 CH92 CH95 CH97 CH100-CH108 CH116 CR6 CR7 = C_0402: room: PCH
CD330 = C_X
CE1 = C_0402: room: FAN1
CE2 = C_0402: room: FAN2
CE5 CE6 CE8-CE12 = C_0402: room: TPM
CE7 = C_0603: room: TPM
CE42 CE43 CE45 CE48-CE51 CE54-CE56 CE83 CE87 CE93-CE95 CE104 = C_0201: room: KBC
CE44 CE46 CE47 CE52 CE53 CE57-CE67 CE75 CE79 CE86 CE90 CE101 CE103 = C_0402: room: KBC
CE70 = C_0201: room: TABLET LID
CE71 = C_0402: room: TABLET LID
CH36 CH40-CH43 CH53 CH54 = C_0402: room: CPU
CH37-CH39 CH46-CH52 CH57 CH59 CH60 CH62-CH72 = C_0603: room: CPU
CH58 = C_EEFSS0D221R: room: CPU
CH90 CH91 CH93 CH94 CH96 CH98 CH99 = C_0603: room: PCH
CH114 CH115 CT94 CT95 = C_0201: room: PCH
CH220 CH221 = C_1206
CLRC CLRME RH68 RH69 = SHORTPADS: User Part Number: PART#
CP1 CP3-CP13 = C_0402: room: TBT_CCG5
CP2 = C_0603: room: TBT_CCG5
CR1-CR5 CR8-CR18 = C_0402: room: CARD READER
CT2 = C_0201: room: THUNBERBOLT
CT4-CT9 = C_0201: room: TBT
CT10 CT11 CT14 CT15 CT20 CT21 CT24 CT25 = C_0201: room: TBT_TYPEC
CT12 CT13 CT16-CT19 CT22 CT23 = C_0201: room: NONTBT_TYPEC
CT26 = C_0201: room: AR
CT62-CT65 CT85 CT86 PC1108 PC1424-PC1428 = C_0402: room: ETY-ROOM
CT79-CT81 CT92 CT93 = C_0603: room: ETY-ROOM
CT97 CT98 CT101 CT102 CT107 CT108 CT111 CT112 = C_0402: room: TBT_TYPEC
CV230 CV231 = C_0603: room: EDP+TS
CZ3-CZ6 = C_0402: room: 3V_5V_DC_DC
CZ7 CZ8 = C_0603: room: 3V_5V_DC_DC
CZ9-CZ11 = C_0402: room: PCH_DC_DC
CZ12-CZ14 = C_0402: room: CAMERA_CR_DC_DC
CZ17 CZ18 = C_0402: room: HDD_DC_DC
CZ19 = C_0402: room: EDP_DC_DC
CZ20 CZ21 CZ27-CZ32 = C_0402: room: CPU_DC_DC
CZ34 = C_0402: room: CCD+SENSOR
D18 D74 = ESD101-B1-02ELS_TSSLP-2-4-2: room: EDP+TS
D72 = ESD101-B1-02ELS_TSSLP-2-4-2: room: CCD+SENSOR
D321 DE2 DV10-DV15 DZ123 DZ124 DZ127 DZ128 RTCD1 RTCD2 = AZ5125-01HPR7G_SOD523-2
D429 MD3 = TVNST52302AB0_SOT523-3
DE1 = AZ5125-01HPR7G_SOD523-2: room: FAN1
DE3 = AZ5125-01HPR7G_SOD523-2: room: FAN2
DH1 = AZ5125-01HPR7G_SOD523-2: room: PCH
DI5 = TVNST52302AB0_SOT523-3: room: FP
DL1 = AZ5125-02SPR7G_SOT23-3: room: BATTERY LED
DT1 DT36 = AZ4520-01FPR7G_DFN1610P2E2: room: TBT_TYPEC
DT3 DT4 DT7 DT8 DT11 DT12 DT15 DT16 DT19 DT20 DT23 DT24 DT27 DT28 DT31 DT32 DT41 DT42 DT45 DT46 DT49 DT50 DT53 DT54 DT57 DT58 DT61 DT62 DT65-DT68 = ESD108-B1-CSP0201_WLL-2-1-2: room: TBT_TYPEC
DV4 = BAT54CW_SOT323-3: room: EDP_DC_DC
DV5 DV6 = BAT54CW_SOT323-3: room: EDP+TS
DV7 = TVNST52302AB0_SOT523-3: room: CCD+SENSOR
DV9 = BAT54CW_SOT323-3
DZ1 = BAT54ATB_SOT523-3: room: CPU
F1 PR510 PR614 PR620 PR800 PR903 PR1802 PR1803 PR1867 PR2200 PR2203 PR2204 PR2251 PR2308 PR2328 R207 RE272 RH206 RH642 RP94 RP110 RP111 RP118 RP119 = R_0603
FD1-FD4 = FIDUCIAL_C40M80: room: FD
H1 H3 H6 H7 H16 = H_2P3-G: room: SCREWHOLE
H4 = H_3P3-G: room: SCREWHOLE
H5 = H_3P3: room: SCREWHOLE
H9 H10 H18 H19 = H_3P9N: room: SCREWHOLE
H17 = H_6P0N: room: SCREWHOLE
H20 = H_1P3X1P8: room: SCREWHOLE
H26 = H_1P6: room: SCREWHOLE
H27 = H_1P2
H28 = H_3P5
H40-H43 = EMIST_SUL-12A2M_1P: room: SCREWHOLE
H49 H50 = H_1P0N
H51 H52 = H_2P7N
JAPS1 = ACES_50506-01841-P01_18P-NPM: room: KB+DMIC
JCAM1 = ACES_50506-02041-P01_20P: room: CCD+SENSOR
JCCG1 JSPI2 = ACES_50521-01041-P01_10P
JCR1 = T-SOL_158-1000902614_23P-T: room: CARD READER
JDEBUG1 JDGPU1 = ACES_50521-01041-P01_10P-NPM
JDEG1 = ACES_50521-01041-P01_10P: room: KBC
JEDP1 = STARC_115B40-000000-G4-R_40P: room: EDP+TS
JESPI1 = ACES_50521-01041-P01_10P-NPM: room: KBC
JFAN1 = JXT_WB247H-006G10M_6P-T
JFP1 = ACES_50521-0084N-P01_8P: room: FP
JIO1 = UNIMI_LLGCAX005_182P-T: room: ETY-ROOM
JKB1 = ACES_50696-0260M-P01_26P: room: KB+DMIC
JNGFF2 = BELLW_80159-3221_67P: room: NGFF SSD
JRTC1 = ACES_50271-0020N-001_2P: room: RTC
JTAG2 = SHORTPADS: User Part Number: PART#; room: KBC
JUSBC1 JUSBC2 = JAE_DX07B024XJ1R1300_24P: room: TBT_TYPEC
LED2-LED6 = LED_LTW-270TLA_2P: room: BATTERY LED
LED7 = LED_LTW-270TLA_2P
LED_PRI LED_RST LED_RUN = LED_HT-F196BP5_2P
LH1 LH2 = MURAT_BLM15GA750SN1D_2P: room: PCH
LP1 LP2 = CHILI_MHCD252012A-2R2M-A8S_2P
LT1 = MAG_MND-04ABIR60M-XGL_2P: room: ETY-ROOM
LT2 = CHILI_PBY160808T-300Y-N_2P: room: ETY-ROOM
LT4 LT8 LT10 = MURAT_DLM0NSN900HY2D_4P: room: TBT_TYPEC
LT11 = MURAT_DLM0NSN900HY2D_4P
LV4 = MURAT_DLM0NSN900HY2D_4P: room: CCD+SENSOR
ML1 = MURAT_DLM0NSN900HY2D_4P: room: FP
PC100 PC115 = C_0402: room: CCG5_5V_PATH_12
PC101-PC103 PC105 PC108 PC111 PC112 PC116 = C_0402: room: CCG5_PATH_12
PC104 PC106 PC107 PC142 = C_0201: room: CCG5_PATH_12
PC109 PC110 = C_0603: room: CCG5_PATH_12
PC132 PC134 PC135 = C_0201: room: BATT_CONNECTOR
PC133 = C_0402: room: BATT_CONNECTOR
PC136-PC141 = C_0402: room: CCG5_LPS_12
PC341 PC342 = C_0402: room: 3V_LDO
PC500-PC502 PC523 PC524 PC528 PC529 PC533-PC539 = C_0402: room: PWR_CHARGER
PC503-PC509 PC520-PC522 PC525-PC527 PC530-PC532 = C_0603: room: PWR_CHARGER
PC545 = C_D
PC600-PC602 PC605 PC610 PC611 = C_0402: room: PWR_3V1
PC603 PC604 PC606-PC609 = C_0603: room: PWR_3V1
PC612-PC614 PC617 = C_0402: room: PWR_5V1
PC615 PC616 PC618 PC619 = C_0603: room: PWR_5V1
PC630-PC633 = C_0603: room: PWR_5V2
PC634 PC635 = C_0402: room: PWR_5V2
PC636-PC638 PC641 PC646 PC647 = C_0402: room: PWR_3V2
PC639 PC640 PC642-PC645 = C_0603: room: PWR_3V2
PC706 PC711-PC713 = C_0402: room: +1VALWP
PC707-PC710 = C_0603: room: +1VALWP
PC810-PC815 = C_0402: room: PWR_1.2VDDR
PC900 PC902 PC905 = C_0402: room: PWM_+1.05_VMM
PC901 PC903 PC904 = C_0603: room: PWM_+1.05_VMM
PC1003 PC1005 = C_0805
PC1013 = C_0402: room: VCCIO
PC1100 PC1103-PC1107 = C_0402: room: ISL95859
PC1101 PC1102 = C_0603: room: ISL95859
PC1109 = C_0402: room: PWR_CPU_CONTROLLER
PC1200 = C_D: room: PWR_CPU_VCCCORE
PC1201 PC1209 PC1211 PC1217 = C_0603: room: PWR_CPU_VCCCORE
PC1203-PC1208 PC1210 PC1213-PC1216 PC1218 PC1219 = C_0402: room: PWR_CPU_VCCCORE
PC1301 PC1302 PC1308 PC1310-PC1312 PC1317 = C_0603: room: PWR_CPU_VCCGT
PC1303-PC1307 PC1309 PC1313-PC1316 = C_0402: room: PWR_CPU_VCCGT
PC1318 = C_0402: room: PWR_CPU_VCCSA
PC1319 PC1320 = C_0603: room: PWR_CPU_VCCSA
PC1379 PC1410-PC1413 PC2215-PC2219 PC2230 PC2232 PC2237 PC2238 PC2243 PC2249 PC2262 PC2267 = C_0603: room: CPU_OUTPUT_MLCC
PC1400 = C_D2
PC1401 PC1499 PC3288 = C_EEFSS0D221R
PC1414-PC1423 PC2263 PC2264 PC2273 PC2275 PC2276 = C_0402: room: CPU_OUTPUT_MLCC
PC1442-PC1451 PC2231 PC2235 PC2236 PC2241 PC2266 PC2272 = C_0201: room: CPU_OUTPUT_MLCC
PC1500 = C_0402: room: PWR_1.8VALW
PC1501 = C_0603: room: PWR_1.8VALW
PC1502 PC1505 = C_0402: room: PWR_1.8VU
PC1503 PC1504 = C_0603: room: PWR_1.8VU
PC1810-PC1812 PC1815-PC1829 = C_0402: room: PWM_GPU_CONTROLLER
PC1813 PC1814 = C_0603: room: PWM_GPU_CONTROLLER
PC1910-PC1913 PC1919 PC2000-PC2003 PC2009 = C_0402: room: PWM_VDDC
PC1914-PC1918 PC2004-PC2008 = C_0603: room: PWM_VDDC
PC1920 = C_D: room: PWM_VDDC
PC2200-PC2203 PC2207 = C_0402: room: PWM_VDD12
PC2204-PC2206 PC2208 = C_0603: room: PWM_VDD12
PC2268 PC2270 = C_B2: room: CPU_OUTPUT_MLCC
PC3000-PC3009 = C_0402: room: PWM_GPU VR MLCC
PC3033 PC3090 PC3091 PC3193 PC3194 = C_B2: room: PWM_GPU VR MLCC
PC3034 PC3094-PC3097 PC3192 = C_EEFSS0D221R: room: PWM_GPU VR MLCC
PC3035-PC3039 PC3060-PC3062 = C_0603: room: PWM_GPU VR MLCC
PC3088 PC3089 = C_B2
PC3130-PC3149 PC3160-PC3179 = C_0201: room: PWM_GPU VR MLCC
PD102 PD103 = RB520SM-30T2R_EMD2-2: room: CCG5_LPS_12
PD104 PD105 = TVNST52302AB0_SOT523-3: room: BATT_CONNECTOR
PD106-PD109 = BAT54CW_SOT323-3: room: CCG5_LPS_12
PD304-PD308 PD500 PD501 PD506 PD508 PD509 PD800 PD1000 PD2300 = RB520SM-30T2R_EMD2-2
PD505 = BAT54CW_SOT323-3: room: PWR_CHARGER
PD510 = SMF22A-SOD123FL-2-S
PH1800 PH1801 PR112 PR118 PR140 PR144 PR172 PR264 PR266 PR363 PR384 PR515 PR517 PR518 PR540 PR552 PR554 PR555 PR610 PR613 PR616 PR628 PR802-PR804 PR806 PR809 PR813 PR900 PR901 PR904-PR907 PR1010 PR1012 PR1013 PR1111 PR1112 PR1115-PR1119 PR1121 PR1123 PR1143 PR1144 PR1146 PR1148 PR1151 PR1152 PR1154 PR1800 PR1801 PR1806-PR1808 PR1830-PR1839 PR1860-PR1866 PR1868 PR1869 PR1880 PR2301 PR2302 PR2304 PR2306 PR2307 PR2311-PR2313 PR2317 PR2319 PR2330 PR2335 PR2336 PR2338 PR2339 R3 R276 R2741 R5830 R5836 R5840 R5846 R5858 R5860 RC14 RC20 RC26 RC32 RC101 RC387 RC394 RC397 RD60 RD157-RD164 RD194-RD197 RD226-RD237 RE196 RE271 RE292 RE428 RH66 RH67 RH480-RH485 RH541 RH542 RH544 RH547 RH548 RH559 RH560 RH571 RH573-RH575 RH581-RH584 RH586 RH603 RH605 RH606 RH621-RH624 RH634 RP33 RP137-RP140 RR41 RT240 RT241 RT428 RTCR1 RTCR2 RW1 RZ60 RZ61 = R_0402
PJP501 PJP502 PJP801 PJP1001 = JUMP_43X39
PJP600 = JUMP_43X118: room: PWR_3V1
PJP601 = JUMP_43X118: room: PWR_5V1
PJP602 = JUMP_43X118: room: PWR_5V2
PJP603 = JUMP_43X118: room: PWR_3V2
PJP700 PJP1000 PJP1702 = JUMP_43X118
PJP800 = JUMP_43X118: room: PWR_1.2VDDR
PJP900 = JUMP_43X39: room: PWM_+1.05_VMM
PJP1402 = JUMP_43X39: room: KBC
PJP1500 PJP1701 = JUMP_43X79
PL100-PL103 = TAI-T_HCB2012KF-121T50_2P: room: CCG5_PATH_12
PL104-PL106 = TAI-T_HCB2012KF-121T50_2P: room: BATT_CONNECTOR
PL500 = MAG_MMD-05CZ-1R5M-X2L_2P
PL501 = MAG_MMD-10CZN1R0M-R1L_2P
PL502 = TAI-T_HCB1608KF-121T3_L0603_2P
PL600 = TAI-T_HCB2012KF-121T50_2P: room: PWR_3V1
PL601 = MAGLA_MMD-05CZ-1R0M-M7L_2P: room: PWR_3V1
PL602 PL609 = TAI-T_HCB2012KF-121T50_2P: room: PWR_5V1
PL603 = MAG_MLD-06CZH1R0M-N1L_2P: room: ETY-ROOM
PL604 PL608 = TAI-T_HCB2012KF-121T50_2P: room: PWR_5V2
PL605 = MAG_MLD-06CZH1R0M-N1L_2P: room: PWR_5V2
PL606 = TAI-T_HCB2012KF-121T50_2P: room: PWR_3V2
PL607 = MAGLA_MMD-05CZ-1R0M-M7L_2P: room: PWR_3V2
PL700 = TAI-T_HCB2012KF-121T50_2P: room: +1VALWP
PL701 = MAG_MLD-06CZH1R0M-N1L_2P: room: +1VALWP
PL800 = MAGLA_MMD-05CZ-1R0M-M7L_2P: room: PWR_1.2VDDR
PL801 = TAI-T_HCB2012KF-121T50_2P: room: PWR_1.2VDDR
PL900 PL1500 PL1900 PL1901 PL2204 PL2205 = TAI-T_HCB2012KF-121T50_2P
PL901 PL1501 PL2203 = CHILI_HEI322512A-1R0M-Q8_2P
PL1000 = MURAT_BLM15PX121SN1D_2P
PL1001 = MAGLA_MMD-05CZ-1R0M-M7L_2P
PL1200 PL1203 PL1204 = L_7X7X3_M: room: PWR_CPU_VCCCORE
PL1201 PL1202 = TAI-T_HCB2012KF-121T50_2P: room: PWR_CPU_VCCCORE
PL1300 PL1302 = TAI-T_HCB2012KF-121T50_2P: room: PWR_CPU_VCCGT
PL1301 PL1303 = L_7X7X3_M: room: PWR_CPU_VCCGT
PL1304 = TAI-T_HCB2012KF-121T50_2P: room: PWR_CPU_VCCSA
PL1305 = MAG_MMD-05CZ-R33M-V1L_2P: room: PWR_CPU_VCCSA
PL1902 PL1904 = L_7X7X4_M
PL2001 PL2202 = L_7X7X4_M: room: PWM_VDDC
PL2200 = TAI-T_HCB2012KF-121T50_2P: room: PWM_VDD12
PL2201 = MAG_MMD05CZR47M_4P: room: PWM_VDD12
PL2207 = MAG_MMD-05AB-1R0M-V1L_2P
PQ100 = AON7405_DFN8-5: room: CCG5_5V_PATH_12
PQ101 = SI1303DL-T1-E3_SOT323-3: room: CCG5_5V_PATH_12
PQ102 = AON7405_DFN8-5: room: CCG5_PATH_12
PQ103 PQ111 PQ113 PQ114 PQ500 = AON7405_DFN8-5
PQ105 PQ106 PQ112 PQ325 PQ328 = SI1303DL-T1-E3_SOT323-3
PQ116 PQ117 = SI1303DL-T1-E3_SOT323-3: room: CCG5_PATH_12
PQ132 PQ133 = L2N7002WT1G_SC70-3: room: CCG5_LPS_12
PQ134 = L2N7002WT1G_SC70-3: room: CCG5_PATH_12
PQ136 PQ139 PQ146 PQ147 PQ216 PQ217 = 2N7002KDW_SOT363-6
PQ137 PQ143 PQ144 PQ199 PQ213 PQ322 PQ501 = L2N7002WT1G_SC70-3
PQ149 PQ150 PQ152 PQ153 = 2N7002KDW_SOT363-6: room: AC_DISCONNECT
PQ154 PQ155 = 2N7002KDW_SOT363-6: room: CCG5_PATH_12
PQ200-PQ205 = RJU003N03_UMT3: room: CCG5_LPS_12
PQ330 = 2N7002KDW_SOT363-6: room: 3V_LDO
PQ502 PQ503 PQ506 = AON6232A_DFN5X6-8-5
PQ504 PQ505 = AON6380_DFN5X6-8-5
PQ2200 = AON6962_DFN5X6D-8-7
PR100-PR102 PR104 PR127-PR129 PR131 = R_0201: room: CCG5_5V_PATH_12
PR105-PR107 PR121 PR126 PR132 PR133 PR135 PR155 PR246 PR248 = R_0201: room: CCG5_PATH_12
PR108 PR109 PR123 PR137 PR138 PR151 = R_0402: room: CCG5_PATH_12
PR110 PR119 PR143 PR174 PR258 PR275 PR276 PR389 PR392 PR513 PR514 PR516 PR542-PR546 PR548 PR549 PR553 PR611 PR617 PR619 PR708 PR805 PR814 PR1002 PR1011 PR1120 PR1122 PR1145 PR1147 PR1149 PR1150 PR1153 PR1300 PR1302 PR1304 PR1506 PR1507 PR2250 PR2303 PR2305 PR2337 PR2340 R5823 R5824 R5838 R5839 R5851 RC33 RH540 RH549 RH589 RH604 RH648 RP141 RP142 = R0402_0OHM
