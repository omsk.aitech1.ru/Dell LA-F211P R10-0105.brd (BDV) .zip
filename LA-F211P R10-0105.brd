# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCGT: length 108.9
  GND2 w0.254: v7(126.16,66) v5(125.78,66) ; v7(124.24,75.01) v5(123.86,75.01) ; v7(121.84,75.52) v5(122.22,75.52) ; v7(124.24,73.74) v5(123.86,73.74) ; v7(122.06,77.04) v5(122.06,76.66) ; v7(127.23,67.32) v5(127.23,66.99) ; v7(127.23,61.88) v5(126.91,62.17) ; v7(126.02,68.15) v5(125.64,68.15) ; v7(124.6,77.04) v5(124.6,76.66) ; v7(127.23,72.78) v5(127.23,72.45) ; v7(126.56,65) v5(126.91,64.82) ; v7(127.73,61.8) 127.73,62.14 v5(127.7,62.17) 127.71,62.18 v7(127.71,62.54) ; v7(125.38,69.42) v5(125,69.42) ; v7(126.08,72.78) v5(126.08,72.45) ; v7(126.16,67.01) v5(125.78,67.01) ; v7(127.23,71.79) v5(127.23,71.41) ; v7(126.65,75.01) v5(126.27,75.01) ; v7(128.11,64.94) v5(128.49,64.82) ; v7(126.41,63.71) v5(126.13,63.47) ; v7(122.74,77.04) v5(122.74,76.66) ; v7(124.99,76.28) v5(124.99,75.9) ; v7(121.84,74.5) v5(122.22,74.5) ; v7(127.23,70.01) v5(127.23,69.63) ; v7(125.41,77.04) v5(125.41,76.66)
  GND3 w0.254: v5(122.22,75.52) v15(122.6,75.52) ; v5(127.23,71.41) v15(127.23,71.02) ; v5(126.27,75.01) v15(125.89,75.01) ; v5(126.08,72.45) v8(126.08,72.12) ; v5(125.41,76.66) v15(125.41,76.28) ; v5(127.23,69.63) v15(127.23,69.25) ; v5(123.86,73.74) v15(123.48,73.74) ; v5(127.23,72.45) v8(127.23,72.12) ; v5(122.22,74.5) v15(122.6,74.5) ; v5(125,69.42) v15(124.62,69.42) ; v5(122.06,76.66) v15(122.06,76.28) ; v5(124.99,75.9) v15(124.99,75.52) ; v5(127.23,66.99) v8(127.23,66.66) ; v5(122.74,76.66) v15(122.74,76.28) ; v5(123.86,75.01) v15(123.48,75.01) ; v5(124.6,76.66) v15(124.6,76.28)
  GND3 w0.381: v6(133.23,50.74) v5(133.23,51.33)
  IN3 w0.254: v14(127.85,67.37) v8(127.84,67.63) ; v14(130.45,61.07) v8(130.44,61.33) ; v14(132.4,61.07) v8(132.41,61.33) ; v14(127.85,66.58) v8(127.84,66.84) ; v14(131.75,65.01) v8(131.75,65.26) ; v14(130.45,63.44) v8(130.44,63.69) ; v14(128.23,61.2) v8(128.49,61.2) ; v14(127.45,59.89) v8(127.7,59.9) ; v14(128.23,64.5) v8(128.49,64.49) ; v14(131.75,69.73) v8(131.75,69.99) ; v14(131.1,67.37) v8(131.11,67.63) ; v14(130.45,65.01) v8(130.44,65.26) ; v14(127.45,63.8) v8(127.7,63.8) ; v14(127.85,68.95) v8(127.84,69.2) ; v14(125.87,65.15) v8(126.13,65.15) ; v14(132.4,69.73) v8(132.41,69.99) ; v14(131.1,65.8) v8(131.11,66.05) ; v14(132.4,65.8) v8(132.41,66.05) ; v14(131.1,62.65) v8(131.11,62.9) ; v14(128.23,59.24) v8(128.49,59.24) ; v14(131.75,63.44) v8(131.75,63.69) ; v14(130.45,68.95) v8(130.44,69.2) ; v14(130.45,66.58) v8(130.44,66.84) ; v14(128.23,63.8) v8(128.49,63.8) ; v14(129.15,64.22) v8(129.14,64.48) ; v14(131.1,68.16) v8(131.11,68.41) ; v14(127.45,61.85) v8(127.7,61.84) ; v14(125.87,63.8) v8(126.13,63.8) ; v14(127.45,59.24) v8(127.7,59.24) ; v14(128.5,68.95) v8(128.5,69.2) ; v14(129.02,58.59) v8(129.28,58.6) ; v14(130.45,67.37) v8(130.44,67.63) ; v14(130.45,65.8) v8(130.44,66.05) ; v14(131.75,59.5) v8(131.75,59.75) ; v14(125.87,64.5) v8(126.13,64.49) ; v14(131.1,61.07) v8(131.11,61.33) ; v14(129.15,68.16) v8(129.14,68.41) ; v14(129.15,62.65) v8(129.14,62.9) ; v14(129.15,65.01) v8(129.14,65.26) ; v14(132.4,65.01) v8(132.41,65.26) ; v14(132.4,62.65) v8(132.41,62.9) ; v14(126.66,61.2) v8(126.91,61.2) ; 132.4,60.29 v8(132.41,60.54) ; v14(129.8,65.01) v8(129.8,65.26) ; v14(128.23,59.89) v8(128.49,59.9) ; v14(129.8,66.58) v8(129.8,66.84) ; v14(129.02,60.55) v8(129.28,60.54) ; v14(129.15,66.58) v8(129.14,66.84) ; v14(127.85,65.8) v8(127.84,66.05) ; v14(125.87,63.15) v8(126.13,63.14) ; v14(128.5,66.58) v8(128.5,66.84) ; v14(130.45,64.22) v8(130.44,64.48) ; v14(130.45,69.73) v8(130.44,69.99) ; v14(127.85,69.73) v8(127.84,69.99) ; v14(128.5,65.8) v8(128.5,66.05) ; v14(131.1,63.44) v8(131.11,63.69) ; v14(131.1,65.01) v8(131.11,65.26) ; v14(128.23,60.55) v8(128.49,60.54) ; v14(131.75,65.8) v8(131.75,66.05) ; v14(131.1,66.58) v8(131.11,66.84) ; v14(127.45,58.59) v8(127.7,58.6) ; v14(126.66,61.85) v8(126.91,61.84) ; v14(126.66,60.55) v8(126.91,60.54) ; v14(129.8,64.22) v8(129.8,64.48) ; v14(127.85,68.16) v8(127.84,68.41) ; v14(131.1,61.86) v8(131.11,62.11) ; v14(128.5,69.73) v8(128.5,69.99) ; v14(126.66,63.15) v8(126.91,63.14) ; v14(127.45,60.55) v8(127.7,60.54) ; v14(128.23,63.15) v8(128.49,63.14) ; v14(129.8,68.95) v8(129.8,69.2) ; v14(129.8,62.65) v8(129.8,62.9) ; v14(131.1,69.73) v8(131.11,69.99) ; v14(128.23,57.94) v8(128.49,57.94) ; v14(127.45,62.5) v8(127.7,62.5) ; v14(132.4,63.44) v8(132.41,63.69) ; v14(127.45,57.94) v8(127.7,57.94) ; v14(131.75,61.07) v8(131.75,61.33) ; v14(131.1,68.95) v8(131.11,69.2) ; v14(131.75,67.37) v8(131.75,67.63) ; v14(126.66,64.5) v8(126.91,64.49) ; v14(127.45,63.15) v8(127.7,63.14) ; v14(129.02,61.2) v8(129.28,61.2) ; v14(128.23,58.59) v8(128.49,58.6) ; v14(130.45,61.86) v8(130.44,62.11) ; v14(127.45,61.2) v8(127.7,61.2) ; v14(131.75,62.65) v8(131.75,62.9) ; v14(126.66,62.5) v8(126.91,62.5) ; v14(132.4,68.16) v8(132.41,68.41) ; v14(130.45,62.65) v8(130.44,62.9) ; v14(132.4,67.37) v8(132.41,67.63) ; v14(130.45,68.16) v8(130.44,68.41) ; v14(128.23,57.29) v8(128.49,57.3) ; v14(131.1,64.22) v8(131.11,64.48) ; v14(128.23,65.15) v8(128.49,65.15) ; v14(128.5,67.37) v8(128.5,67.63) ; v14(131.75,60.29) v8(131.75,60.54) ; 132.4,59.5 v8(132.41,59.75) ; v14(126.66,65.15) v8(126.91,65.15) ; v14(129.15,68.95) v8(129.14,69.2) ; v14(126.66,63.8) v8(126.91,63.8) ; v14(129.02,57.94) v8(129.28,57.94) ; v14(128.5,68.16) v8(128.5,68.41) ; v14(129.8,68.16) v8(129.8,68.41) ; v14(131.75,68.16) v8(131.75,68.41)
  BOTTOM w0.127: 127.57,66.07 127.85,65.8 v14(127.85,65.8) ; UC1.CV14 125.52,77.96 125.24,78.24 ; UC1.CV14 125.23,77.67 ; UC1.CV14 125.83,78.27 ; UC1.CV14 125.78,77.7 ; UC1.DA22 127.85,72.88 127.57,73.16 ; UC1.DA22 128.12,73.15 ; UC1.DA22 127.56,72.59 ; UC1.DA22 128.11,72.62 ; v14(128.23,64.5) 128.5,64.24 ; v14(128.23,64.5) 128.5,64.77 ; v14(128.23,64.5) 128.23,64.5 127.96,64.77 ; v14(128.23,64.5) 127.94,64.2 ; v14(126.66,65.15) 126.92,64.89 ; v14(126.66,65.15) 126.37,64.85 ; v14(126.66,65.15) 126.93,65.42 ; v14(126.66,65.15) 126.66,65.15 126.38,65.42 ; 127.57,72.37 127.85,72.1 UC1.DA23 ; UC1.CN14 123.04,77.7 ; UC1.CN14 122.78,77.97 122.51,78.24 ; UC1.CN14 122.49,77.67 ; UC1.CN14 123.09,78.27 ; v14(126.66,64.5) 126.93,64.77 ; v14(126.66,64.5) 126.37,64.2 ; v14(126.66,64.5) 126.92,64.24 ; v14(126.66,64.5) 126.66,64.5 126.38,64.77 ; v14(129.15,64.22) 129.41,63.96 ; v14(129.15,64.22) 129.15,64.22 128.87,64.5 ; v14(129.15,64.22) 129.42,64.49 ; v14(129.15,64.22) 128.86,63.93 ; UC1.CM13 121.87,78.61 121.64,78.38 ; UC1.CM13 121.86,78.61 121.59,78.89 ; UC1.CM13 122.13,78.35 ; UC1.CM13 122.18,78.92 ; 122.5,78.89 UC1.CN13 ; UC1.CN13 123.11,78.28 ; UC1.CN13 123.09,78.92 ; UC1.CN13 122.78,78.61 122.54,78.36 ; 127.56,67.87 v14(127.85,68.16) ; v14(127.85,68.16) 127.85,68.16 127.57,68.44 ; v14(127.85,68.16) 128.11,67.9 ; v14(127.85,68.16) 128.12,68.43 ; UC1.DA23 128.12,72.37 ; UC1.DA23 127.56,71.8 ; UC1.DA23 128.11,71.83 ; 128.86,67.87 v14(129.15,68.16) ; v14(129.15,68.16) 129.15,68.16 128.87,68.44 ; v14(129.15,68.16) 129.42,68.43 ; v14(129.15,68.16) 129.41,67.9 ; v14(128.5,67.37) 128.77,67.64 ; v14(128.5,67.37) 128.21,67.08 ; v14(128.5,67.37) 128.76,67.11 ; v14(128.5,67.37) 128.5,67.37 128.22,67.65 ; v14(128.5,68.16) 128.5,68.16 128.22,68.44 ; v14(128.5,68.16) 128.21,67.87 ; v14(128.5,68.16) 128.77,68.43 ; v14(128.5,68.16) 128.76,67.9 ; 128.87,66.86 129.15,66.58 v14(129.15,66.58) ; 127.94,63.5 v14(128.23,63.8) ; v14(128.23,63.8) 128.5,63.53 ; v14(128.23,63.8) 128.5,64.07 ; v14(128.23,63.8) 128.23,63.8 127.96,64.07 ; 128.22,66.86 128.5,66.58 v14(128.5,66.58) ; v14(126.66,63.8) 126.93,64.07 ; v14(126.66,63.8) 126.92,63.53 ; v14(126.66,63.8) 126.37,63.5 ; v14(126.66,63.8) 126.66,63.8 126.38,64.07 ; UC1.CV13 125.52,78.61 125.24,78.89 ; UC1.CV13 125.78,78.35 ; UC1.CV13 125.83,78.92 ; UC1.CV13 125.23,78.32 ; 124.92,78.27 UC1.CT14 ; UC1.CT14 124.61,77.96 124.33,78.24 ; UC1.CT14 124.31,77.67 ; UC1.CT14 124.87,77.7 ; 127.57,69.22 127.85,68.95 v14(127.85,68.95) ; 127.56,67.08 v14(127.85,67.37) ; v14(127.85,67.37) 128.11,67.11 ; v14(127.85,67.37) 127.85,67.37 127.57,67.65 ; v14(127.85,67.37) 128.12,67.64 ; 126.13,64.24 v14(125.87,64.5) 126.14,64.77 ; UC1.DA24 128.12,71.58 ; UC1.DA24 128.11,71.05 ; UC1.DA24 127.56,71.02 ; UC1.DA24 127.85,71.31 127.57,71.59 ; 121.59,78.24 121.86,77.96 UC1.CM14 ; UC1.DA17 128.12,76.3 ; UC1.DA17 127.85,76.03 127.57,76.31 ; UC1.DA17 127.56,75.74 ; UC1.DA17 128.11,75.77 ; 128.21,66.29 v14(128.5,66.58) ; v14(128.5,66.58) 128.76,66.32 ; v14(128.5,66.58) 128.77,66.85 ; v14(127.45,63.8) 127.44,63.8 127.17,64.07 ; v14(127.45,63.8) 127.71,63.53 ; v14(127.45,63.8) 127.72,64.07 ; v14(127.45,63.8) 127.15,63.5 ; 127.57,70.8 127.85,70.52 UC1.DA25 ; v14(129.15,68.95) 129.42,69.22 ; v14(129.15,68.95) 129.41,68.68 ; v14(129.15,68.95) 128.86,68.65 ; v14(129.15,68.95) 129.15,68.95 128.87,69.22 ; v14(128.5,68.95) 128.77,69.22 ; v14(128.5,68.95) 128.76,68.68 ; v14(128.5,68.95) 128.5,68.95 128.22,69.22 ; v14(128.5,68.95) 128.21,68.65 ; UC1.DA18 127.85,75.25 127.57,75.52 ; UC1.DA18 128.12,75.52 ; UC1.DA18 128.11,74.98 ; UC1.DA18 127.56,74.95 ; v14(128.5,65.8) 128.5,65.8 128.22,66.07 ; v14(128.5,65.8) 128.76,65.54 ; v14(128.5,65.8) 128.21,65.5 ; v14(128.5,65.8) 128.77,66.07 ; UC1.DA20 128.12,73.94 ; UC1.DA20 127.56,73.38 ; UC1.DA20 128.11,73.41 ; UC1.DA20 127.85,73.67 127.57,73.95 ; 127.56,65.5 v14(127.85,65.8) ; v14(127.85,65.8) 128.11,65.54 ; v14(127.85,65.8) 128.12,66.07 ; 124.33,78.89 124.61,78.61 UC1.CT13 ; UC1.DA19 127.85,74.46 127.57,74.74 ; UC1.DA19 127.56,74.17 ; UC1.DA19 128.12,74.73 ; UC1.DA19 128.11,74.2 ; 128.21,69.44 v14(128.5,69.73) ; v14(128.5,69.73) 128.76,69.47 ; v14(128.5,69.73) 128.5,69.73 128.22,70.01 ; v14(128.23,65.15) 128.5,65.42 ; v14(128.23,65.15) 128.23,65.15 127.96,65.42 ; v14(128.23,65.15) 127.94,64.85 ; v14(128.23,65.15) 128.5,64.89 ; UC1.CT13 124.31,78.32 ; UC1.CT13 124.92,78.92 ; UC1.CT13 124.87,78.35 ; 127.56,76.53 UC1.DA16 ; UC1.DA16 127.85,76.82 127.57,77.1 ; UC1.DA16 128.12,77.09 ; UC1.DA16 128.11,76.56 ; v14(127.85,66.58) 128.11,66.32 ; v14(127.85,66.58) 127.85,66.58 127.57,66.86 ; v14(127.85,66.58) 127.56,66.29 ; v14(127.85,66.58) 128.12,66.85 ; v14(129.15,66.58) 129.42,66.85 ; v14(129.15,66.58) 129.41,66.32 ; v14(129.15,66.58) 128.86,66.29 ; 127.57,70.01 127.85,69.73 v14(127.85,69.73) ; UC1.CM14 122.13,77.7 ; UC1.CM14 122.18,78.27 ; UC1.CM14 121.57,77.67 ; v14(127.85,69.73) 127.56,69.44 ; v14(127.85,69.73) 128.12,70 ; v14(127.85,69.73) 128.11,69.47 ; 128.86,64.72 v14(129.15,65.01) ; v14(129.15,65.01) 129.41,64.75 ; v14(129.15,65.01) 129.15,65.01 128.87,65.29 ; v14(129.15,65.01) 129.42,65.28 ; UC1.DA25 128.11,70.26 ; UC1.DA25 128.12,70.79 ; UC1.DA25 127.56,70.23 ; 126.13,64.89 v14(125.87,65.15) 126.14,65.42 ; 126.14,64.07 v14(125.87,63.8) 126.13,63.53 ; v14(127.85,68.95) 127.56,68.65 ; v14(127.85,68.95) 128.11,68.68 ; v14(127.85,68.95) 128.12,69.22
  vias: v5(126.13,64.82) v5(126.91,63.47) v5(126.91,60.87) v5(127.7,63.47) v5(127.7,60.87) v5(127.7,59.57) v5(127.7,58.27) v5(128.17,69.99) v5(128.17,69.2) v5(128.17,68.41) v5(128.17,67.63) v5(128.17,66.84) v5(128.17,66.05) v5(128.49,63.47) v5(128.49,60.87) v5(128.49,59.57) v5(128.49,58.27) v5(128.49,56.97) v5(129.28,60.87) v5(129.28,58.27) v5(129.47,69.2) v5(129.47,68.41) v5(129.47,66.84) v5(129.47,65.26) v5(129.47,64.48) v5(129.47,62.9) v5(130.77,69.99) v5(130.77,69.2) v5(130.77,68.41) v5(130.77,67.63) v5(130.77,66.84) v5(130.77,66.05) v5(130.77,65.26) v5(130.77,64.48) v5(130.77,63.69) v5(130.77,62.9) v5(130.77,62.11) v5(130.77,61.33) v5(132.08,69.99) v5(132.08,68.41) v5(132.08,67.63) v5(132.08,66.05) v5(132.08,65.26) v5(132.08,63.69) v5(132.08,62.9) v5(132.08,61.33) v5(132.08,60.54) v5(132.08,59.75) v6(131.08,56.64) v7(128.49,56.64) v8(128.49,56.64) v9(122.32,78.3) v9(122.32,77.67) v9(123.24,78.3) v9(123.24,77.67) v9(124.15,78.3) v9(124.15,77.67) v9(125.07,78.3) v9(125.07,77.67) v9(133.33,68.34) v9(133.33,67.51) v9(133.33,66.67) v9(133.33,65.83) v9(133.33,64.99) v9(133.33,64.15) v9(133.33,63.32) v9(133.33,62.48) v9(133.33,61.64) v9(133.33,60.8) v9(133.33,59.96) v9(133.33,59.12) v9(133.33,58.29) v9(133.33,57.45) v9(133.33,56.61) v9(133.33,55.77) v9(133.33,54.93) v9(134.16,68.34) v9(134.16,67.51) v9(134.16,66.67) v9(134.16,65.83) v9(134.16,64.99) v9(134.16,64.15) v9(134.16,63.32) v9(134.16,62.48) v9(134.16,61.64) v9(134.16,60.8) v9(134.16,59.96) v9(134.16,59.12) v9(134.16,58.29) v9(134.16,57.45) v9(134.16,56.61) v9(134.16,55.77) v9(134.16,54.93) v9(135.9,68.34) v9(135.92,67.51) v9(135.92,66.67) v9(135.92,65.83) v9(135.92,64.99) v9(135.92,64.15) v9(135.92,63.32) v9(135.92,62.48) v9(135.92,61.64) v9(135.92,60.8) v9(135.92,59.96) v9(135.92,59.12) v9(135.92,58.29) v9(135.92,57.45) v9(135.92,56.61) v9(135.92,55.77) v9(135.92,54.93) v9(136.62,68.34) v9(136.62,67.52) v9(136.66,66.66) v9(136.66,65.82) v9(136.66,64.98) v9(136.66,64.14) v9(136.65,63.3) v9(136.65,62.46) v9(136.66,61.64) v9(136.66,60.8) v9(136.66,59.96) v9(136.66,59.12) v9(136.65,58.29) v9(136.65,57.45) v9(137.39,68.34) v9(137.39,67.52) v9(137.4,61.64) v9(137.4,60.8) v9(137.4,59.96) v9(137.4,59.12) v9(137.41,58.29) v9(137.41,57.45) v9(140.17,70.92) v9(140.17,70.24) v9(140.17,69.47) v9(140.17,68.71) v9(140.74,70.92) v9(140.74,70.24) v9(140.74,69.47) v9(140.74,68.71) v16(124.3,71.71)
+VCCIO: length 200.7
  TOP w0.254: v2(85.59,29.06) 84.45,27.92 84.45,16.15 v16(83.75,15.45) v2(83.75,14.95) ; QE13.1 33.06,18.84 31.68,20.22 31.68,22.1 33.8,24.21 v2(34.25,24.21)
  TOP w0.508: v2(82.57,78.64) 83.35,79.42 87.36,79.42 87.73,79.79 RH35.1 88.17,81.03 88.68,80.52 88.68,78.59 89.19,78.08 104.67,78.08 106.05,76.69 111.63,76.69 CH38.1
  IN1 w0.254: v9(104.61,41.84) 104.06,41.28 101.34,41.28 101.04,40.98 101.04,38.21 101.44,37.8 101.44,34.35 100.63,33.54 100.63,33.15 99.86,32.38 95.23,32.38 92.82,29.97 86.5,29.97 v2(85.59,29.06) ; v2(83.75,14.95) 79.31,14.95 78.5,15.75 74.28,15.75 71.01,19.02 68.79,19.02 63.84,23.97 55.17,23.97 53.98,25.16 52.74,25.16 52.18,25.72 44.84,25.72 43.59,26.97 40.79,26.97 39.56,25.74 37.74,25.74 36.21,24.21 v2(34.25,24.21)
  IN1 w0.508: v2(82.57,78.64) 82.27,78.64 81.44,77.82 81.44,72.85 82.46,71.84 84.05,71.84 84.55,71.33 84.55,68.6 83.89,67.94 83.89,64.76 83.27,64.14 82.78,64.14 v7(82.29,63.66)
  GND2 w0.254: v7(111.32,62.54) v5(111.17,62.17) ; v5(111.17,63.47) v7(111.55,63.3)
  IN3 w0.254: v14(110.12,57.94) v8(110.38,57.94) ; v14(110.91,63.8) v8(111.17,63.8) ; v14(112.49,63.8) v8(112.74,63.8) ; v14(108.55,58.59) v8(108.8,58.6) ; v14(111.7,58.59) v8(111.95,58.6) ; v14(112.49,58.59) v8(112.74,58.6) ; v14(113.27,58.59) v8(113.53,58.6) ; v14(112.49,57.29) v8(112.74,57.3) ; v14(110.12,64.5) v8(110.38,64.49) ; v14(109.34,56.64) v8(109.59,56.64) ; v14(112.49,61.85) v8(112.74,61.84) ; v14(111.7,65.15) v8(111.95,65.15) ; v14(108.11,60.7) v8(108.36,60.69) ; v14(109.34,59.24) v8(109.59,59.24) ; v14(112.49,63.15) v8(112.74,63.14) ; v14(113.27,60.55) v8(113.53,60.54) ; v14(110.91,58.59) v8(111.17,58.6) ; v14(111.7,59.24) v8(111.95,59.24) ; v14(111.7,63.8) v8(111.95,63.8) ; v14(110.91,59.24) v8(111.17,59.24) ; v14(113.27,59.89) v8(113.53,59.9) ; v14(112.49,64.5) v8(112.74,64.49) ; v14(111.7,64.5) v8(111.95,64.49) ; v14(111.7,63.15) v8(111.95,63.14) ; v14(113.27,61.2) v8(113.53,61.2) ; v14(110.12,57.29) v8(110.38,57.3) ; v14(110.91,60.55) v8(111.17,60.54) ; v14(111.7,60.55) v8(111.95,60.54) ; v14(110.12,56.64) v8(110.38,56.64) ; v14(110.12,61.85) v8(110.38,61.84) ; v14(110.91,57.94) v8(111.17,57.94) ; v14(110.91,62.5) v8(111.17,62.5) ; v14(109.04,61.35) v8(109.29,61.35) ; v14(110.12,63.8) v8(110.38,63.8) ; v14(111.7,57.94) v8(111.95,57.94) ; v14(113.27,59.24) v8(113.53,59.24) ; v14(110.91,61.2) v8(111.17,61.2) ; v14(110.12,61.2) v8(110.38,61.2) ; v14(112.49,62.5) v8(112.74,62.5) ; v14(110.12,62.5) v8(110.38,62.5) ; v14(110.91,61.85) v8(111.17,61.84) ; v14(110.91,63.15) v8(111.17,63.14) ; v14(111.7,61.2) v8(111.95,61.2) ; v14(111.7,59.89) v8(111.95,59.9) ; v14(108.55,59.89) v8(108.8,59.9) ; v14(112.49,65.15) v8(112.74,65.15) ; v14(110.91,59.89) v8(111.17,59.9) ; v14(110.12,65.15) v8(110.38,65.15) ; v14(109.04,60.7) v8(109.29,60.69) ; v14(108.11,61.35) v8(108.36,61.35) ; v14(112.49,56.64) v8(112.74,56.64) ; v14(109.34,59.89) v8(109.59,59.9) ; v14(110.12,63.15) v8(110.38,63.14) ; v14(108.55,59.24) v8(108.8,59.24) ; v14(112.49,61.2) v8(112.74,61.2) ; v14(111.7,56.64) v8(111.95,56.64) ; v14(113.27,57.94) v8(113.53,57.94) ; v14(109.34,57.29) v8(109.59,57.3) ; v14(110.12,58.59) v8(110.38,58.6) ; v14(110.12,60.55) v8(110.38,60.54) ; v14(108.55,57.94) v8(108.8,57.94) ; v14(112.49,60.55) v8(112.74,60.54) ; v14(112.49,57.94) v8(112.74,57.94) ; v14(111.7,57.29) v8(111.95,57.3)
  BOTTOM w0.127: v14(111.7,65.15) 111.97,65.42 ; v14(111.7,65.15) 111.41,64.85 ; v14(111.7,65.15) 111.96,64.89 ; v14(111.7,65.15) 111.7,65.15 111.42,65.42 ; v14(111.7,63.8) 111.96,63.53 ; v14(111.7,63.8) 111.41,63.5 ; v14(111.7,63.8) 111.97,64.07 ; v14(111.7,63.8) 111.7,63.8 111.42,64.07 ; v14(110.91,63.8) 110.91,63.8 110.63,64.07 ; v14(110.91,63.8) 111.17,63.53 ; v14(110.91,63.8) 110.62,63.5 ; v14(110.91,63.8) 111.18,64.07 ; UC1.BU13 112.07,78.35 ; UC1.BU13 111.51,78.32 ; UC1.BU13 112.08,78.88 ; UC1.BU13 111.8,78.61 111.53,78.89 ; 110.61,78.24 110.89,77.96 UC1.BR14 ; 109.83,64.2 v14(110.12,64.5) ; v14(110.12,64.5) 110.12,64.5 109.85,64.77 ; v14(110.12,64.5) 110.39,64.24 ; v14(110.12,64.5) 110.39,64.77 ; UC1.BU14 112.08,78.23 ; UC1.BU14 111.8,77.96 111.53,78.24 ; UC1.BU14 111.51,77.67 ; UC1.BU14 112.07,77.7 ; UC1.BV14 112.98,77.7 ; UC1.BV14 112.99,78.23 ; UC1.BV14 112.72,77.96 112.44,78.24 ; UC1.BV14 112.43,77.67 ; 110.61,78.89 110.89,78.61 UC1.BR13 ; v14(110.12,65.15) 110.39,64.89 ; v14(110.12,65.15) 110.12,65.15 109.85,65.42 ; v14(110.12,65.15) 109.83,64.85 ; v14(110.12,65.15) 110.39,65.42 ; 112.19,64.85 v14(112.49,65.15) 112.48,65.15 112.21,65.42 ; UC1.BV13 112.98,78.35 ; UC1.BV13 112.99,78.88 ; UC1.BV13 112.72,78.61 112.44,78.89 ; UC1.BV13 112.43,78.32 ; 109.83,63.5 v14(110.12,63.8) ; v14(110.12,63.8) 110.39,64.07 ; v14(110.12,63.8) 110.39,63.53 ; v14(110.12,63.8) 110.12,63.8 109.85,64.07 ; UC1.BR14 110.6,77.67 ; UC1.BR14 111.15,77.7 ; UC1.BR14 111.16,78.23 ; v14(111.7,64.5) 111.97,64.77 ; v14(111.7,64.5) 111.96,64.24 ; v14(111.7,64.5) 111.7,64.5 111.42,64.77 ; v14(111.7,64.5) 111.41,64.2 ; 112.21,64.77 112.48,64.5 v14(112.49,64.5) 112.19,64.2 ; 112.21,64.07 112.48,63.8 v14(112.49,63.8) 112.19,63.5 ; UC1.BR13 111.16,78.88 ; UC1.BR13 111.15,78.35 ; UC1.BR13 110.6,78.32
  vias: v5(108.36,61.02) v5(108.8,59.57) v5(108.8,58.27) v5(109.29,61.02) v5(109.59,59.57) v5(109.59,56.97) v5(110.38,64.82) v5(110.38,63.47) v5(110.38,62.17) v5(110.38,60.87) v5(110.38,58.27) v5(110.38,56.97) v9(104.6,44.65) v9(104.6,44.09) v9(104.59,43.53) v9(104.6,42.97) v9(104.61,42.4) v9(105.24,44.65) v9(105.24,44.09) v9(105.23,43.53) v9(105.23,42.97) v9(105.25,42.4) v9(105.25,41.84) v9(109.25,55.84) v9(109.25,55) v9(110.09,55.84) v9(110.09,55) v9(110.93,55.84) v9(111.34,78.29) v9(112.25,78.29)
+VCCSA: length 33.4
  GND2 w0.254: v7(113.83,68.28) v5(113.45,68.28) ; v7(113.81,65.61) v5(113.56,65.85) ; v7(114.84,65.49) v5(114.59,65.72) ; v7(114.84,62.69) v5(115.1,62.17) ; v7(113.83,62.82) 113.77,62.8 113.51,62.22 v5(113.53,62.17) ; v7(113.83,66.88) v5(113.45,66.88) ; v7(114.84,64.03) v5(114.32,63.47) ; v7(113.83,64.03) v5(113.53,63.47) ; v7(114.84,68.28) v5(114.46,68.28) ; v7(114.84,66.88) v5(114.46,66.88)
  GND3 w0.254: v5(114.59,65.72) v8(114.26,65.72) ; v5(113.45,68.28) v15(113.06,68.28) ; v5(114.46,66.88) v15(114.08,66.88) ; v5(114.46,68.28) v15(114.08,68.28) ; v5(113.56,65.85) v8(113.23,65.85) ; v5(113.45,66.88) v15(113.06,66.88)
  IN3 w0.254: v14(113.27,61.85) v8(113.53,61.84) ; v14(113.27,63.15) v8(113.53,63.14) ; v14(116.42,58.59) v8(116.68,58.6) ; v14(114.85,62.5) v8(115.1,62.5) ; v14(114.06,60.55) v8(114.32,60.54) ; v14(114.06,63.8) v8(114.32,63.8) ; v14(113.27,62.5) v8(113.53,62.5) ; v14(115.64,61.2) v8(115.89,61.2) ; v14(114.85,60.55) v8(115.1,60.54) ; v14(114.06,57.94) v8(114.32,57.94) ; v14(114.85,57.29) v8(115.1,57.3) ; v14(115.64,58.59) v8(115.89,58.6) ; v14(114.85,61.2) v8(115.1,61.2) ; v14(114.06,59.24) v8(114.32,59.24) ; v14(115.64,62.5) v8(115.89,62.5) ; v14(114.06,64.5) v8(114.32,64.49) ; v14(115.64,57.94) v8(115.89,57.94) ; v14(116.42,57.94) v8(116.68,57.94) ; v14(114.06,65.15) v8(114.32,65.15) ; v14(115.64,59.24) v8(115.89,59.24) ; v14(114.06,56.64) v8(114.32,56.64) ; v14(115.64,61.85) v8(115.89,61.84) ; v14(114.06,59.89) v8(114.32,59.9) ; v14(116.42,59.89) v8(116.68,59.9) ; v14(114.85,57.94) v8(115.1,57.94) ; v14(114.85,58.59) v8(115.1,58.6) ; v14(114.85,63.8) v8(115.1,63.8) ; v14(116.42,65.15) v8(116.68,65.15) ; v14(116.42,61.2) v8(116.68,61.2) ; v14(115.64,63.8) v8(115.89,63.8) ; v14(114.85,61.85) v8(115.1,61.84) ; v14(114.85,63.15) v8(115.1,63.14) ; v14(115.64,63.15) v8(115.89,63.14) ; v14(114.06,57.29) v8(114.32,57.3) ; v14(116.42,60.55) v8(116.68,60.54) ; v14(115.64,60.55) v8(115.89,60.54) ; v14(114.85,65.15) v8(115.1,65.15) ; v14(114.85,64.5) v8(115.1,64.49) ; v14(114.06,58.59) v8(114.32,58.6) ; v14(115.64,59.89) v8(115.89,59.9) ; v14(114.85,56.64) v8(115.1,56.64) ; v14(113.27,63.8) v8(113.53,63.8) ; v14(114.06,61.2) v8(114.32,61.2) ; v14(114.06,63.15) v8(114.32,63.14) ; v14(116.42,59.24) v8(116.68,59.24) ; v14(116.42,63.15) v8(116.68,63.14) ; v14(116.42,63.8) v8(116.68,63.8) ; v14(116.42,64.5) v8(116.68,64.49)
  BOTTOM w0.127: v14(114.06,64.5) 114.33,64.77 ; v14(114.06,64.5) 114.32,64.24 ; v14(114.06,64.5) 113.77,64.2 ; v14(114.06,64.5) 114.06,64.5 113.78,64.77 ; v14(114.85,64.5) 114.85,64.5 114.57,64.77 ; v14(114.85,64.5) 115.12,64.77 ; v14(114.85,64.5) 115.11,64.24 ; v14(114.85,64.5) 114.56,64.2 ; 116.13,63.5 v14(116.42,63.8) 116.42,63.8 116.14,64.07 ; 113.78,64.07 114.06,63.8 v14(114.06,63.8) ; 113.54,63.53 v14(113.27,63.8) 113.54,64.07 ; v14(114.06,63.8) 114.32,63.53 ; v14(114.06,63.8) 113.77,63.5 ; v14(114.06,63.8) 114.33,64.07 ; v14(115.64,63.8) 115.63,63.8 115.36,64.07 ; v14(115.64,63.8) 115.34,63.5 ; v14(115.64,63.8) 115.91,64.07 ; v14(115.64,63.8) 115.9,63.53 ; 116.14,64.77 116.42,64.5 v14(116.42,64.5) 116.13,64.2 ; 114.56,63.5 v14(114.85,63.8) ; v14(114.85,63.8) 114.85,63.8 114.57,64.07 ; v14(114.85,63.8) 115.12,64.07 ; v14(114.85,63.8) 115.11,63.53 ; v14(114.85,65.15) 115.12,65.42 ; v14(114.85,65.15) 114.85,65.15 114.57,65.42 ; v14(114.85,65.15) 115.11,64.89 ; v14(114.85,65.15) 114.56,64.85 ; 116.14,65.42 116.42,65.15 v14(116.42,65.15) 116.13,64.85 ; v14(114.06,65.15) 114.06,65.15 113.78,65.42 ; v14(114.06,65.15) 114.33,65.42 ; v14(114.06,65.15) 113.77,64.85 ; v14(114.06,65.15) 114.32,64.89
  vias: v2(113.06,50.74) v3(108.56,45.74) v3(108.56,45.1) v3(109.06,45.74) v3(109.06,45.1) v3(109.57,45.74) v3(109.57,45.1) v3(110.08,45.74) v3(110.08,45.1) v5(114.32,64.82) v5(114.32,60.87) v5(114.32,59.57) v5(114.32,58.27) v5(114.32,56.97) v5(115.1,64.82) v5(115.1,63.47) v5(115.1,60.87) v5(115.1,58.27) v5(115.1,56.97) v5(115.89,63.47) v5(115.89,62.17) v5(115.89,60.87) v5(115.89,59.57) v5(115.89,58.27) v5(116.68,59.57) v5(116.68,58.27) v7(113.83,61.3) v7(114.84,61.3) v9(109.88,50.76) v9(109.88,49.51) v9(109.88,48.42) v9(109.88,46.92) v9(110.72,52.53) v9(111.1,45.99) v9(111.1,45.42) v9(111.1,44.85) v9(111.1,44.28) v9(111.25,49.76) v9(111.22,46.84) v9(111.54,53.36) v9(111.54,52.53) v9(111.67,45.99) v9(111.67,45.42) v9(111.67,44.85) v9(111.67,44.28) v9(112.4,54.22) v9(112.4,53.38) v9(112.4,52.55) v9(113.24,55.06) v9(113.24,54.22) v9(113.24,53.38) v9(113.24,52.55) v9(114.08,55.06) v9(114.08,54.22) v9(114.08,53.38) v9(114.08,52.55) v16(112.75,44.41)
+VCCST: length 291.9
  TOP w0.381: PR1108.1 135.16,43.96 134.27,44.85 134.27,49.51 v16(135.34,50.58) v2(135.83,51.07) ; PR1111.1 PR1112.1 PR1116.1 141.55,50.2 141.53,50.17 PC1104.1 PR1115.1
  TOP w0.508: v2(131.06,72.29) 131.26,72.29 131.72,71.84 133.63,71.84 134.54,70.92 134.59,70.92 v7(135.39,70.13) ; PC1104.1 140.24,50.17 140.2,50.21 138.26,50.21 137.23,51.24 136,51.24 v2(135.83,51.07)
  IN1 w0.508: v2(131.06,72.29) 125.5,72.29 124.81,72.98 116.3,72.98 115.72,72.4 115.72,71.61 114.98,70.87 111.15,70.87 109.72,69.45 109.72,66.71 110.01,66.42 110.01,65.24 108.73,63.96 v7(108.73,63.61) ; v4(107.46,28.73) 106.75,28.02 105.85,28.02 v4(103.5,25.68) ; v7(135.39,70.13) 134.75,69.5 134.75,52.15 v2(135.83,51.07)
  GND2 w0.254: v7(108.73,63.61) 108.73,63.11 v5(108.66,63.04) 108.48,62.86 v7(108.48,62.72) ; v7(31.68,17.23) v5(31.68,16.78)
  GND2 w0.508: v4(107.46,28.73) 107.46,29.11 v5(107.34,29.24) ; v7(53.9,8.72) v5(53.9,9.16) ; v4(103.5,25.68) 103.12,25.68 v5(102.85,25.41) ; v5(134.97,70.69) 135.18,70.49 135.18,70.34 v7(135.39,70.13) ; v5(112.85,28.99) 112.87,29.01 113.29,29.01 v7(113.71,29.43)
  IN2 w0.254: v5(51.77,13.95) 51.54,13.72 48.25,13.72 47.99,13.98 45.68,13.98 45.54,14.11 43.97,14.11 43.29,14.78 41.21,14.78 40.86,15.14 35.33,15.14 33.69,16.78 v5(31.68,16.78)
  IN2 w0.508: v5(102.85,25.41) 94.96,25.41 93.59,26.79 91.64,26.79 90.57,25.72 90.57,24.45 88.94,22.82 88.03,22.82 84.64,19.42 84.64,16.21 82.64,14.21 77.99,14.21 77.35,13.57 56.81,13.57 56.16,14.23 53.61,14.23 52.97,14.86 52.39,14.86 51.77,14.25 v5(51.77,13.95) ; v5(136.93,70.08) 135.58,70.08 v5(134.97,70.69)
  GND3 w0.254: v6(108.11,62.65) 108.27,62.65 v5(108.66,63.04) 108.71,63.04 109.04,62.71 v6(109.04,62.65)
  GND3 w0.305: v6(137.33,70.31) 137.16,70.31 v5(136.93,70.08) ; v5(134.97,70.69) 135.1,70.57 135.1,70.39 v6(135.18,70.31)
  GND3 w0.508: v6(52.15,13.3) 52.1,13.35 52.1,13.62 v5(51.77,13.95) ; v6(53.63,9.95) 53.9,9.68 v5(53.9,9.16) ; v5(112.85,28.99) v8(112.85,28.51) ; v5(102.85,25.41) 103.02,25.58 v8(103.13,25.58) ; v8(107.54,29.85) 107.54,29.44 v5(107.34,29.24)
  IN3 w0.381: 104.44,62.79 104.44,63.68 103.78,64.34 103.78,70.8 103.4,71.18 103.4,72.45 103.7,72.75 103.7,76.28 104.03,76.61 104.03,77.15 103.81,77.37 103.32,77.37 102.97,77.73 81.71,77.73 81.48,77.5 81.48,70.01 84.4,67.09 84.4,63.2
  IN3 w0.508: v8(112.85,28.51) 112.43,28.1 105.65,28.1 v8(103.13,25.58) ; v8(107.54,29.85) 111.38,29.85 111.82,30.3 111.82,33.47 111.5,33.79 110.84,33.79 110.64,33.99 107.64,33.99 107.24,34.39 106.73,34.39 106.35,34.78 106.35,35.52 107.18,36.35 107.18,38.64 106.87,38.96 106.87,41.04 107.46,41.64 107.46,45.52 107.03,45.95 107.03,49.23 105.64,50.63 105.64,54.47 105,55.11 105,58.48 103.24,60.23 103.24,60.87 104.05,61.68
  BOTTOM w0.305: RH47.1 138.59,71.2 139.05,70.74 RH44.1 ; RH47.1 RH46.1 ; RH47.1 138.22,71.09 137.45,70.31 v6(137.33,70.31)
  BOTTOM w0.381: v3(83.19,55.61) 82.27,54.68 RH45.1
  BOTTOM w0.508: v6(52.15,13.3) 52.32,13.3 52.83,12.79 52.83,12.18 52.63,11.98 52.63,10.29 52.97,9.95 v6(53.63,9.95)
  vias: v6(104.45,62)
+VCCSTG: length 249.2
  TOP w0.356: RH51.1 v2(145.54,73.74)
  TOP w0.508: RH635.1 v2(61.9,83.79) ; v9(106.8,44.89) 107.84,45.93 107.84,51.47 108.65,52.28 108.65,60.88 CH40.1 v7(108.73,61.85) ; v7(86.75,29.06) 85.74,28.05 85.54,28.05 85.04,27.54 v16(85.04,24.59) 85.04,21.95 v7(85.06,21.93)
  IN1 w0.381: v4(139.73,86.39) 140.69,85.43 141.77,85.43 143.21,83.98 143.21,82.11 145.23,80.1 145.23,77.27 145.51,76.98 145.51,73.77 v2(145.54,73.74)
  IN1 w0.508: v2(61.9,83.79) 62.58,83.79 63.3,84.51 63.3,86.02 66.89,89.62 67.86,89.62 v4(70.01,91.78) ; v4(95.04,31.17) 93.3,29.43 87.13,29.43 v7(86.75,29.06)
  GND2 w0.381: v4(139.73,86.39) v5(139.73,86.93)
  GND2 w0.508: v4(95.04,31.17) v5(95.04,31.65) ; v5(70.46,91.84) 70.08,91.84 v4(70.01,91.78) ; v7(108.73,61.85) 108.73,61.85 108.2,61.85 v5(107.62,61.68) ; v7(85.06,21.93) 84.91,22.08 v5(84.58,22.08) ; v5(86.78,28.68) 86.78,29.02 v7(86.75,29.06)
  IN2 w0.508: 111.6,84.66 111.6,86.77 112.11,87.28 ; v5(95.04,31.65) 95.22,31.83 99.14,31.83 100.03,32.72 103.2,32.72 104.29,33.81 104.29,36.25 105.13,37.09 105.13,38.46 106.8,40.14 v9(106.8,44.89) ; 112.11,87.28 110.12,87.28 109.61,87.79 92.73,87.79 92.31,88.21 83.87,88.21 83.16,88.92 82.18,88.92 81.47,89.63 78.94,89.63 78.67,89.9 78.67,91.18 77.95,91.9 75.54,91.9 75.49,91.85 70.47,91.85 v5(70.46,91.84) ; 112.11,87.28 116.66,87.28 117.07,87.69 119,87.69 119.47,87.22 137.14,87.22 137.47,86.89 v5(138.68,86.89) ; v5(84.58,22.08) 83.92,22.74 78.85,22.74 77.94,23.65 76.8,23.65 75.11,21.96 62.71,21.96 60.84,20.09 56.94,20.09 56.06,20.97 52.97,20.97 52.79,21.15 50.5,21.15 50.05,21.6 43.74,21.6 42.99,22.34 42.99,23 42.67,23.32 39.79,23.32 39.15,23.96 39.15,26.87 37.57,28.45 35.9,28.45 35.32,27.87 33.12,27.87 v5(32.76,28.23) ; v5(107.62,61.68) 107.62,62.79 108.75,63.92 108.75,70 110.83,72.07 110.83,76.9 111.73,77.81
  GND3 w0.254: v6(105.37,62) 105.34,62 v5(105.1,62.24) ; v6(107.2,61.35) 107.29,61.35 v5(107.62,61.68) 107.3,62 v6(107.2,62)
  GND3 w0.381: v5(32.76,28.23) 32.76,28.34 v6(32.37,28.73) 32.36,28.75 v6(31.68,28.75) v6(31,28.75)
  GND3 w0.508: v5(138.68,86.89) 139.69,86.89 v5(139.73,86.93) ; v6(86.49,28.39) v5(86.78,28.68)
  BOTTOM w0.305: RC11.1 v6(31,28.75)
  BOTTOM w0.508: RZ38.1 85.94,28.09 CZ30.1 86.18,28.1 86.47,28.39 v6(86.49,28.39)
+VDD08: length 42.2
  TOP w0.356: CH126.1 84.3,68.38 RH543.2
  TOP w0.381: RH483.2 80.37,80.46 v16(81.44,79.39) 81.44,78.79 v2(82.37,77.86) 82.37,77.27 82.01,76.92 82.01,72.35 82.39,71.96 84.24,71.96 84.62,71.58 84.62,69.98 84.3,69.67 RH543.2
  IN1 w0.381: v2(82.37,77.86) 82.5,77.73 104.79,77.73 105.11,77.41 105.11,76.66
  BOTTOM w0.127: UC1.BC39 103.71,61.62 ; UC1.BC39 103.15,61.05 ; UC1.BC39 103.7,61.08 ; UC1.BC39 103.44,61.35 103.16,61.62 ; 102.89,61.08 UC1.BB39 102.89,61.62
  vias: v2(103.83,63.2) v2(103.83,62.63) v2(103.83,62.06) v2(104.31,65.74) v2(104.45,63.2) v2(104.45,62.63) v2(104.45,62.06) v2(104.49,63.75) v2(104.68,67.39) v2(104.72,64.83) v2(104.73,64.47) v2(105,69.23) v2(105.52,64.85) v2(105.53,64.5) v2(107.16,69.23) v9(103.43,58.92) v9(103.44,58.27) v9(103.45,57.61) v9(103.45,55.5) v9(103.73,56.04) v9(103.92,60.47) v9(104.02,55.56) v9(135.29,81.74) v9(135.29,81.17) v9(135.29,80.6) v9(135.29,80.03) v9(135.29,79.46) v9(135.86,81.74) v9(135.86,81.17) v9(135.86,80.6) v9(135.86,80.03) v9(135.86,79.46)
+VDD08P: length 13
  TOP w0.254: PC3285.1 150.91,88.57 PR2336.1 151.1,88.4 152.02,87.48 v1(152.02,86.91) 152.02,83.41 147.33,78.72 v9(147.33,78.61)
  vias: v3(142.94,81.66) v3(142.95,81.11) v3(143.03,82.26) v3(142.96,80.54) v3(143.24,81.66) v3(143.35,82.25) v3(143.27,81.1) v3(143.29,80.53) v3(146.52,80.29) v3(146.51,79.91) v3(146.84,80.29) v3(146.84,79.9) v3(147.15,79.88) v3(147.16,80.27) v3(147.49,80.26) v3(147.47,79.88)
+VDD12: length 28.6
  TOP w0.254: PC3005.1 v7(65.88,64.62) ; PC3008.1 v7(64.74,64.7) ; v7(66.9,64.65) PC3001.1
  IN1 w0.305: 79.98,66.95 80.86,66.06 80.86,64.07 82.22,62.72 v2(83.07,62.72)
  GND2 w0.254: v7(65.88,64.62) v5(65.88,64.98) ; v7(79.54,76.6) 79.73,76.6 v5(79.85,76.73) ; v7(83.41,69.11) 83.41,69.3 v5(83.54,69.42) ; v5(75.71,67.67) 75.53,67.86 v7(75.37,67.86) ; v5(82.33,69.42) 82.2,69.3 v7(82.2,69.11) ; v5(79.85,73.93) 79.73,74.06 v7(79.54,74.06) ; v5(79.85,76.09) 79.73,76.22 v7(79.54,76.22) ; v5(79.85,67.84) 79.73,67.96 v7(79.54,67.96) ; v5(67.74,64.06) 67.76,64.09 v7(67.76,64.47) ; v5(82.9,69.42) 83.03,69.3 v7(83.03,69.11) ; v7(83.03,70.36) v5(83.49,70.36) v7(83.92,70.36) ; v7(77.82,69.68) v5(77.57,69.93) 77.53,69.97 v7(77.2,69.97) ; v7(79.28,70.91) 79.37,70.91 v5(79.66,71.2) ; v7(79.98,70.44) 79.98,70.63 v5(79.85,70.76) ; v7(77.95,70.82) v5(78.2,70.57) v7(77.95,70.31) ; v7(75.09,68.48) 75.31,68.48 v5(75.46,68.64) v7(75.17,68.93) ; v7(64.74,64.7) v5(64.74,65.06) ; v7(78.81,66.96) v5(79.07,66.7) ; v5(67.94,62.9) 67.64,63.2 v7(67.61,63.2) ; v7(68.32,64.85) 68.65,64.85 v5(68.7,64.9) ; v5(67.97,62.08) 67.69,62.36 v7(67.69,62.39) ; v5(79.85,73.3) 79.73,73.17 v7(79.54,73.17) ; v7(79.54,74.44) 79.73,74.44 v5(79.85,74.57) ; v7(67.76,64.85) v5(67.76,65.21) ; v7(68.32,64.47) 68.63,64.47 v5(68.7,64.39) ; v5(68.7,62.11) 68.45,62.36 v7(68.42,62.36) ; v5(79.85,72.66) 79.73,72.79 v7(79.54,72.79) ; v5(78.15,68.32) 78.18,68.35 v7(78.18,68.71) ; v5(68.65,62.92) 68.37,63.2 v7(68.35,63.2) ; v7(79.54,68.34) 79.73,68.34 v5(79.85,68.47) ; v7(77.77,66.65) 78.05,66.65 v5(78.15,66.75) ; v5(81.7,69.42) 81.82,69.3 v7(81.82,69.11) ; v7(66.87,62.36) 66.87,62.39 v5(67.18,62.69) ; v7(81.25,70.36) v5(81.71,70.36) v7(82.14,70.36) ; v5(80.49,70.76) 80.36,70.63 v7(80.36,70.44) ; v7(66.9,64.65) v5(66.9,65.03) ; v7(66.9,63.2) v5(66.39,63.2)
  GND3 w0.254: v6(67.94,68.31) 67.94,68.36 v5(67.69,68.61) 67.46,68.38 v6(67.46,68.31) ; v6(68.4,68.31) 68.4,68.51 v5(68.58,68.69) 68.81,68.46 v6(68.81,68.31) ; v6(66.09,68.28) 66.09,68.33 v5(65.86,68.56) 65.63,68.33 v6(65.63,68.26) ; v6(66.54,68.28) 66.54,68.41 v5(66.75,68.61) 67,68.36 v6(67,68.31) ; v5(75.71,67.67) 75.91,67.82 v14(75.92,67.93)
  BOTTOM w0.254: UC1.A29 v14(75.92,67.93)
  vias: v5(76.22,66.76) v5(77.12,68.27) v5(77.12,66.7) v8(75.76,66.73) v8(75.92,67.14) v8(75.92,66.36) v8(76.73,68.23) v8(76.88,68.51) v8(76.88,66.93) v8(77.22,67.93) v8(77.22,66.36) v8(78.2,68.87) v8(78.18,67.29) v8(78.18,66.15) v8(78.61,66.68) v8(78.83,66.93) v8(79.17,66.36) v9(70.51,60.79) v9(70.51,60.2) v9(70.51,59.63) v9(70.51,59.06) v9(70.51,58.49) v9(70.51,57.92) v9(70.51,57.33) v9(71.09,60.79) v9(71.09,60.2) v9(71.09,59.63) v9(71.09,59.06) v9(71.09,58.49) v9(71.09,57.92) v9(71.09,57.33) v13(75.76,66.73) v13(75.92,67.14) v13(75.92,66.36) v13(76.73,68.23) v13(76.88,68.51) v13(76.88,66.93) v13(77.22,67.93) v13(77.22,66.36) v13(78.2,68.87) v13(78.18,67.29) v13(78.18,66.15) v13(78.61,66.68) v13(78.83,66.93) v13(79.17,66.36) v14(75.76,66.73) v14(75.92,67.14) v14(75.92,66.36) v14(76.73,68.23) v14(76.88,68.51) v14(76.88,66.93) v14(77.22,67.93) v14(77.22,66.36) v14(78.2,68.87) v14(78.18,67.29) v14(78.18,66.15) v14(78.61,66.68) v14(78.83,66.93) v14(79.17,66.36) v16(63.03,66.63)
+VDD_18: length 268.4
  TOP w0.254: PR1806.1 PR1807.1 PR1808.1 47.56,38.88 v16(47.15,38.47) 47.15,37.41 PR1820.1 47.77,36.55 48.03,36.29 48.35,36.29 v7(48.35,36.29) ; v7(58.2,23.03) 58.26,22.97 58.26,18.88 58.47,18.67 RH573.1
  TOP w0.305: v7(84.09,83.83) 84.09,81.73 84.37,81.45 RH538.1 ; v7(89.79,93.22) 89.61,93.22 88.87,92.48 86.12,92.48 85.81,92.79 84.04,92.79 v9(83.99,92.74)
  TOP w0.381: v2(83.85,80.98) 84.34,80.98 RH538.1 ; R93.2 v7(67.55,90.82)
  IN1 w0.305: v4(91.51,93.48) 91.46,93.53 90.1,93.53 v7(89.79,93.22)
  IN1 w0.381: v4(78.05,78.79) 78.95,79.69 82.96,79.69 83.28,80.01 83.28,80.67 83.59,80.98 83.6,80.98 83.6,80.98 v2(83.85,80.98)
  GND2 w0.254: v7(48.35,36.29) 48.35,36.3 48.41,36.36 v5(48.89,36.36) ; v7(58.2,23.03) 57.97,23.26 v5(57.73,23.26)
  GND2 w0.305: v5(83.97,84.21) 83.97,83.95 v7(84.09,83.83) ; v5(90.27,93.13) 89.88,93.13 v7(89.79,93.22) ; v4(91.51,93.48) 91.94,93.48 92.05,93.38 v5(92.05,93.35)
  GND2 w0.381: v4(78.05,78.79) v5(77.81,78.55)
  IN2 w0.254: v5(53.69,74.68) 53.57,74.56 53.57,70.36 51.18,67.96 51.18,66.72 46.91,62.45 46.91,60.41 44.73,58.22 44.73,57.56 44.88,57.41 45.18,57.41 45.73,56.86 45.73,54.37 49.64,50.46 49.64,39.37 48.89,38.61 v5(48.89,36.36) 49.35,36.36 50.03,35.67 50.03,32.97 50.24,32.77 50.24,27.11 53.37,23.98 57.02,23.98 v5(57.73,23.26)
  IN2 w0.381: v5(77.81,78.55) 77.69,78.43 77.69,75.14 77.3,74.74 76.82,74.74 76.81,74.76 76.78,74.76 76.53,75.01 75.6,75.01 74.46,73.87 74.46,65.66 77.54,62.58 77.54,56.05 v5(77.67,55.93)
  IN2 w0.914: 77.19,88.6 78.37,87.42 91.98,87.42 92.63,86.77 92.63,86.32 93.21,85.73 93.21,83.6 92.96,83.34 92.96,79.69 94.21,78.44 98.24,78.44 98.4,78.59 103.02,78.59 103.66,77.95 104.66,77.95 105.08,78.36 107.64,78.36 109.76,76.24 109.76,75.52
  GND3 w0.254: v8(54.05,74.76) 53.97,74.68 v5(53.69,74.68)
  GND3 w0.305: v5(83.97,84.21) 83.65,84.21 v8(83.59,84.27) ; v6(90.65,93.13) v5(90.27,93.13) ; v5(92.05,93.35) 92.33,93.07 v6(92.74,93.07)
  GND3 w0.381: v6(77.26,91.34) v5(76.81,91.34) ; v6(78.06,55.93) v5(77.67,55.93) ; v5(72.96,88.64) 72.72,88.4 v6(72.69,88.4)
  GND3 w0.914: 77.36,88.48 78.42,87.42 91.98,87.42 92.63,86.77 92.63,86.32 93.42,85.52 93.42,83.81 93.07,83.46 93.07,79.57 94.3,78.35 98.15,78.35 98.25,78.45 103.16,78.45 103.66,77.95 104.66,77.95 105.08,78.36 107.34,78.36 109.76,75.94 109.76,75.52
  IN3 w0.254: v6(67.81,85.3) 67.23,84.71 67.23,83.7 66.47,82.94 63.94,82.94 55.53,74.53 54.28,74.53 v8(54.05,74.76)
  IN3 w0.305: v8(83.59,84.27) 81.71,84.27 80.49,85.49 80.49,88.99 v6(80.99,89.49) 82.67,89.49 84.15,90.96 84.15,92.59 v9(83.99,92.74)
  BOTTOM w0.254: RH496.1 79.66,90.89 RH498.1 RH495.1 RH499.1 RH500.1 ; v6(67.81,85.3) 68.14,85.63 68.14,85.73 69.36,86.95 RH497.1 ; RH500.1 RH501.1 ; RH500.1 77.38,91.23 v6(77.26,91.34)
  BOTTOM w0.305: RH496.1 79.87,90.87 80.11,90.63 80.11,90.37 v6(80.99,89.49)
  BOTTOM w0.381: v6(78.06,55.93) 78.06,54.26 78.39,53.93 RH539.1 78.65,53.21 79.03,52.83 80.32,52.83 80.68,52.47 80.68,52.22 80.68,52.09 80.97,51.8 RH568.1 CH234.1 82.04,51.02 YC1.4 ; v6(72.69,88.4) 72.31,88.78 71.22,88.78 70.48,88.04 RH502.1 RH497.1
  vias: v5(67.95,91.31) v5(67.96,90.78) v5(68.42,91.32) v5(68.43,90.78) v5(76.43,88.89) v5(76.41,88.42) v7(67.57,91.22) v9(109.51,74.69) v9(109.56,74.11) v9(110.08,74.69) v9(110.13,74.11)
+VDD_33: length 291.3
  TOP w0.305: RH553.1 RH554.1
  TOP w0.356: RE289.1 45.12,22.01 v2(45.12,22.9) 45.48,23.26 QE27.2 ; RE290.1 41.38,23.98 v9(41.36,23.97)
  TOP w0.381: RH553.1 81.76,80.86 v9(82.39,80.23) ; UZ22.5 64.12,22.39 64.36,22.62 64.36,23.08 CH239.1 RH576.1 RH572.1 60.59,23.6 60.87,23.32 62.01,23.32 62.77,22.56 62.77,20.78 v2(62.84,20.72) ; QE27.5 43.41,23.26 43.18,23.49 42.33,23.49 42.31,23.5 42.28,23.5 41.94,23.84 RE290.1
  TOP w0.457: v2(68.09,91.6) R95.2
  TOP w0.508: RH603.1 58.26,9.89 59.2,8.95 60.53,8.95 v7(62.77,11.19) 63.34,11.76 RH583.1 64.23,12.78 65.22,13.77 v2(65.22,16.67) ; v9(89.06,96.96) 88.12,97.89 84.23,97.89 83.31,96.97 83.31,95.74 83.78,95.27 v9(83.78,94.13) 83.6,94.13 82.78,93.3 82.78,92 81.63,90.86 73.41,90.86 v16(72.27,92) v7(71.47,92.79) ; R95.2 68.88,90.84 v2(69.95,90.84) ; 82.33,81.51 82.33,84.33 v7(82.83,84.83) ; v2(52.36,73.29) 53.92,73.29 v7(54.76,72.45)
  IN1 w0.508: v2(68.09,91.6) 67.96,91.73 67.15,91.73 63.13,87.71 v7(62.89,87.71) ; v4(59.66,81.24) 58.6,81.24 57.45,80.09 57.45,78.38 v2(52.36,73.29) 51.61,72.54 50.73,72.54 47.5,69.31 47.5,68.82 46.68,68 46.37,68 45.86,67.49 45.86,62.41 44.94,61.49 44.94,60.88 42.32,58.26 42.32,57.5 41.3,56.47 41.3,53.63 v4(42.38,52.55) ; v2(65.22,16.67) 65.22,18.46 62.96,20.72 v2(62.84,20.72) 62.19,20.72 61.74,20.28 57.48,20.28 v2(56.24,21.51) 56.13,21.62 53.65,21.62 52.94,22.33 49.12,22.33 49.06,22.27 46.43,22.27 45.79,22.9 v2(45.12,22.9) 44.76,22.9 43.7,23.97 v9(41.36,23.97) ; v7(71.47,92.79) 71.47,92.27 70.04,90.84 v2(69.95,90.84)
  GND2 w0.254: v7(54.76,72.45) 55.17,72.04 v5(55.17,71.91)
  GND2 w0.305: v5(82.57,84.59) 82.59,84.59 v7(82.83,84.83)
  GND2 w0.508: v7(62.77,11.19) 63.19,11.19 v5(63.22,11.22) ; v7(62.89,87.71) v5(62.89,87.38) ; v5(42.14,52.3) v4(42.38,52.55) ; v4(59.66,81.24) v5(59.99,81.24)
  IN2 w0.254: v5(53.67,66.83) 54.67,67.83 54.67,71.41 v5(55.17,71.91)
  IN2 w0.508: v5(59.99,81.24) 61.06,81.24 62.89,83.06 v5(62.89,87.38) ; v9(104.97,59.57) 104.96,59.58 v9(104.96,60.27) 103.92,61.32 103.92,64.34 103.66,64.6 103.66,65.94 103.53,66.07 103.53,76.97 102.84,77.65 93.72,77.65 93.1,78.27 89.62,78.27 89.19,78.71 89.19,79.61 88.57,80.23 v9(82.39,80.23) ; v5(42.14,52.3) 40.94,51.11 40.94,47 42.64,45.29 42.64,42.35 41.68,41.38 41.68,40.82 42.16,40.34 42.16,39.78 40.62,38.24 40.62,24.72 v9(41.36,23.97)
  GND3 w0.254: v6(62.66,11.13) 62.75,11.22 v5(63.22,11.22) ; v5(53.67,66.83) 53.82,66.68 v6(53.82,66.48)
  GND3 w0.305: v5(82.57,84.59) 82.59,84.59 v8(82.82,84.82)
  IN3 w0.508: v6(87.12,90.89) 86.53,90.3 86.53,90.09 83.49,87.04 83.49,85.49 v8(82.82,84.82)
  BOTTOM w0.254: 56.29,66.41 56.29,64.73 57.2,63.82 58.38,63.82 59.85,65.29 59.85,66.63 59.5,66.98 58.77,66.98 57.78,67.96 R1320.2 ; 56.29,66.41 56.74,66.87 RH613.1 ; 56.29,66.41 53.88,66.41 v6(53.82,66.48) RH614.1 ; RH494.1 84.13,90.57 84.58,91.01 86.53,91.01
  BOTTOM w0.305: 72.43,8.41 72.77,8.07 JDGPU1.1
  BOTTOM w0.356: 72.43,8.41 72.21,8.63 72.21,9.33 71.79,9.75 CH124.1 RH530.1 68.44,11.13 v6(62.66,11.13)
  BOTTOM w0.508: RH571.1 104.45,92.86 103.25,94.06 101.7,94.06 100.82,94.94 95.18,94.94 93.16,96.96 v9(89.06,96.96) ; v9(83.78,94.13) 84.6,93.3 84.6,91.88 84.98,91.5 86.94,91.5
+VDD_33_GPU: length 3.6
  IN3 w0.508: v6(93.8,87.79) 93.82,87.81 v3(93.82,89.78) 93.82,90.54 v3(93.62,90.75)
  BOTTOM w0.508: v3(93.62,90.75) 93.82,90.95 RH607.1
  vias: v1(105.83,90.32)
+VDDAN_18: length 1.8
  GND2 w0.254: v5(106.19,59.47) 106.42,59.47 v4(106.6,59.65) ; v5(105.89,60.31) v4(106.22,60.31)
  GND3 w0.254: v5(106.19,59.47) 106.17,59.49 106.17,59.88 v6(106.19,59.89) ; v6(106.28,60.7) 105.89,60.31 v5(105.89,60.31)
  vias: v1(108.45,66.6) v2(109.5,65.87) v9(106.08,56.09) v9(106.08,55.52)
+VDDCI: length 76.8
  TOP w0.508: v2(61.88,47.99) 60.88,47.99 60.31,48.56 59.26,48.56 58.3,47.61 55.79,47.61 53.54,49.87 50.39,49.87 50,50.26 R5846.1
  TOP w1.524: 74.01,51.71 77.38,55.07 86.14,55.07 87.09,56.03 87.09,57.11
  IN1 w0.508: v2(61.88,47.99) 68.96,47.99 70.47,49.5 v2(75.16,49.5)
  GND2 w0.254: v5(87.68,64.75) 87.66,64.76 v7(87.66,65.11) ; v5(85.46,58.27) 85.78,58.59 v7(85.92,58.59) v5(86.25,58.27) 86.58,58.6 v7(86.71,58.6) 86.71,58.59 v5(87.04,58.27) 87.35,58.58 v7(87.35,58.6) ; v7(87.02,63.96) 87.03,63.95 v5(87.03,63.61) 87.02,63.59 v7(87.02,63.07) ; v7(87.66,67.65) 87.66,67.3 v5(87.68,67.29) ; v7(85.86,60.79) 86.17,60.79 v5(86.25,60.87) 86.25,60.88 v7(86.25,61.3) 85.99,61.3 v7(85.86,61.42) ; v5(86.25,62.23) 86.25,62.98 v7(86.15,63.07) 86.15,63.59 v5(86.17,63.61) 86.15,63.62 v7(86.15,63.96) ; v5(86.25,62.23) v7(86.25,61.85) ; v5(86.25,62.23) 86.03,62.23 v7(85.86,62.06) ; v7(87.8,60.79) 87.12,60.79 v5(87.04,60.87) 87.07,60.9 v7(87.07,61.3) 87.13,61.36 87.79,61.36 v7(87.8,61.37) 87.88,61.45 87.88,61.88 v7(87.8,61.96) ; v7(85.85,59.57) 85.46,59.57 v5(85.46,59.57) ; v7(86.69,62.41) 86.85,62.41 v5(87.04,62.23) 87.04,62.18 86.87,62.01 v7(86.71,62.01) ; v5(87.68,66.02) 87.66,66.03 v7(87.66,66.38) ; v5(86.66,67.29) 86.65,67.3 v7(86.65,67.65) ; v7(87.07,60.03) 87.07,59.6 v5(87.04,59.57) 87.02,59.55 v7(87.02,59.09) ; v7(86.65,65.11) 86.65,64.76 v5(86.66,64.75) ; v7(86.65,66.38) 86.65,66.03 v5(86.66,66.02)
  GND3 w0.254: v5(86.66,64.75) v8(86.99,64.75) ; v5(86.17,63.61) v8(86.5,63.61) ; v5(86.66,67.29) v8(86.99,67.29) ; v5(87.68,67.29) v8(87.35,67.29) ; v5(87.68,64.75) v8(87.35,64.75) ; v5(87.03,63.61) v8(87.36,63.61) ; v5(86.66,66.02) v8(86.99,66.02) ; v5(87.68,66.02) v8(87.35,66.02)
  IN3 w0.254: v14(86.5,61.9) v8(86.25,61.9) ; v14(86.5,57.29) v8(86.25,57.3) ; v8(85.46,61.2) 85.47,61.2 v3(85.72,61.2) ; v14(87.29,61.9) v8(87.04,61.9) ; v14(85.72,57.94) v8(85.46,57.94) ; v14(87.29,59.24) v8(87.04,59.24) ; v14(87.29,61.2) v8(87.04,61.2) ; v14(85.72,58.59) v8(85.46,58.6) ; v14(87.29,58.59) v8(87.04,58.6) ; v14(87.29,57.94) v8(87.04,57.94) ; v14(87.29,62.55) v8(87.04,62.56) ; v14(87.29,59.89) v8(87.04,59.9) ; v14(86.5,61.2) v8(86.25,61.2) ; v14(85.72,60.55) v8(85.46,60.54) ; v14(86.5,56.64) v8(86.25,56.64) ; v14(85.72,59.24) v8(85.46,59.24) ; v14(86.5,62.55) v8(86.25,62.56) ; v14(85.72,59.89) v8(85.46,59.9) ; v14(86.5,57.94) v8(86.25,57.94) ; v14(86.5,58.59) v8(86.25,58.6) ; v14(86.5,60.55) v8(86.25,60.54) ; v14(87.29,60.55) v8(87.04,60.54)
  BOTTOM w0.127: 86.21,62.26 v14(86.5,62.55) ; v14(86.5,62.55) 86.76,62.29 ; v14(86.5,62.55) 86.5,62.55 86.22,62.83 ; v14(86.5,62.55) 86.77,62.82 ; v14(86.5,61.9) 86.5,61.9 86.22,62.18 ; v14(86.5,61.9) 86.77,62.17 ; v14(86.5,61.9) 86.21,61.61 ; v14(86.5,61.9) 86.76,61.64 ; v14(87.29,62.55) 87.29,62.55 87.01,62.83 ; v14(87.29,62.55) 87,62.26 ; v14(87.29,62.55) 87.56,62.82 ; v3(85.72,61.2) 85.98,61.46 ; v3(85.72,61.2) 85.98,60.93 ; v3(85.72,61.2) 85.71,61.2 85.44,61.47 ; v3(85.72,61.2) 85.42,60.9 ; v14(86.5,61.2) 86.77,61.46 ; v14(86.5,61.2) 86.76,60.93 ; v14(86.5,61.2) 86.21,60.9 ; v14(86.5,61.2) 86.5,61.2 86.22,61.47 ; 87.01,62.18 87.29,61.9 v14(87.29,61.9) ; 87.01,61.47 87.29,61.2 v14(87.29,61.2) ; v14(87.29,61.9) 87,61.61 ; v14(87.29,61.9) 87.55,61.64 ; v14(87.29,61.2) 87,60.9 ; v14(87.29,61.2) 87.56,61.46 ; v14(87.29,61.2) 87.55,60.93
  vias: v16(75.35,50.31)
+VDDCIP: length 14.4
  TOP w0.254: v2(66.08,50.69) 66.36,50.41 PU4255.10 ; v9(71.73,50.26) 71.81,50.26 72.26,50.7 72.26,51.17 72.01,51.41 v1(70.18,51.41) PC3264.1 69.22,51.6 68.54,52.28 68.54,53.04 PR2311.1
  IN1 w0.254: v2(66.08,50.69) 66.08,51.83 66.54,52.29 69.37,52.29 70.31,51.35 v7(70.31,50.24)
  vias: v5(70.31,50.67) v5(70.64,50.36) v5(70.97,50.69) v6(70.4,50.05) v6(70.88,50.04) v6(71,50.3) v7(70.6,50) v7(70.91,50.09) v9(69.67,50.91) v9(69.68,50.34) v9(71.73,50.83)
+VDDD_SUPPLY_3.3V: length 145.9
  TOP w0.356: v2(20.94,91.64) RP91.1
  TOP w0.381: RP93.1 42.35,101.81 42.58,101.58 v2(42.58,99.95)
  IN1 w0.381: 34.89,92.41 34.89,88.8 34.45,88.35 34.45,87.78 34.72,87.51 37.2,87.51 v4(37.93,86.78) ; 34.89,92.41 36.18,93.7 38.8,93.7 40.56,95.46 40.56,97.94 v2(42.58,99.95) ; 34.89,92.41 34.63,92.67 31.8,92.67 31.06,91.93 29.83,91.93 29.46,91.56 28.66,91.56 27.76,90.66 25.96,90.66 25.32,90.01 24.17,90.01 23.59,90.59 21.98,90.59 v2(20.94,91.64)
  GND2 w0.254: v7(35.37,67.16) 35.37,67.44 v5(35.53,67.6) ; v7(35.37,66.23) 35.37,66.57 v5(35.53,66.73)
  GND2 w0.508: v4(37.93,86.78) 37.93,86.59 v5(38.24,86.29)
  IN2 w0.381: v5(35.53,66.73) 35.53,66.54 34.82,65.83 34.82,65.46 35.62,64.66
  IN2 w0.508: 38.71,64.5 38.55,64.66 35.62,64.66 ; 38.71,64.5 39.31,64.5 40.18,65.37 40.18,68.23 36.75,71.66 36.75,72.26 36.62,72.38 36.62,74.71 37.44,75.52 37.44,76 38.17,76.74 40.84,76.74 42.69,78.59 42.69,81.25 40.98,82.96 40.98,84.99 39.68,86.29 v5(38.24,86.29) ; 38.71,64.5 38.72,64.48 38.72,63.03 40.28,61.47 40.28,57.15 41.87,55.57 41.87,55.24 47.16,49.95 47.16,40.93 46.47,40.24 46.47,35.04 46.81,34.7 46.81,33.97 45.87,33.02 45.36,33.02 42.94,30.6 42.94,25.69 43.68,24.95 44.27,24.95 45.65,23.57 47.15,23.57 47.52,23.95 52.75,23.95 53.18,23.52 56.68,23.52 57.51,22.69 58.65,22.69 58.8,22.84 v5(60.89,22.84)
  GND3 w0.254: v6(61.31,22.82) 61.29,22.84 v5(60.89,22.84) ; v5(35.53,66.73) 35.43,66.73 35.22,66.53 v6(35.18,66.53) ; v5(35.53,67.6) 35.53,67.37 35.19,67.03 v6(35.18,67.03)
  BOTTOM w0.305: v6(61.31,22.82) 61.57,22.82 62.36,22.03 JCCG1.1
  vias: v1(31.28,68.12) v7(30.1,68.13) v9(30.53,71.01) v9(31.1,70.98)
+VDDIO_18: length 16.8
  GND1 w0.254: v9(107.22,53.49) 107.22,59.97 107.81,60.55 108.99,60.55 110.5,62.06 110.5,68.16 v2(110.59,68.24)
  vias: v9(107.82,53.47)
+VSS_PLL: length 3.3
  TOP w0.254: UE3.G1 v9(40.22,12.59)
  BOTTOM w0.127: CE47.2 41.88,11.87 v1(41.82,11.81)
  BOTTOM w0.381: CE47.2 41.35,12.82 41.27,12.74 CE48.2 40.71,12.59 v9(40.22,12.59)
DV12S: length 7.9
  TOP w0.203: UR1.14 21.89,68.66 CR17.1 ; UR1.10 23.49,67.67 23.91,68.09 24.23,68.09
  TOP w0.508: v2(24.6,68.73) 24.6,68.46 24.23,68.09 ; CR17.1 21.89,69.49 v7(22.07,69.67)
  IN1 w0.508: v7(22.07,69.67) 23.01,68.73 v2(24.6,68.73)
DV33_18: length 2.2
  TOP w0.203: 18.97,66.04 UR1.18
  TOP w0.508: 18.97,66.04 18.93,66 CR5.1
GND: length 2234.3
  TOP w0.203: v2(17.37,25.75) 17.08,25.46 v2(16.61,25.46) ; v11(67.34,88.7) U14.11
  TOP w0.254: v6(11.69,96.33) v6(11.31,96.33) v6(10.94,96.33) ; RH561.1 v7(108.49,65) ; v6(11.69,101.15) v6(11.31,101.15) v6(10.94,101.15) ; v6(11.31,78.38) v6(11.69,78.38) ; v6(11.31,78.38) v6(10.94,78.38) ; v6(11.31,78.38) v6(11.31,78.02) ; v6(128.27,103.49) v4(127.87,103.89) ; v6(11.31,86.63) v6(10.89,86.63) ; v6(11.31,86.63) v6(11.31,87.01) ; v6(11.31,86.63) v6(11.72,86.63) ; CH104.2 33.32,54.36 v7(33.6,54.08) ; v6(11.69,83.27) v6(11.31,83.27) v6(10.94,83.27) ; UZ24.5 155.37,20.16 v7(154.96,19.75) ; UD5.E1 v4(112.37,99.09) ; 10.2,78.3 v9(9.95,78.56) ; UD2.N1 v14(127.87,105.49) ; PU2200.6 58.04,54.78 v7(58.21,54.95) ; v6(10.89,84.45) v6(11.31,84.45) v6(11.72,84.45) ; v6(11.69,96.99) v6(11.31,96.99) v6(10.94,96.99) ; v6(10.94,79.9) v6(11.31,79.9) v6(11.69,79.9) ; v6(11.69,81.74) v6(11.31,81.74) v6(10.94,81.74) ; v2(17.42,30.71) 17.42,30.98 17.76,31.31 v2(18.45,31.31) ; UD5.N9 v4(106.74,105.52) ; UD1.N9 v4(131.87,105.49) ; UD6.N1 v14(101.98,105.49) ; v6(11.72,85.11) v6(11.31,85.11) v6(10.94,85.11) ; v6(11.69,99.45) v6(11.31,99.45) v6(10.94,99.45) ; UD2.N9 v4(121.47,105.49) ; 10.37,86.73 v9(9.97,86.33) ; v14(112.77,101.89) v4(112.37,101.49) ; v6(11.69,80.6) v6(11.31,80.6) v6(10.94,80.6) ; UD2.T1 v4(127.87,107.89) ; UD1.N1 v14(138.27,105.49) ; 10.09,94.91 v9(9.87,95.13) ; UD5.F1 v4(112.37,99.89) ; v6(112.77,103.49) v4(112.37,103.89) ; UD6.T1 v4(101.98,107.89) ; v14(95.98,105.89) v4(95.58,105.49) ; v6(10.94,100.49) v6(11.31,100.49) v6(11.69,100.49) ; v6(11.31,94.91) v6(11.71,94.91) ; v6(11.31,94.91) v6(10.94,94.91) ; v6(11.31,94.91) v6(11.31,94.57) ; RH608.1 v7(83.63,81.45) ; v6(11.69,98.03) v6(11.31,98.03) v6(10.94,98.03) ; v7(128.01,73.67) 128.11,73.56 PC2272.2 ; UD5.N1 v14(112.37,105.49) ; UD1.T1 v4(138.27,107.89) ; UD5.T1 v4(112.37,107.89)
  TOP w0.305: JUSBC1.A12 9.23,79.77 9.54,79.47 9.54,78.97 v9(9.95,78.56) ; v7(77.44,9.16) 77.33,9.05 JAPS1.8 ; v9(9.9,102.38) 9.9,102.14 9.22,101.47 JUSBC2.A1 ; v9(9.87,95.13) 9.87,95.52 9.41,95.97 JUSBC2.A12 ; RE160.2 v9(39.09,4.1) ; v9(9.97,86.33) 9.62,85.98 9.62,85.57 9.32,85.27 JUSBC1.A1 ; D72.2 v11(146.05,106.58) ; v9(130.27,109.75) CD280.2
  TOP w0.356: v7(34.13,104.84) 34.3,105.01 PR184.2 ; RH620.2 v7(26.55,37.99) ; RP71.2 33.61,70.98 33.6,70.98 v11(33.6,70.99) ; PR147.1 v7(29.64,101.1) ; RP122.2 v7(38.15,65.22)
  TOP w0.381: PC3289.2 48.55,41.61 v11(48.6,41.66) ; v11(41.2,45.46) 41.2,44.7 42.05,43.86 PU78.3
  TOP w0.508: PU101.2 32.2,104.35 v7(32.19,104.34) ; CD348.2 90.42,103.51 v9(90.12,103.21) ; CD328.2 88.48,109.24 v9(88.46,109.23) ; SW3.2 v9(4.79,49.93) ; SW3.1 v9(4.79,51.05) ; PC700.2 11.4,52.03 v7(11.78,52.41) 10.89,53.3 DL1.1 ; PC635.2 126.23,25.32 v9(126.23,23.89) ; v2(27.02,20.01) CE7.2 ; CR13.2 17.29,60.53 v7(17.12,60.36) ; PC1107.2 v9(147.3,34.11) ; v7(69.5,83.78) 69.36,83.64 C3313.2 ; PC1102.2 v9(135.61,40.98) ; CP9.1 34.39,70.81 34.39,71.2 v7(34.9,71.71) ; CD373.2 v9(88.41,108.35) ; CP8.2 v7(31.72,67.21) ; JAPS1.19 v7(71.73,3.99) ; PQ137.3 39.3,95.96 v9(39.19,95.85) ; v9(88.4,105.43) CD349.2 CD341.2 ; JCR1.21 v9(2.69,69.67) ; JAPS1.20 84.43,4.1 v7(84.3,3.97) ; SW1.4 v9(5.13,12.2) ; SW1.5 3.75,20.35 v9(3.25,19.84) ; v11(42.9,37.12) 44.16,38.38 PR2339.2 ; JCR1.18 2.52,66.94 v7(2.56,66.97) ; CD277.2 v9(135.61,94.8) ; RC387.2 v2(27.2,21.16) ; CD344.2 104.26,110.38 v9(103.63,110.38) ; QP4.3 39.61,67.93 v7(39.53,67.85) ; v7(2.54,64.22) 2.52,64.21 JCR1.15 ; CP4.2 34.09,66.23 v7(33.94,66.38) ; C1100.2 37.86,77.39 CT68.2 ; QV9.3 v7(66.71,98.9) ; PC1111.2 v9(135.61,39.71) ; v7(107.9,60.94) 107.88,60.95 CH181.2
  GND1 w0.203: 7.33,101.89 JUSBC2.B12 ; JUSBC2.B12 8.16,101.52 ; JUSBC2.B12 7.7,101.06 ; JUSBC2.B12 8.07,101.15 ; JUSBC2.B12 7.24,101.52 ; JUSBC2.B1 7.7,96.38 ; JUSBC2.B1 7.33,95.55 ; JUSBC2.B1 7.24,95.92 ; JUSBC2.B1 8.07,96.29 ; H5.1 16.34,14.87 ; H5.1 14.28,16.92 ; H5.1 12.22,14.87 ; H5.1 12.77,13.36 ; H5.1 12.77,16.37 ; H5.1 14.28,12.81 ; H5.1 15.79,16.37 ; H5.1 15.79,13.36 ; JUSBC2.3 4.34,104.52 ; JUSBC2.3 3.15,103.82 ; JUSBC2.3 1.96,103.82 ; JUSBC2.3 4.34,103.82 ; JUSBC2.3 3.15,105.22 ; JUSBC2.3 4.34,105.22 ; JUSBC2.3 1.96,105.22 ; JUSBC2.3 1.96,104.52 ; H16.1 152.93,112.11 ; H16.1 150.61,112.11 ; H16.1 151.77,112.51 ; H16.1 151.77,109.39 ; H16.1 153.33,110.95 ; H16.1 152.93,109.79 ; H16.1 150.21,110.95 ; H16.1 150.61,109.79 ; JUSBC1.2 7.38,78.42 ; JUSBC1.2 8.51,77.02 ; JUSBC1.2 7.38,77.02 ; JUSBC1.2 6.24,77.02 ; JUSBC1.2 8.51,77.72 ; 118.29,12.03 BAT100.12 ; BAT100.12 118.96,12.03 ; BAT100.12 117.61,13.98 ; BAT100.12 118.96,13.01 ; BAT100.12 117.61,12.03 ; BAT100.12 118.96,13.98 ; BAT100.12 118.29,13.98 ; JUSBC1.3 4.34,88.32 ; JUSBC1.3 4.34,87.62 ; JUSBC1.3 4.34,89.02 ; JUSBC1.3 1.96,87.62 ; JUSBC1.3 3.15,89.02 ; JUSBC1.3 1.96,88.32 ; JUSBC1.3 3.15,87.62 ; 4.39,72.34 JCR1.23 ; JCR1.23 6.61,70.95 ; JCR1.23 6.61,71.65 ; JCR1.23 4.39,71.65 ; JCR1.23 4.39,70.95 ; JCR1.23 6.61,72.34 ; JCR1.23 5.5,72.34 ; JCR1.23 5.5,70.95 ; JUSBC2.2 8.51,93.22 ; JUSBC2.2 8.51,93.92 ; JUSBC2.2 7.38,94.62 ; JUSBC2.2 6.24,93.22 ; JUSBC2.2 7.38,93.22 ; 1.96,92.92 JUSBC2.4 ; JUSBC2.4 4.34,93.62 ; JUSBC2.4 4.34,92.92 ; JUSBC2.4 4.34,92.22 ; JUSBC2.4 1.96,93.62 ; JUSBC2.4 3.15,92.22 ; JUSBC2.4 3.15,93.62 ; 11.66,3.21 H20.1 ; H20.1 11.66,1.9 ; H20.1 13.76,0.59 ; H20.1 13.76,1.9 ; H20.1 13.76,3.21 ; H20.1 12.71,3.21 ; H20.1 11.66,0.59 ; H20.1 12.71,0.59 ; H6.1 8.66,73.36 ; H6.1 5.94,74.52 ; H6.1 8.66,75.68 ; H6.1 7.5,72.96 ; H6.1 6.34,73.36 ; H6.1 7.5,76.08 ; H6.1 6.34,75.68 ; H6.1 9.06,74.52 ; 4.39,56.55 JCR1.22 ; JCR1.22 6.61,57.25 ; JCR1.22 5.5,56.55 ; JCR1.22 4.39,57.25 ; JCR1.22 6.61,57.94 ; JCR1.22 4.39,57.94 ; JCR1.22 5.5,57.94 ; JCR1.22 6.61,56.55 ; H4.1 152.77,74.02 ; H4.1 152.77,77.04 ; H4.1 151.26,73.47 ; H4.1 153.32,75.53 ; H4.1 151.26,77.59 ; H4.1 149.75,77.04 ; H4.1 149.2,75.53 ; H4.1 149.75,74.02 ; 11.81,109.75 H26.1 ; H26.1 13.61,109.75 ; H26.1 12.71,107.64 ; H26.1 12.71,110.06 ; H26.1 13.92,108.85 ; H26.1 11.81,107.95 ; H26.1 11.5,108.85 ; H26.1 13.61,107.95 ; 133.04,12.03 BAT100.14 ; BAT100.14 132.36,12.03 ; BAT100.14 133.71,13.01 ; BAT100.14 133.71,12.03 ; BAT100.14 132.36,13.01 ; BAT100.14 133.04,13.98 ; BAT100.14 132.36,13.98 ; BAT100.14 133.71,13.98 ; H28.1 154.35,33.35 ; H28.1 151.19,30.19 ; H28.1 154.35,30.19 ; H28.1 152.77,33.93 ; H28.1 150.61,31.77 ; H28.1 151.19,33.35 ; H28.1 152.77,29.61 ; H28.1 154.93,31.77 ; 1.96,76.72 JUSBC1.4 ; JUSBC1.4 4.34,76.72 ; JUSBC1.4 1.96,77.42 ; JUSBC1.4 4.34,76.02 ; JUSBC1.4 4.34,77.42 ; JUSBC1.4 3.15,76.02 ; JUSBC1.4 3.15,77.42 ; JUSBC1.4 1.96,76.02 ; H7.1 8.77,3.13 ; H7.1 8.37,4.29 ; H7.1 5.65,3.13 ; H7.1 6.05,4.29 ; H7.1 7.21,4.69 ; H7.1 6.05,1.97 ; H7.1 8.37,1.97 ; H7.1 7.21,1.57 ; H1.1 9.06,106.72 ; H1.1 7.5,108.28 ; H1.1 8.66,105.56 ; H1.1 8.66,107.88 ; H1.1 6.34,105.56 ; H1.1 7.5,105.16 ; H1.1 5.94,106.72 ; H1.1 6.34,107.88 ; H27.1 71.57,97.68 ; H27.1 70.05,97.68 ; H27.1 69.81,98.44 ; H27.1 71.57,99.2 ; H27.1 70.81,99.44 ; H27.1 70.81,97.44 ; H27.1 71.81,98.44 ; H27.1 70.05,99.2 ; H3.1 8.12,90.62 ; H3.1 7.72,89.46 ; H3.1 5,90.62 ; H3.1 6.56,89.06 ; H3.1 5.4,91.78 ; H3.1 7.72,91.78 ; H3.1 5.4,89.46 ; H3.1 6.56,92.18 ; 7.38,86.62 JUSBC1.1 ; JUSBC1.1 6.24,88.02 ; JUSBC1.1 8.51,87.32 ; JUSBC1.1 7.38,88.02 ; JUSBC1.1 8.51,88.02 ; JUSBC2.1 7.38,104.22 ; JUSBC2.1 8.51,103.52 ; JUSBC2.1 7.38,102.82 ; JUSBC2.1 8.51,104.22 ; JUSBC2.1 6.24,104.22 ; 117.61,16.48 BAT100.11 ; BAT100.11 118.96,17.46 ; BAT100.11 117.61,17.46 ; BAT100.11 117.61,15.5 ; BAT100.11 118.29,17.46 ; BAT100.11 118.29,15.5 ; BAT100.11 118.96,16.48 ; BAT100.11 118.96,15.5 ; JUSBC1.B1 7.7,80.18 ; JUSBC1.B1 7.33,79.35 ; JUSBC1.B1 8.07,80.09 ; JUSBC1.B1 7.24,79.72 ; BAT100.13 133.04,17.46 ; BAT100.13 132.36,15.5 ; BAT100.13 132.36,16.48 ; BAT100.13 133.71,17.46 ; BAT100.13 133.71,15.5 ; BAT100.13 133.71,16.48 ; BAT100.13 132.36,17.46 ; BAT100.13 133.04,15.5 ; 7.7,84.86 JUSBC1.B12 ; JUSBC1.B12 8.16,85.32 ; JUSBC1.B12 8.07,84.95 ; JUSBC1.B12 7.33,85.69 ; JUSBC1.B12 7.24,85.32
  GND2 w0.102: 50.01,13.49 50.26,13.49 50.35,13.4 50.35,13.39 ; 42.26,46.97 42.26,46.73 v5(42.34,46.65) ; v17(82.88,16.53) v5(82.88,16.9)
  GND2 w0.107: v6(42.75,40.81) 42.75,41.11 v5(42.85,41.2) ; v6(35.16,47.91) v5(34.93,48.14) ; v6(39.03,45.58) v5(38.8,45.82) ; v5(31.39,54.59) v6(31.62,54.35) ; v5(35.81,51.72) v14(36.04,51.49) ; v6(33.76,42.04) 33.54,42.26 33.49,42.26 v5(33.46,42.23) ; v5(40.84,45.93) v6(41.07,45.69) ; v5(34.67,50.99) 34.82,50.84 v17(34.82,50.68) ; v6(29.77,53.07) 29.65,53.19 v5(29.37,53.19) ; v5(38.83,51.14) v6(38.48,51.49) ; v14(37.48,45.58) v5(37.25,45.82) ; v5(37.52,56.27) v6(37.76,56.04) ; v5(29.81,40.28) v6(30.05,40.05) ; v5(43.89,45.93) v6(44.12,45.69) ; v5(38.24,37.17) v6(38.47,36.94) ; v5(42.05,56.29) v17(42.3,56.04) ; v5(33.49,50.43) v14(33.76,50.17) ; v14(37.48,44.04) v5(37.25,44.27) ; v5(109.83,17.13) v6(110.06,16.9) ; v6(38.26,45.58) v5(38.02,45.82) ; v5(31.35,45.93) v6(31.58,45.69) ; v14(35.93,44.04) v5(35.7,44.27) ; v5(39.43,42.23) v6(39.66,41.99) ; v5(38.73,47.4) 38.76,47.4 v6(39.03,47.13) ; v5(44.88,56.98) 44.88,56.94 v6(45.16,56.66) ; v5(37.14,39.94) v6(37.38,39.71) ; v5(33.38,49.69) v6(33.61,49.46) ; v5(31.42,37.17) v6(31.65,36.94) ; v5(30.88,36.91) v6(31.11,36.68) ; v6(34.38,47.91) v5(34.15,48.14) ; v5(41.56,37.84) v6(41.8,37.6) ; 32.11,47.26 v14(32.34,47.03) ; v5(43.47,55.56) 43.47,56.05 v17(42.97,56.55) ; v5(31.49,40.09) v6(31.72,39.86) ; v5(32.38,50.93) v6(32.61,50.7) ; v5(44.71,38.95) v6(44.95,38.71) ; v5(38.77,57.3) 38.77,57.34 38.98,57.55 v17(39.08,57.55) ; v5(43.89,48.37) v17(44.12,48.13) ; v6(33.61,47.91) v5(33.38,48.14) ; v5(30.29,37.71) v6(30.53,37.47) ; v5(39.57,48.92) v6(39.81,48.68) ; 29.06,47.26 v6(29.3,47.03) ; v5(41.31,55.3) 41.71,55.3 v6(41.87,55.14) ; v6(39.66,51.39) 39.47,51.58 v5(39.34,51.58) ; v14(34.38,44.04) v5(34.15,44.27) ; v6(39.03,44.81) v5(38.8,45.04) ; v5(35.81,50.96) v6(36.04,50.72) ; v6(34.38,46.36) 34.54,46.52 v5(34.54,46.72) ; v5(34.88,49.74) v6(35.16,49.46) ; v6(37.38,53.77) 37.15,53.54 v5(37.15,53.47) ; v5(30.44,38.59) v6(30.67,38.36) ; v6(33.21,56.04) 33.21,56.08 v5(32.98,56.31) ; v5(31.22,51.12) v6(30.96,51.39) ; v5(28.4,53.6) 28.64,53.35 v6(28.77,53.35) ; v14(34.94,50.17) 34.73,50.17 v5(34.6,50.3) ; v5(39.36,50.97) v6(39.66,50.67) ; v5(41.6,44.82) v17(41.84,44.59) ; v6(35.93,47.13) v5(35.7,47.37) ; v5(42.25,36.91) v6(42.48,36.68) ; v14(37.48,44.81) v5(37.25,45.04) ; v5(37.14,40.7) v6(37.38,40.47) ; v5(28.83,38.36) v6(29.06,38.12) ; v5(39.57,49.69) v6(39.81,49.46) ; v5(31.44,38.57) 31.09,38.57 v17(31.09,38.56) ; v5(26.79,40.82) v6(27.03,40.59) ; v6(46.17,57.17) 46.07,57.27 v5(46.07,57.67) ; v5(43.89,44.82) v6(44.12,44.59) ; v17(111.06,14.9) 111.06,15.21 v5(111.12,15.27) ; v5(40.13,39.54) v6(40.36,39.3) ; v6(34.38,43.26) v5(34.15,43.49) ; v6(33.76,42.55) v5(33.52,42.79) ; v6(38.26,47.91) v5(38.02,48.14) ; v5(33.15,36.91) v17(33.39,36.68) ; v5(43.57,37.56) v6(43.8,37.32) ; v5(44.1,36.81) v17(44.33,37.04) ; v5(39.97,36.91) v6(40.21,36.68) ; v6(36.71,44.81) v5(36.47,45.04) ; v5(34.68,54.03) v6(34.94,53.77) ; v5(32.67,47.26) v6(32.9,47.03) ; v5(29.76,39.66) v14(30,39.42) ; v5(42.54,39.2) v6(42.78,38.96) ; v5(39.43,39.94) v6(39.66,39.71) ; v17(28.79,41.2) v5(28.48,41.51) ; v5(43.67,46.9) 43.79,47.03 ; v6(38.26,48.68) v5(38.02,48.92) ; v6(39.81,44.04) v5(39.57,44.27) ; v5(39.43,39.18) v6(39.66,38.95) ; v5(31.49,39.33) v6(31.72,39.1) ; v6(32.61,53.75) 32.51,53.75 v5(32.31,53.96) ; v5(30.13,53.29) v6(30.4,53.02) ; v5(42.79,37.17) 42.69,37.17 v17(42.48,37.38) ; v5(43.89,49.55) v17(44.12,49.31) ; v5(26.79,45.37) 27,45.16 v17(27,45.04) ; v5(38.25,39.18) v6(38.48,38.95) ; v6(33.61,48.68) v5(33.38,48.92) ; v5(32.11,43.64) v6(32.34,43.41) ; v5(32.67,44.82) v17(32.9,44.59) ; v5(29.48,38.66) v17(29.79,38.35) ; v5(43.56,40.52) v6(43.79,40.28) ; v6(38.26,44.04) v5(38.02,44.27) ; v5(37.7,36.91) v6(37.93,36.68) ; v14(33.61,44.04) v5(33.38,44.27) ; v6(34.38,47.13) v5(34.15,47.37) ; 28.62,48.88 v17(28.62,48.9) ; v5(32.67,43.64) v6(32.9,43.41) ; v17(33.82,53.42) 33.65,53.42 v5(33.5,53.27) ; v5(39.57,43.49) v6(39.81,43.26) ; v5(42.79,39.93) v6(43.02,39.7) ; v5(28.3,44.82) v6(28.53,44.59) ; v5(37.14,42.79) v6(37.38,42.55) ; v5(32.11,44.82) 32.11,45.1 v17(32.18,45.17) ; v6(33.61,43.26) v5(33.38,43.49) ; v5(26.79,43.09) v6(27.03,42.86) ; v5(32.11,48.37) v14(32.34,48.13) ; v5(40.57,42.25) v6(40.8,42.02) ; v17(36.04,41.99) 35.81,42.22 v5(35.75,42.22) ; v5(37.96,49.75) v6(38.26,49.46) ; v14(36.71,45.58) v5(36.47,45.82) ; v6(35.16,47.13) v5(34.93,47.37) ; v6(35.93,48.68) v5(35.7,48.92) ; v17(32.67,51.44) 32.85,51.26 v5(32.95,51.26) ; v5(38.17,51.04) v6(38.48,50.72) ; v5(26.79,52.19) v6(27.03,51.95) ; v6(37.48,47.13) v5(37.25,47.37) ; v5(28.4,49.55) 28.67,49.27 ; v6(36.71,47.13) v5(36.47,47.37) ; v5(33.52,40.04) v14(33.76,39.81) ; v5(35.25,56.27) v17(35.48,56.04) ; v5(35.78,53.27) v6(36.04,53.01) ; v5(28.24,54.24) v6(28.47,54) ; v5(32.4,40.04) v6(32.64,39.81) ; v5(37.09,51.01) v6(37.38,50.72) ; v5(44.65,56) 44.85,55.79 v6(44.91,55.79) ; v5(43.39,36.87) v6(43.62,36.63) ; v5(30.44,52.14) v6(30.67,51.91) ; v5(37.14,39.18) v6(37.38,38.95) ; v5(29.06,43.64) v6(29.3,43.41) ; v5(40.57,39.97) v6(40.8,39.73) ; v6(39.03,44.04) v5(38.8,44.27) ; v5(30.7,56.27) v6(30.94,56.04) ; v5(109.83,14.13) v17(110.06,13.9) ; v5(38.8,49.69) v6(39.03,49.46) ; v5(43.62,38.6) v6(43.85,38.37) ; v6(34.38,48.68) v5(34.15,48.92) ; v14(36.71,44.04) v5(36.47,44.27) ; v5(31.35,48.37) v6(31.58,48.13) ; v5(39.43,40.7) v14(39.66,40.47) ; v5(30.4,39.51) v6(30.63,39.28) ; v5(32.67,49.55) v6(32.9,49.31) ; v5(40.28,45.93) v6(40.52,45.69) ; v5(37.2,49.74) v6(37.48,49.46) ; v5(29.16,50.66) v6(29.4,50.43) ; v5(35.81,39.18) v6(36.04,38.95) ; v5(41.56,40.12) v14(41.8,39.89) ; v5(36.43,49.74) v6(36.71,49.46) ; v6(39.66,50.17) 39.6,50.17 v5(39.29,50.48) ; v5(39.43,42.79) v6(39.66,42.55) ; v5(28.48,39.45) v6(28.72,39.22) ; v5(39.39,53.94) v6(39.66,53.67) ; v5(41.39,37.31) v17(41.74,36.96) ; v5(34.15,49.69) v6(34.38,49.46) ; v5(34.7,51.72) v14(34.94,51.49) ; v5(38.2,50.45) v6(38.48,50.17) ; v5(44.41,39.6) v17(44.64,39.36) ; v6(39.03,46.36) v5(38.8,46.59) ; v5(35.65,49.74) v6(35.93,49.46) ; v6(35.16,48.68) v5(34.93,48.92) ; v6(38.26,44.81) v5(38.02,45.04) ; v5(29.21,51.58) v6(29.45,51.34) ; v6(34.38,44.81) v5(34.15,45.04) ; v6(35.93,44.81) v5(35.7,45.04) ; v5(32.41,37.19) v6(32.64,36.96) ; v5(40.54,53.43) v6(40.78,53.67) ; v5(38.2,54.05) v6(38.48,53.77) ; v5(29.85,42.5) v6(30.08,42.26) ; v5(30.92,40.55) v6(31.16,40.32) ; v5(43.79,43.64) v6(44.02,43.41) ; v5(29.39,52.67) v6(29.63,52.44) ; v17(41.26,57.55) v5(41.03,57.79) ; v5(35.81,40.7) v14(36.04,40.47) ; v5(43.41,39.88) v6(43.65,39.65) ; v6(37.48,43.26) v5(37.25,43.49) ; v6(38.26,43.26) v5(38.02,43.49) ; v5(43.13,48.37) v6(43.36,48.13) ; v5(33.49,50.99) v6(33.76,50.72) ; v5(40.28,49.55) v6(40.52,49.31) ; v5(37.14,42.23) v6(37.38,41.99) ; v6(32.17,57.55) v5(31.93,57.79)
  GND2 w0.127: v17(46.31,55.49) 46.32,55.5 v5(46.32,55.92) ; v5(46.76,54.76) v17(46.33,54.76) ; v17(29.7,54.48) 29.39,54.48 v5(29.28,54.58) ; v6(35.16,46.36) 35.16,46.58 v5(35.04,46.7) ; v17(46.24,56.39) 46.34,56.29 v5(46.64,56.29) ; v17(43.05,55.76) 43,55.76 v5(42.77,55.99)
  GND2 w0.152: v5(27.16,49.93) 27.16,49.9 v17(27.39,49.68)
  GND2 w0.203: 4.39,71.65 JCR1.23 ; JCR1.23 6.61,70.95 ; JCR1.23 4.39,70.95 ; JCR1.23 5.5,72.34 ; JCR1.23 4.39,72.34 ; JCR1.23 6.61,72.34 ; JCR1.23 6.61,71.65 ; JCR1.23 5.5,70.95 ; 6.24,77.02 JUSBC1.2 ; JUSBC1.2 7.38,77.02 ; JUSBC1.2 8.51,77.72 ; JUSBC1.2 7.38,78.42 ; JUSBC1.2 8.51,77.02 ; BAT100.11 118.96,15.5 ; BAT100.11 117.61,16.48 ; BAT100.11 118.29,17.46 ; BAT100.11 118.29,15.5 ; BAT100.11 118.96,17.46 ; BAT100.11 117.61,17.46 ; BAT100.11 118.96,16.48 ; BAT100.11 117.61,15.5 ; H16.1 153.33,110.95 ; H16.1 150.61,109.79 ; H16.1 152.93,112.11 ; H16.1 151.77,109.39 ; H16.1 151.77,112.51 ; H16.1 150.61,112.11 ; H16.1 152.93,109.79 ; H16.1 150.21,110.95 ; H26.1 13.61,107.95 ; H26.1 13.92,108.85 ; H26.1 11.81,107.95 ; H26.1 13.61,109.75 ; H26.1 11.5,108.85 ; H26.1 12.71,107.64 ; H26.1 11.81,109.75 ; H26.1 12.71,110.06 ; 149.75,77.04 H4.1 ; H4.1 152.77,77.04 ; H4.1 151.26,77.59 ; H4.1 151.26,73.47 ; H4.1 152.77,74.02 ; H4.1 149.2,75.53 ; H4.1 153.32,75.53 ; H4.1 149.75,74.02 ; v7(112.85,48.88) 112.98,48.75 v5(112.98,48.52) ; 132.36,16.48 BAT100.13 ; BAT100.13 133.71,15.5 ; BAT100.13 132.36,17.46 ; BAT100.13 133.71,17.46 ; BAT100.13 133.04,15.5 ; BAT100.13 133.71,16.48 ; BAT100.13 133.04,17.46 ; BAT100.13 132.36,15.5 ; 1.96,104.52 JUSBC2.3 ; JUSBC2.3 1.96,105.22 ; JUSBC2.3 3.15,103.82 ; JUSBC2.3 4.34,104.52 ; JUSBC2.3 4.34,105.22 ; JUSBC2.3 3.15,105.22 ; JUSBC2.3 1.96,103.82 ; JUSBC2.3 4.34,103.82 ; 11.66,1.9 H20.1 ; H20.1 11.66,0.59 ; H20.1 13.76,3.21 ; H20.1 11.66,3.21 ; H20.1 13.76,0.59 ; H20.1 12.71,3.21 ; H20.1 13.76,1.9 ; H20.1 12.71,0.59 ; v5(113.97,46.23) 113.97,46.46 v7(113.84,46.59) ; 4.39,57.25 JCR1.22 ; JCR1.22 6.61,56.55 ; JCR1.22 6.61,57.25 ; JCR1.22 4.39,56.55 ; JCR1.22 6.61,57.94 ; JCR1.22 5.5,56.55 ; JCR1.22 5.5,57.94 ; JCR1.22 4.39,57.94 ; v5(112.98,46.23) 112.98,46.46 v7(112.85,46.59) ; 6.34,73.36 H6.1 ; H6.1 8.66,73.36 ; H6.1 6.34,75.68 ; H6.1 5.94,74.52 ; H6.1 9.06,74.52 ; H6.1 7.5,76.08 ; H6.1 8.66,75.68 ; H6.1 7.5,72.96 ; 1.96,87.62 JUSBC1.3 ; JUSBC1.3 4.34,87.62 ; JUSBC1.3 3.15,89.02 ; JUSBC1.3 4.34,88.32 ; JUSBC1.3 3.15,87.62 ; JUSBC1.3 4.34,89.02 ; JUSBC1.3 1.96,88.32 ; JUSBC1.1 8.51,88.02 ; JUSBC1.1 8.51,87.32 ; JUSBC1.1 7.38,86.62 ; JUSBC1.1 6.24,88.02 ; JUSBC1.1 7.38,88.02 ; JUSBC2.4 4.34,93.62 ; JUSBC2.4 1.96,92.92 ; JUSBC2.4 4.34,92.92 ; JUSBC2.4 3.15,93.62 ; JUSBC2.4 3.15,92.22 ; JUSBC2.4 4.34,92.22 ; JUSBC2.4 1.96,93.62 ; 7.21,1.57 H7.1 ; H7.1 6.05,1.97 ; H7.1 8.37,4.29 ; H7.1 8.77,3.13 ; H7.1 7.21,4.69 ; H7.1 5.65,3.13 ; H7.1 8.37,1.97 ; H7.1 6.05,4.29 ; H3.1 8.12,90.62 ; H3.1 7.72,91.78 ; H3.1 5.4,89.46 ; H3.1 5,90.62 ; H3.1 7.72,89.46 ; H3.1 6.56,89.06 ; H3.1 5.4,91.78 ; H3.1 6.56,92.18 ; 7.24,95.92 JUSBC2.B1 ; JUSBC2.B1 8.07,96.29 ; JUSBC2.B1 7.7,96.38 ; JUSBC2.B1 7.33,95.55 ; H1.1 9.06,106.72 ; H1.1 6.34,105.56 ; H1.1 8.66,107.88 ; H1.1 7.5,108.28 ; H1.1 7.5,105.16 ; H1.1 5.94,106.72 ; H1.1 6.34,107.88 ; H1.1 8.66,105.56 ; H5.1 15.79,16.37 ; H5.1 12.22,14.87 ; H5.1 12.77,13.36 ; H5.1 14.28,16.92 ; H5.1 16.34,14.87 ; H5.1 14.28,12.81 ; H5.1 12.77,16.37 ; H5.1 15.79,13.36 ; BAT100.12 118.29,13.98 ; BAT100.12 118.96,12.03 ; BAT100.12 117.61,13.98 ; BAT100.12 118.29,12.03 ; BAT100.12 118.96,13.98 ; BAT100.12 118.96,13.01 ; BAT100.12 117.61,12.03 ; v7(112.85,47.73) 112.98,47.61 v5(112.98,47.38) ; JUSBC2.2 8.51,93.22 ; JUSBC2.2 7.38,94.62 ; JUSBC2.2 6.24,93.22 ; JUSBC2.2 8.51,93.92 ; JUSBC2.2 7.38,93.22 ; v7(113.84,47.73) 113.97,47.61 v5(113.97,47.38) ; 70.81,97.44 H27.1 ; H27.1 71.57,99.2 ; H27.1 70.05,99.2 ; H27.1 70.05,97.68 ; H27.1 69.81,98.44 ; H27.1 70.81,99.44 ; H27.1 71.57,97.68 ; H27.1 71.81,98.44 ; 151.19,33.35 H28.1 ; H28.1 151.19,30.19 ; H28.1 154.35,30.19 ; H28.1 154.93,31.77 ; H28.1 152.77,33.93 ; H28.1 150.61,31.77 ; H28.1 154.35,33.35 ; H28.1 152.77,29.61 ; JUSBC1.B12 8.16,85.32 ; JUSBC1.B12 7.33,85.69 ; JUSBC1.B12 8.07,84.95 ; JUSBC1.B12 7.7,84.86 ; JUSBC1.B12 7.24,85.32 ; 7.33,101.89 JUSBC2.B12 ; JUSBC2.B12 7.24,101.52 ; JUSBC2.B12 8.07,101.15 ; JUSBC2.B12 7.7,101.06 ; JUSBC2.B12 8.16,101.52 ; v7(113.84,48.88) 113.97,48.75 v5(113.97,48.52) ; 132.36,13.01 BAT100.14 ; BAT100.14 133.71,12.03 ; BAT100.14 132.36,13.98 ; BAT100.14 133.04,12.03 ; BAT100.14 133.04,13.98 ; BAT100.14 132.36,12.03 ; BAT100.14 133.71,13.01 ; BAT100.14 133.71,13.98 ; 3.15,76.02 JUSBC1.4 ; JUSBC1.4 1.96,77.42 ; JUSBC1.4 4.34,76.72 ; JUSBC1.4 1.96,76.02 ; JUSBC1.4 4.34,76.02 ; JUSBC1.4 3.15,77.42 ; JUSBC1.4 1.96,76.72 ; JUSBC1.4 4.34,77.42 ; JUSBC2.1 8.51,104.22 ; JUSBC2.1 8.51,103.52 ; JUSBC2.1 7.38,104.22 ; JUSBC2.1 6.24,104.22 ; JUSBC2.1 7.38,102.82 ; 7.33,79.35 JUSBC1.B1 ; JUSBC1.B1 8.07,80.09 ; JUSBC1.B1 7.24,79.72 ; JUSBC1.B1 7.7,80.18
  GND2 w0.229: v5(86.94,83.4) v6(87.17,83.17)
  GND2 w0.254: v5(74.67,52.05) v14(74.44,51.81) ; v7(99.63,76.28) v5(99.27,76.28) v7(98.94,76.28) ; v5(124.79,86.66) v17(124.55,86.42) ; v5(90.9,59.97) v6(91.23,59.89) ; v7(102.09,75.63) 101.79,75.63 v5(101.76,75.66) 101.74,75.63 v7(101.43,75.63) ; v7(80.93,72.79) 81.12,72.79 v5(81.25,72.66) ; v5(112.68,84.05) v14(112.45,83.82) ; v5(131.67,64.55) v6(131.75,64.22) ; v15(98.21,66.25) v5(98.54,66.25) ; v5(124.15,79.49) v14(123.69,79.26) ; v13(97.26,48.02) v5(97.03,48.26) ; v5(129.88,67.7) v6(129.8,67.37) ; v7(123.73,66.5) v5(123.4,66.5) ; v5(124.79,83.4) v17(124.55,83.17) ; v15(98.21,67.65) v5(98.54,67.65) ; v5(126.67,78.19) v14(126.44,77.96) ; v5(108.09,59.17) v6(107.76,59.24) ; v7(127.23,69.09) v5(127.23,68.76) ; v13(97.26,46.06) v5(97.49,46.29) ; v5(106.76,83.4) v17(106.48,83.12) ; v7(119.94,74.5) v5(120.32,74.5) ; v7(89.54,69.76) v5(89.87,69.76) ; v5(107.92,80.14) v14(108.15,79.91) ; v5(84.58,86.66) v6(84.81,86.42) ; v14(115.85,83.17) v5(116.08,83.5) v14(115.85,83.82) ; v7(89.54,68.76) v5(89.87,68.76) ; v5(122.27,85.35) v17(122.04,85.12) ; v5(90.9,59.17) v6(91.23,59.24) ; v7(112.43,65.49) 112.21,65.49 v5(112.09,65.61) ; v13(97.26,47.33) v5(97.49,47.56) ; v5(120.22,86.01) v14(119.99,85.77) ; v5(85.39,82.74) v6(85.62,82.51) ; v5(116.61,80.14) v14(116.38,79.91) ; v7(94.32,72.19) v5(94.65,72.19) ; v7(123.33,77.04) v5(123.33,76.71) ; v5(111.13,79.49) v14(110.89,79.26) ; v8(94.33,64.85) v5(94.66,64.85) ; v7(94.32,71.8) v5(93.97,71.8) ; v5(78.96,78.19) v6(79.19,77.96) ; v8(94.33,67.65) v5(94.66,67.65) ; v5(88.62,86.66) v17(88.9,86.47) ; v5(96.05,82.74) v14(96.29,82.51) ; v5(120.27,79.49) v14(120.04,79.26) ; v5(117.53,78.84) v14(117.29,78.61) ; v7(116.25,74.5) v5(116.63,74.5) ; v5(83.53,77.54) v6(83.77,77.31) ; v8(102.33,66.25) v5(102.66,66.25) ; v7(31.91,88.47) v5(32.18,88.74) ; v5(90.08,81.44) v6(90.32,81.21) ; v5(129.87,47.2) v7(130.08,46.95) ; v5(120.69,64.42) v6(120.36,64.5) ; v5(103.07,63.96) 103.29,63.75 v7(103.29,63.7) ; v5(118.17,87.1) 118.4,87.34 ; v5(81.25,68.47) 81.12,68.34 v7(80.93,68.34) ; v5(114.78,79.49) v14(114.55,79.26) ; v5(77.64,84.6) v6(77.87,84.36) ; v5(123.05,56.57) v6(122.72,56.64) ; v5(92.07,79.49) v6(92.3,79.26) ; v5(128.41,47.2) v7(128.62,46.95) ; v5(130.13,84.13) v14(129.9,83.9) ; v7(102.35,73.48) v5(102.68,73.48) ; v5(83,86.66) v14(83.24,86.42) ; v7(98.22,73.48) v5(98.55,73.48) ; v5(108.09,59.97) v6(107.76,59.89) ; v5(112.04,79.49) 112.04,79.1 v17(112.06,79.08) ; v5(119.36,79.49) v14(119.12,79.26) ; v5(105.14,84.7) v17(105.37,84.94) ; v7(112.32,71.43) 112.32,71.43 v5(112.08,71.66) ; v5(123.05,57.37) v6(122.72,57.29) ; v17(86.69,81.41) 86.31,81.41 v5(86.27,81.44) ; v5(110.21,78.09) v14(109.98,77.86) ; v15(90.15,67.27) v5(89.82,67.27) ; v5(85.36,77.54) v6(85.59,77.31) ; v5(111.4,73.87) 111.11,73.58 ; v5(96.41,56.57) v6(96.74,56.64) ; v5(76.34,80.76) v6(76.57,80.53) ; v5(132.48,66.92) v6(132.4,66.58) ; v5(130.06,85.69) v14(129.82,85.46) ; v5(129.07,66.13) v6(129.15,65.8) ; v7(98.23,74.43) v5(97.88,74.43) ; v8(94.33,63.46) v5(94.66,63.46) ; v5(111.32,82.94) v14(111.56,83.17) ; v5(78.96,80.79) v6(79.19,80.56) ; v6(94.28,81.21) 93.95,81.21 v5(93.85,81.11) ; v5(78.96,77.54) v6(79.19,77.31) ; v5(92.98,77.54) v6(93.21,77.31) ; v5(95.62,59.97) v6(95.95,59.89) ; v7(139.48,67.01) v5(139.86,67.01) ; v7(96.89,73.09) v5(96.54,73.09) ; v7(138.73,54.44) v5(139.11,54.44) ; v5(111.24,57.37) v6(110.91,57.29) ; v5(34.26,57.99) 34.26,57.73 v17(34.44,57.55) ; v4(95.32,61.83) 95.19,61.91 v5(94.85,61.81) ; v5(79.9,82.74) v6(80.13,82.51) ; v5(118.33,65.22) v6(118,65.15) ; v5(128.41,48.02) v7(128.62,47.77) ; v5(120.69,65.22) v6(120.36,65.15) ; v5(111.24,65.22) v6(110.91,65.15) ; v5(110.21,78.84) v14(109.98,78.61) ; v7(107.35,66.95) v5(107.02,66.95) ; v7(85.25,66.38) v5(85.58,66.38) ; v5(81.25,76.73) 81.12,76.6 v7(80.93,76.6) ; v15(86.42,76.28) v5(86.09,76.28) ; v5(102.62,86.66) v17(102.86,86.89) ; v7(113.43,75.52) v5(113.81,75.52) ; v7(106.96,71.9) v5(106.63,71.9) ; v5(95.4,86.16) 95.42,86.16 v6(95.68,86.42) ; v7(102.34,71.77) v5(101.99,71.77) ; v5(84.45,81.44) v6(84.68,81.21) ; v15(98.21,63.07) v5(97.88,63.07) ; v5(119.36,82.09) v14(119.12,81.86) ; v5(106.16,5.89) 106.25,5.98 v7(106.25,6.24) ; v7(80.93,76.22) 81.12,76.22 v5(81.25,76.09) ; v5(125.6,49.92) v14(125.37,49.69) ; v5(110.45,59.17) v6(110.12,59.24) ; v7(85.3,72.3) v5(84.95,72.3) ; v5(88.53,59.97) v6(88.86,59.89) ; v5(75.33,50.54) v14(75.09,50.31) ; v15(82.86,75.01) v5(82.53,75.01) ; v5(77.9,86.66) v6(78.14,86.42) ; v5(96.94,81.44) v14(97.18,81.21) ; v7(102.42,69.75) 102.39,69.73 v5(101.97,69.73) 101.96,69.74 v7(101.52,69.74) ; v5(126.99,59.17) v6(126.66,59.24) ; v7(125.26,75.01) v5(124.93,75.01) ; v5(90.08,79.49) v6(90.32,79.26) ; v5(79.85,72.15) 79.98,72.03 v7(79.98,71.84) ; v5(129.38,78.63) v14(129.15,78.4) ; v14(109.04,83.17) 109.04,83.26 v5(108.84,83.47) ; v5(132.63,80.99) v14(132.4,80.76) ; v6(95.16,62.55) v5(94.79,62.5) ; v7(90.51,70.71) v5(90.84,70.71) ; v17(90.94,84.45) 90.69,84.7 v5(90.55,84.7) ; v5(125.42,56.57) v6(125.09,56.64) ; v7(89.19,71.75) v5(88.84,71.75) ; v17(130.27,82.01) 129.94,81.91 v5(129.92,81.87) ; v5(86.81,78.43) v7(86.81,78.77) ; v8(96.87,65.87) v5(96.54,65.87) ; v5(100.38,79.49) 100.67,79.2 v7(100.75,79.2) ; v5(93.26,59.17) v6(93.59,59.24) ; v7(112.43,66.88) v5(112.1,66.88) ; v5(89.4,67.84) 89.38,67.86 v7(89.07,67.86) ; v7(109.13,46.95) v5(108.75,46.95) ; v5(99.69,82.74) 99.88,82.55 v17(99.88,82.44) ; v5(81.43,86.66) v6(81.66,86.42) ; v7(128.05,50.76) v5(128.43,50.76) ; v5(105.14,86.66) v17(105.37,86.89) ; v5(81.25,73.3) 81.12,73.17 v7(80.93,73.17) ; v7(94.23,69.7) 94.21,69.69 v5(93.77,69.69) 93.73,69.73 v7(93.3,69.73) ; v7(31.02,88.49) v5(31.29,88.75) ; v5(79.07,85.35) v6(79.3,85.12) ; 85.24,63.07 v5(85.57,63.07) ; v5(86.27,80.79) v17(86.51,80.56) ; v5(100.35,59.97) v6(100.68,59.89) ; v5(127.59,80.14) v14(127.35,79.91) ; v5(127.77,84.05) v14(127.53,83.82) ; v7(97.07,70.74) v5(97.4,70.74) ; v13(97.26,46.69) v5(97.03,46.92) ; v5(125.6,50.71) v14(125.37,50.48) ; v5(96.03,79.49) v14(96.26,79.26) ; v5(97.98,59.17) v6(98.31,59.24) ; v6(77.19,85.42) 77.19,85.02 v5(77.16,84.99) ; v5(99.69,81.44) v14(99.92,81.21) ; v5(110.21,79.49) v14(109.98,79.26) ; v7(139.48,58.12) v5(139.86,58.12) ; v5(107.65,85.35) v17(107.88,85.12) ; v8(94.33,64.47) v5(94,64.47) ; 103.29,79.41 v5(103.27,79.46) ; v5(129.87,48.79) v7(130.08,48.53) ; v5(130.03,82.57) v14(129.8,82.33) ; v5(96.97,82.74) v14(97.2,82.51) ; v7(101.43,76.27) 101.76,76.27 v5(101.76,76.27) 101.76,76.27 v7(102.09,76.27) ; v7(91.96,75.65) v5(91.63,75.65) ; v5(126.39,50.71) v14(126.16,50.48) ; v7(117.26,66.5) v5(116.93,66.5) ; v5(119.9,59.17) v6(119.57,59.24) ; v7(98.03,45.56) 98.27,45.32 v5(98.27,45.12) ; v7(117.19,63.84) 117.04,63.93 v5(116.99,64.12) ; v5(131.98,82.57) v14(131.75,82.33) ; v5(86.96,57.37) v6(87.29,57.29) ; v8(94.33,63.07) v5(94,63.07) ; v7(102.33,74.79) v5(102.66,74.79) ; v7(121.19,66.5) v5(120.81,66.5) ; v15(82.9,72.92) v5(83.23,72.92) ; v5(115.19,86.01) v14(114.96,85.77) ; v7(120.93,74.5) v5(121.31,74.5) ; v5(82.62,79.49) v6(82.85,79.26) ; v5(108.09,56.57) v6(107.76,56.64) ; v5(83.79,83.4) v6(84.02,83.17) ; v5(76.39,85.33) v6(76.63,85.1) ; v7(115.12,77.04) v5(114.74,77.04) ; v7(98.19,70.76) v5(98.52,70.76) ; v5(85.36,85.35) v6(85.6,85.12) ; v5(43.91,54.41) 43.83,54.5 v17(43.43,54.5) ; v5(108.31,83.5) v14(108.31,83.17) ; v5(78.97,71.27) 79.19,71.49 v7(79.28,71.49) ; v7(80.93,74.06) 81.12,74.06 v5(81.25,73.93) ; v5(118.6,83.4) v14(118.36,83.17) ; v14(102.66,81.21) v5(102.43,81.54) v14(102.66,81.86) ; v7(117.12,75.52) v5(117.5,75.52) ; v5(100.11,86.01) v14(99.87,85.77) ; v5(124.84,81.44) v14(124.61,81.21) ; v5(108.1,64.94) 108.16,65 v7(108.49,65) ; v5(88.1,77.54) v6(88.34,77.31) ; v17(90.94,85.1) 90.69,85.35 v5(90.55,85.35) ; v7(94.26,74.8) v5(94.59,74.8) ; v7(117.26,67.9) v5(116.93,67.9) ; v5(121.18,79.49) v14(120.95,79.26) ; v5(113.6,57.37) v6(113.27,57.29) ; v7(127.23,73.69) v5(127.23,73.31) ; v5(92.07,77.54) v6(92.3,77.31) ; v14(121.87,82.51) 121.94,82.51 v5(122.15,82.72) ; v5(112.03,61.77) v6(111.7,61.85) ; v5(86.27,77.54) v6(86.51,77.31) ; v8(102.33,67.27) v5(102,67.27) ; v5(127.59,80.79) v14(127.35,80.56) ; v6(115.64,65.15) 115.78,65.06 v5(116.07,65.12) 116.24,65.29 v7(116.24,65.49) ; v5(86.37,51.18) v14(86.13,50.95) ; v5(132.22,48.11) v7(132.43,47.86) ; v5(95.62,59.17) v6(95.95,59.24) ; v5(107.65,84.05) v17(107.88,83.82) ; v7(81.82,67.71) 81.82,67.9 v5(81.7,68.03) ; v7(117.1,76.41) 117.6,76.41 v5(117.62,76.38) ; v5(84.45,79.49) v6(84.68,79.26) ; v7(94.04,76.28) v5(93.62,76.28) v15(93.23,76.28) ; v5(86.27,79.49) v6(86.51,79.26) ; v7(85.25,67.65) v5(85.58,67.65) ; v5(125.42,65.22) v6(125.09,65.15) ; v7(89.07,66.24) 89.02,66.19 v5(88.74,66.19) ; v5(113.6,56.57) v6(113.27,56.64) ; v7(139.48,64.47) v5(139.86,64.47) ; v7(118.17,76.41) v5(118.55,76.41) ; v5(113.6,64.42) v6(113.27,64.5) ; v5(88.62,84.05) v6(88.85,83.82) ; v5(123.05,64.42) v6(122.72,64.5) ; v5(117.24,85.35) v14(117.48,85.12) ; v5(119.12,61.77) v6(118.79,61.85) ; v5(99.61,82.07) 99.82,81.86 v14(99.92,81.86) ; v5(102.62,86.01) v17(102.86,86.24) ; v7(94.26,68.73) 93.79,68.73 v5(93.79,68.72) 93.75,68.75 v7(93.32,68.75) ; v5(87.15,51.18) v14(86.92,50.95) ; v5(99.69,79.49) 99.69,79.1 v7(99.67,79.08) ; v6(86.5,59.89) v5(86.17,59.97) ; v14(127.35,82.51) 127.35,82.57 127.42,82.57 v5(127.61,82.77) ; v5(80.43,72.22) 80.43,72.09 80.36,72.03 v7(80.36,71.84) ; v7(118.17,77.04) v5(118.55,77.04) ; v6(78.52,82.1) 78.18,82.1 v5(78.15,82.07) ; v5(107.92,79.49) v14(108.15,79.26) ; v7(119.94,75.52) v5(120.32,75.52) ; v15(88.78,76.28) v5(89.26,76.28) v15(89.72,76.28) ; v7(102.42,70.78) 102.4,70.76 v5(101.98,70.76) 101.97,70.77 v7(101.54,70.77) ; v13(97.26,45.42) v5(97.03,45.65) ; v5(114.39,61.77) v6(114.06,61.85) ; v5(126.89,79.49) v14(126.44,79.26) ; v5(115.19,85.35) v14(114.96,85.12) ; v5(126.67,78.84) v14(126.44,78.61) ; v5(111.24,64.42) v6(110.91,64.5) ; v14(110.89,82.51) v5(110.66,82.28) ; v7(139.48,63.2) v5(139.86,63.2) ; v5(127.18,49.92) v14(126.95,49.69) ; v15(85.67,73.63) v5(86,73.63) ; v5(91,80.79) v6(91.23,80.56) ; v5(89.04,82.09) v6(89.28,81.86) ; v8(102.33,67.65) v5(102.66,67.65) ; v6(94.64,83.17) 94.89,83.42 v5(94.89,83.52) ; v15(90.15,63.07) v5(89.82,63.07) ; v5(126.39,51.5) v14(126.16,51.26) ; v5(97.2,61.82) v6(97.53,61.9) ; v7(112.29,72.35) v5(112.06,72.58) ; v7(125.9,76.23) v5(125.9,75.9) ; v7(113.1,71.43) 113.1,71.43 v5(112.87,71.66) ; v5(84.45,80.79) v6(84.68,80.56) ; v5(122.27,84.05) v17(122.04,83.82) ; v15(90.15,64.47) v5(89.82,64.47) ; v7(90.31,74.42) v5(89.96,74.42) ; v7(84.87,75.65) v5(85.56,75.65) ; v7(139.48,65.74) v5(139.86,65.74) ; v7(98.16,69.76) v5(98.49,69.76) ; v5(107.92,80.79) v14(108.15,80.56) ; v4(111.17,99.49) v5(110.77,99.09) ; v5(87.19,80.79) v6(87.42,80.56) ; v5(91.59,86.66) v6(91.82,86.42) ; v7(103.4,64.85) v5(103.07,64.85) ; v7(98.23,74.81) v5(98.56,74.81) ; v5(100.11,86.66) v14(99.87,86.42) ; v5(96.97,82.09) v14(97.2,81.86) ; v15(85.31,70.4) v5(85.64,70.4) ; v5(79.07,83.4) v6(79.3,83.17) ; v7(139.48,59.39) v5(139.86,59.39) ; v7(117.12,74.5) v5(117.5,74.5) ; v7(105.25,71.9) v5(105.58,71.9) ; v15(90.15,64.85) v5(90.48,64.85) ; v5(96.94,80.14) v14(97.18,79.91) ; v5(111.13,80.79) v14(110.89,80.56) ; v5(129.07,67.7) v6(129.15,67.37) ; v5(96.41,57.37) v6(96.74,57.29) ; v5(100.43,51.18) v14(100.2,50.95) ; v5(86.96,56.57) v6(87.29,56.64) ; v5(92.04,50.39) v14(91.8,50.16) ; v7(118.53,50.76) v5(118.14,50.76) ; v7(125.24,67.01) v5(124.91,67.01) ; v5(86.94,85.35) v6(87.17,85.12) ; v14(127.53,83.17) 127.73,83.37 v5(127.86,83.37) ; v7(139.48,61.93) v5(139.86,61.93) ; v7(113.72,76.41) v5(113.34,76.41) ; v7(90.56,68.72) v5(90.89,68.72) ; v5(121.48,61.77) v6(121.15,61.85) ; v7(104.75,71.9) v5(104.42,71.9) ; v5(102.43,80.79) v14(102.66,80.56) ; v5(105.86,79.49) v14(106.32,79.26) ; v5(99.69,80.79) v14(99.92,80.56) v7(99.92,80.54) ; v8(96.87,63.07) v5(96.54,63.07) ; v7(89.2,74.74) v5(89.53,74.74) ; v7(139.48,56.85) v5(139.86,56.85) ; v6(101.46,57.29) v5(101.13,57.37) ; v5(83,84.05) v6(83.24,83.82) ; v5(91,78.84) v6(91.23,78.61) ; v5(77.05,86.66) v6(77.29,86.42) ; v5(87.78,78.45) v7(87.78,78.8) ; v5(98.77,56.57) v6(99.1,56.64) ; v13(97.26,49.29) v5(97.03,49.53) ; v5(124.79,86.01) v17(124.55,85.77) ; v5(128.02,86.66) v14(127.79,86.42) ; v7(97.1,69.73) v5(97.43,69.73) ; v5(127.77,84.7) 127.54,84.48 v14(127.53,84.47) ; v5(122.27,86.01) v17(122.04,85.77) ; v15(86.42,75.65) v5(86.09,75.65) ; v7(102.45,68.73) 102.43,68.71 v5(102,68.71) 101.98,68.73 v7(101.52,68.73) ; v5(82.9,68.03) 83.03,67.9 v7(83.03,67.71) ; v5(107.92,81.44) v14(108.15,81.21) ; v7(90.29,73.11) v5(89.94,73.11) ; v5(111.13,82.09) v14(110.89,81.86) ; v5(105,79.26) v14(105.41,79.26) ; v5(87.15,50.39) v14(86.92,50.16) ; v5(132.85,45.27) v7(133.07,45.01) ; v7(89.07,65) 88.99,64.92 v5(88.74,64.92) ; v5(112.68,86.66) v14(112.45,86.42) ; v15(95.89,75.65) v5(96.29,75.65) v7(96.71,75.65) ; v5(74.69,50.54) v14(74.46,50.31) ; v5(123.84,61.77) v6(123.51,61.85) ; v17(110.06,6.9) 110.06,6.94 v5(109.8,7.2) ; v5(115.19,84.05) v14(114.96,83.82) ; v5(81.25,67.84) 81.12,67.96 v7(80.93,67.96) ; v5(130.03,79.42) v14(129.8,79.18) ; v7(31.83,50.5) 31.61,50.5 v5(31.45,50.66) ; v7(98.94,75.65) v5(99.27,75.65) v7(99.63,75.65) ; v5(112.03,62.57) v6(111.7,62.5) ; v5(89.02,80.79) v6(89.25,80.56) ; v5(80.64,83.4) v6(80.87,83.17) ; v5(79.85,84.05) v6(80.09,83.82) ; v5(115.19,84.7) v14(114.96,84.47) ; v5(89.4,66.57) 89.35,66.62 v7(89.07,66.62) ; v5(124.84,82.74) v14(124.61,82.51) ; v5(100.11,84.05) v14(99.87,83.82) ; v5(108.09,58.67) v6(107.76,58.59) ; v5(104.03,79.49) v14(104.49,79.26) ; v5(120.22,84.7) v14(119.99,84.47) ; v5(114.39,62.57) v6(114.06,62.5) ; v5(91.68,56.57) v6(92.01,56.64) ; v15(98.21,67.27) v5(97.88,67.27) ; v7(122.84,73.74) v5(122.51,73.74) ; v5(128.41,48.79) v7(128.62,48.53) ; v5(84.45,77.54) v6(84.68,77.31) ; v8(96.87,67.27) v5(96.54,67.27) ; v5(91.68,57.37) v6(92.01,57.29) ; v5(92.04,51.97) v14(91.8,51.73) ; v6(127.45,64.5) v5(127.78,64.42) ; v7(89.55,70.77) v5(89.88,70.77) ; v5(116.07,80.87) v14(116.38,80.56) ; v7(112.34,70.36) v5(112.11,70.6) ; v5(124.84,80.79) v14(124.61,80.56) ; v15(82.9,72.54) v5(82.57,72.54) ; v7(94.32,73.17) v5(93.97,73.17) ; v7(98.23,68.73) v5(98.56,68.73) ; v5(96.05,82.09) v14(96.29,81.86) ; v7(94.04,75.65) v5(93.62,75.65) v15(93.23,75.65) ; v5(123.93,78.84) v14(123.69,78.61) ; v7(125.99,77.04) v5(125.99,76.66) ; v5(98.89,45.18) 98.89,45.31 v7(98.65,45.55) ; v7(109.13,49.49) v5(108.75,49.49) ; v7(87.98,64.12) 88.26,64.12 v5(88.36,64.22) ; v14(119.1,83.17) 118.84,82.91 118.82,82.91 v5(118.77,82.86) ; v17(130.45,80.93) 130.25,80.87 130.15,80.93 v5(130.11,81.07) ; v15(82.86,76.28) v5(82.53,76.28) ; v7(90.55,69.7) v5(90.88,69.7) ; v5(119.36,82.74) v14(119.12,82.51) ; v8(102.33,63.07) v5(102,63.07) ; v5(102.62,85.35) v17(102.86,85.59) ; v14(105.41,79.91) 105.23,79.74 v5(105.01,79.74) ; v5(108.26,44.46) 108.73,44.46 v7(108.75,44.47) ; v5(90.08,78.84) v6(90.32,78.61) ; v8(102.33,64.47) v5(102,64.47) ; v5(97.59,86.01) v14(97.36,85.77) ; v5(79.87,80.79) v6(80.11,80.56) ; v5(85.36,80.79) v17(85.59,80.56) ; v5(105.17,80.79) v14(105.41,80.56) ; v5(126.2,62.57) v6(125.87,62.5) ; v7(120.93,75.52) v5(121.31,75.52) ; v5(96.03,81.44) v14(96.26,81.21) ; v7(116.25,75.52) v5(116.63,75.52) ; v5(115.18,59.17) v6(114.85,59.24) ; v5(112.68,82.94) v14(112.45,83.17) ; v5(122.27,86.66) v17(122.04,86.42) ; v8(94.33,65.87) v5(94,65.87) ; v5(81.7,80.79) v6(81.94,80.56) ; v7(126.08,73.69) v5(126.08,73.31) ; v17(90.94,85.75) 90.69,86.01 v5(90.55,86.01) ; v7(109.13,50.76) v5(108.75,50.76) ; v5(83.79,85.35) v6(84.02,85.12) ; v7(113.94,71.46) v5(113.71,71.69) ; v8(94.33,66.25) v5(94.66,66.25) ; v5(122.27,84.7) v17(122.04,84.47) ; v7(116.24,66.88) v5(115.91,66.88) ; v5(119.12,62.57) v6(118.79,62.5) ; v7(122.84,75.01) v5(122.51,75.01) ; v5(99.69,80.14) v14(99.92,79.91) ; v5(86.37,51.97) v14(86.13,51.73) ; v5(131.33,49.17) v7(131.54,48.91) ; v13(97.26,48.66) v5(97.49,48.89) ; v7(113.13,70.36) v5(112.89,70.6) ; v5(129.13,48.02) v7(129.35,47.77) ; v7(94.26,74.42) v5(93.91,74.42) ; v13(97.26,51.2) v5(97.49,51.43) ; v5(118.33,64.42) v6(118,64.5) ; v7(82.2,67.71) 82.2,67.9 v5(82.33,68.03) ; v6(115.64,64.5) 115.7,64.54 v5(116.05,64.46) 116.24,64.27 v7(116.24,64.09) ; v5(89.32,57.37) v6(89.65,57.29) ; v5(127.18,51.5) v14(126.95,51.26) ; v7(103.35,29.74) 103.35,30.08 v5(103.42,30.15) ; v5(97.59,85.35) v14(97.36,85.12) ; v5(129.13,47.2) v7(129.35,46.95) ; v8(96.87,63.46) v5(97.2,63.46) ; v5(122.27,83.4) 122.04,83.17 ; v7(125.24,66) v5(124.91,66) ; v15(90.15,66.25) v5(90.48,66.25) ; v7(117.1,77.04) v5(117.6,77.04) ; v5(97.2,62.63) v6(97.53,62.55) ; v5(96.94,80.79) v14(97.18,80.56) ; v5(80.79,79.49) v6(81.02,79.26) ; v5(90.55,83.4) 90.69,83.4 v17(90.94,83.15) ; v5(96.03,80.79) v14(96.26,80.56) ; v5(91.25,50.39) v14(91.02,50.16) ; v5(122.27,59.17) v6(121.94,59.24) ; v5(78.96,78.84) v6(79.19,78.61) ; v5(112.82,59.97) v6(112.49,59.89) ; v5(125.6,51.5) v14(125.37,51.26) ; v5(120.69,57.37) v6(120.36,57.29) ; v5(117.71,84.7) v14(117.48,84.47) ; v5(124.79,84.7) v17(124.55,84.47) ; v7(85.25,65.11) v5(85.58,65.11) ; v5(88.1,79.49) v6(88.34,79.26) ; v5(107.65,84.7) v17(107.88,84.47) ; v5(116.61,79.49) v14(116.38,79.26) ; v5(88.62,85.35) v6(88.85,85.12) ; v5(120.23,86.66) v14(119.99,86.42) ; v5(105.14,84.05) v17(105.37,84.29) ; v13(97.26,49.93) v5(97.49,50.16) ; v5(131.33,82.57) v14(131.1,82.33) ; v5(128.56,61.77) v6(128.23,61.85) ; v5(82.21,85.35) v6(82.45,85.12) ; v7(124.62,68.15) v5(124.29,68.15) ; v5(87.19,77.54) v6(87.42,77.31) ; v5(101,83.4) v14(100.76,83.17) ; v5(102.62,84.05) v17(102.86,84.29) ; v8(102.33,63.46) v5(102.66,63.46) ; v5(119.36,81.44) v14(119.12,81.21) ; v5(105.17,81.44) v14(105.41,81.21) ; v7(141.02,53.3) v5(141.4,53.3) ; v17(76.7,86.09) 76.61,86 v5(76.35,86) ; v7(97.08,68.66) v5(97.41,68.66) ; v5(131.67,62.19) v6(131.75,61.86) ; v5(131.98,79.42) v14(131.75,79.18) ; v5(108.09,57.87) v6(107.76,57.94) ; v7(83.41,67.71) 83.41,67.9 v5(83.54,68.03) ; v7(123.99,69.42) v5(123.66,69.42) ; v7(91.96,76.28) v5(91.63,76.28) ; v5(132.48,64.55) v6(132.4,64.22) ; v14(128.18,79.14) 128.2,79.14 128.41,79.35 v5(128.41,79.37) ; v5(119.36,80.14) v14(119.12,79.91) ; v5(105.14,85.35) v17(105.37,85.59) ; v17(90.94,83.8) 90.69,84.05 v5(90.55,84.05) ; v5(101.13,56.57) v6(101.46,56.64) ; v5(117.71,84.05) v14(117.48,83.82) ; v5(113.87,82.09) v14(113.64,81.86) ; v5(92.04,51.18) v14(91.8,50.95) ; v5(115.19,86.66) v14(114.96,86.42) ; v5(94.05,56.57) v6(94.38,56.64) ; v5(81.73,82.74) v6(81.96,82.51) ; v5(96.08,84.61) 95.94,84.47 v14(95.68,84.47) ; v5(132.63,79.42) v14(132.4,79.18) ; v8(102.33,65.87) v5(102,65.87) ; v7(139.48,60.66) v5(139.86,60.66) ; v8(94.33,67.27) v5(94,67.27) ; v6(106.19,56.64) 105.95,56.59 v5(105.81,56.67) ; v7(85.3,72.68) v5(85.63,72.68) ; v5(123.05,65.22) v6(122.72,65.15) ; v5(91.25,51.18) v14(91.02,50.95) ; v5(78.29,80.76) v6(78.52,80.53) ; v15(98.21,63.46) v5(98.54,63.46) ; v5(123.24,79.49) v14(122.78,79.26) ; v15(90.15,65.87) v5(89.82,65.87) ; v5(76.99,81.55) v6(77.22,81.32) ; v5(112.82,59.17) v6(112.49,59.24) ; v5(94.05,57.37) v6(94.38,57.29) ; v7(107.35,67.9) v5(107.02,67.9) ; v7(96.9,74.79) v5(97.23,74.79) ; v5(105.17,82.74) v14(105.41,82.51) ; v5(91,77.54) v6(91.23,77.31) ; v5(113.6,65.22) v6(113.27,65.15) ; v7(98.22,73.1) v5(97.87,73.1) ; v5(90.11,62.63) v6(90.44,62.55) ; v7(90.27,72.15) v5(90.6,72.15) ; v5(88.1,80.79) v6(88.34,80.56) ; v5(87.15,51.97) v14(86.92,51.73) ; v5(75.74,85.27) v6(75.97,85.03) ; v17(29.09,48.02) 29.09,48.33 v5(29.06,48.37) ; v15(89.72,75.65) v5(89.26,75.65) v15(88.78,75.65) ; v7(129.07,50.76) v5(129.45,50.76) ; v15(85.7,74.65) v5(86.03,74.65) ; v7(109.39,61.93) 109.39,62.19 v5(109.31,62.27) ; v5(100.43,51.97) v14(100.2,51.73) ; v7(80.93,74.44) 81.12,74.44 v5(81.25,74.57) ; v5(111.05,83.4) v14(110.82,83.17) ; v7(111.67,50.74) v5(111.29,50.74) ; v5(91.25,51.97) v14(91.02,51.73) ; v5(118.33,56.57) v6(118,56.64) ; v5(75.04,81.55) v17(74.7,81.22) ; v7(127.23,70.87) v5(127.23,70.54) ; v7(108.75,45.68) v5(108.37,45.68) ; v7(90.27,71.77) v5(89.92,71.77) ; v5(81.43,84.05) v6(81.66,83.82) ; v5(117.54,59.17) v6(117.21,59.24) ; v5(117.71,86.01) v14(117.48,85.77) ; v7(113.08,72.35) v5(112.84,72.58) ; v7(89.2,74.36) v5(88.85,74.36) ; v5(99.65,51.97) v14(99.41,51.73) ; v7(141.02,54.44) v5(141.4,54.44) ; v7(83.85,78.72) v5(83.85,78.36) ; v5(131.33,79.42) v14(131.1,79.18) ; v7(138.73,53.3) v5(139.11,53.3) ; v5(113.34,84.8) v14(113.34,84.47) ; v13(117.71,51.05) v5(117.95,51.29) ; v7(115.12,76.41) v5(114.74,76.41) ; v5(97.59,84.7) v14(97.36,84.47) ; v5(84.58,84.05) v6(84.81,83.82) ; v5(82.62,80.79) v6(82.85,80.56) ; v5(117.71,86.66) v14(117.48,86.42) ; v5(111.13,80.14) v14(110.89,79.91) ; v5(127.59,82.09) v14(127.35,81.86) ; v5(120.22,85.35) v14(119.99,85.12) ; v5(90.55,86.66) v6(90.78,86.42) ; v5(112.68,84.7) v14(112.45,84.47) ; v5(113.87,79.49) v14(113.64,79.26) ; v5(75.33,51.31) v14(75.09,51.07) ; v5(88.53,59.17) v6(88.86,59.24) ; v5(75.69,84.6) v6(75.92,84.36) ; v5(80.79,80.79) v6(81.02,80.56) ; v5(102.9,82.74) v14(102.66,82.51) ; v8(102.33,64.85) v5(102.66,64.85) ; v5(129.87,48.02) v7(130.08,47.77) ; v5(122.1,79.49) v14(121.87,79.26) ; v5(119.83,50.86) 119.58,50.86 v7(119.48,50.76) ; v7(113.72,77.04) v5(113.34,77.04) ; v5(130.68,82.57) v14(130.45,82.33) ; v5(106.78,79.49) v14(107.23,79.26) ; v7(96.9,71.75) v5(96.55,71.75) ; v7(103.4,65.74) v5(103.07,65.74) ; v7(98.21,71.77) v5(97.86,71.77) ; v15(98.21,64.47) v5(97.88,64.47) ; v7(93.29,70.73) 93.75,70.73 v5(93.76,70.72) 93.76,70.72 v7(94.21,70.72) ; v8(96.87,66.25) v5(97.2,66.25) ; v7(82.14,71.28) v5(81.71,71.28) v7(81.25,71.28) ; v5(115.18,59.97) v6(114.85,59.89) ; v5(125.42,64.42) v6(125.09,64.5) ; v14(111.97,98.69) v5(111.57,98.29) ; v15(85.27,71.35) v5(85.6,71.35) ; 106.37,107.49 v5(106.14,107.26) ; v7(96.71,76.28) v5(96.29,76.28) v15(95.89,76.28) ; v5(129.88,63.77) v6(129.8,63.44) ; v5(85.38,62.63) v6(85.72,62.55) ; v5(83.56,82.74) v6(83.79,82.51) ; v6(86.5,59.24) v5(86.17,59.17) ; v5(89.4,65.3) 89.32,65.39 v7(89.07,65.39) ; v15(90.15,67.65) v5(90.48,67.65) ; v5(127.59,79.49) v14(127.35,79.26) ; v7(127.23,68.23) v5(127.23,67.85) ; v14(95.2,80.56) 94.85,80.56 v5(94.74,80.45) ; v5(111.24,56.57) v6(110.91,56.64) ; v5(124.79,84.05) v17(124.55,83.82) ; v5(116.75,62.57) v6(116.42,62.5) ; v5(119.9,59.97) v6(119.57,59.89) ; v7(107.46,71.9) v5(107.79,71.9) ; v5(125.42,57.37) v6(125.09,57.29) ; v5(76.34,82.34) v6(76.57,82.1) ; v5(129.07,63.77) v6(129.15,63.44) ; v7(113.92,72.37) v5(113.68,72.6) ; v5(121.48,62.57) v6(121.15,62.5) ; v5(96.03,80.14) v14(96.26,79.91) ; v7(96.9,74.41) v5(96.55,74.41) ; v5(130.03,78.63) v14(129.8,78.4) ; v5(89.32,56.57) v6(89.65,56.64) ; v7(109.13,48.22) v5(108.75,48.22) ; v7(98.21,72.15) v5(98.54,72.15) ; v5(99.65,50.39) v14(99.41,50.16) ; v5(90.08,77.54) v6(90.32,77.31) ; v5(115.97,57.37) v6(115.64,57.29) ; v5(127.59,81.44) v14(127.35,81.21) ; v8(96.87,64.85) v5(97.2,64.85) ; v5(124.79,85.35) v17(124.55,85.12) ; v6(86.39,83.82) v5(86.15,84.05) ; v5(124.63,59.17) v6(124.3,59.24) ; v14(75.27,67.14) v4(75.27,67.47) ; v5(117.53,78.19) v14(117.29,77.96) ; v5(83.53,80.79) v6(83.77,80.56) ; v15(82.86,75.65) v5(82.53,75.65) ; v7(89.17,73.06) v5(88.82,73.06) ; v7(112.43,68.28) v5(112.1,68.28) ; v5(122.27,59.97) v6(121.94,59.89) ; v5(129.13,48.79) v7(129.35,48.53) ; v7(113.97,70.39) v5(113.73,70.62) ; v5(100.43,50.39) v14(100.2,50.16) ; v7(121.19,67.9) v5(120.81,67.9) ; v5(98.77,57.37) v6(99.1,57.29) ; v15(82.9,74.19) v5(83.23,74.19) ; v7(105.23,60.95) 105.89,60.95 v5(105.97,61.04) ; v5(129.35,59.17) v6(129.02,59.24) ; v7(84.85,78.77) v5(84.85,78.44) ; v5(97.59,84.05) v14(97.36,83.82) ; v7(96.89,73.48) v5(97.22,73.48) ; v4(111.97,97.09) v5(111.57,97.49) ; v5(107.92,82.09) v14(108.15,81.86) ; v5(117.01,65.56) 117.01,65.33 117.24,65.11 v7(117.26,65.11) ; v7(85.24,63.96) v5(85.57,63.96) ; v7(102.34,72.15) v5(102.67,72.15) ; v5(92.07,81.44) v17(91.83,81.21) ; v5(108.09,57.37) v6(107.76,57.29) ; v5(75.3,52.05) v14(75.07,51.81) ; v5(130.68,79.42) v14(130.45,79.18) ; v5(112.68,86.01) v14(112.45,85.77) ; v5(105.22,82.14) 105.41,81.96 v14(105.41,81.86) ; v15(90.15,63.46) v5(90.48,63.46) ; v5(89.02,77.54) v6(89.25,77.31) ; v5(129.35,59.97) v6(129.02,59.89) ; v15(98.21,64.85) v5(98.54,64.85) ; v5(93.49,86.68) v6(93.75,86.42) ; v5(96.26,83.33) 96.42,83.17 v6(96.57,83.17) ; v7(84.86,76.27) 84.87,76.28 v5(85.56,76.28) ; v5(125.98,79.49) v14(125.52,79.26) ; v5(91.02,82.74) v6(91.26,82.51) ; v7(116.24,68.28) v5(115.91,68.28) ; v8(96.87,67.65) v5(97.2,67.65) ; v5(126.39,49.92) v14(126.16,49.69) ; v5(80.64,85.35) v14(80.87,85.12) ; v5(127.18,50.71) v14(126.95,50.48) ; v5(118.33,57.37) v6(118,57.29) ; v5(113.37,77.69) v14(113.64,77.96) ; v7(89.17,73.44) v5(89.5,73.44) ; v5(129.88,66.13) v6(129.8,65.8) ; v5(126.99,59.97) v6(126.66,59.89) ; v7(139.48,55.58) v5(139.86,55.58) ; v7(83.03,71.28) v5(83.49,71.28) v7(83.92,71.28) ; v5(107.65,86.66) v17(107.88,86.42) ; v7(85.84,78.76) v5(85.84,78.43) ; v5(132.48,62.19) v6(132.4,61.86) ; v5(132.48,69.28) v6(132.4,68.95) ; v5(78.29,77.61) v14(78.52,77.38) ; v5(126.2,61.77) v6(125.87,61.85) ; v5(76.99,83.12) v6(77.22,82.89) ; v5(131.2,48.11) v7(131.42,47.86) ; v5(117.54,59.97) v6(117.21,59.89) ; v5(119.36,80.79) v14(119.12,80.56) ; v5(130.03,80.36) v17(130.37,80.47) ; v5(97.98,59.97) v6(98.31,59.89) ; v7(89.19,72.13) v5(89.52,72.13) ; v5(80.79,81.44) v6(81.02,81.21) ; v5(105.14,86.01) v17(105.37,86.24) ; v5(130.24,83.49) v14(130,83.25) ; v5(131.67,66.92) v6(131.75,66.58) ; v5(110.45,59.97) v6(110.12,59.89) ; v7(102.33,74.41) v5(101.98,74.41) ; v7(89.07,67.48) 88.77,67.48 v5(88.74,67.46) ; v5(81.7,77.54) v6(81.94,77.31) ; v5(100.11,84.7) v14(99.87,84.47) ; v5(127.77,85.35) v14(127.53,85.12) ; v5(120.69,56.57) v6(120.36,56.64) ; v5(124.84,82.09) v14(124.61,81.86) ; v7(90.29,73.49) v5(90.62,73.49) ; v5(79.85,86.66) v6(80.09,86.42) ; v6(82.85,77.31) 82.85,77.6 v5(82.93,77.68) ; v5(120.22,84.05) v14(119.99,83.82) ; v5(127.91,85.93) 127.7,85.93 v14(127.53,85.77) ; v5(75.04,83.88) v6(75.27,83.65) ; v7(102.35,73.09) v5(102,73.09) ; v5(124.84,79.49) v14(124.61,79.26) ; v5(115.97,56.57) v6(115.64,56.64) ; v15(82.9,73.81) v5(82.57,73.81) ; v5(100.11,83.4) v14(99.87,83.17) ; v5(130.13,85.04) v14(129.9,84.81) ; v5(107.92,82.74) v14(108.15,82.51) ; v5(86.37,50.39) v14(86.13,50.16) ; v7(109.39,63.71) v5(109.72,63.71) ; v5(124.63,59.97) v6(124.3,59.89) ; v7(90.31,74.8) v5(90.64,74.8) ; v5(115.7,79.49) v14(115.46,79.26) ; v6(127.45,65.15) v5(127.78,65.22) ; v15(98.21,65.87) v5(97.88,65.87) ; v5(100.35,59.17) v6(100.68,59.24) ; v5(123.84,62.57) v6(123.51,62.5) ; v5(116.75,61.77) v6(116.42,61.85) ; v5(99.65,51.18) v14(99.41,50.95) ; v5(121.57,80.85) v14(121.87,80.56) ; v7(109.39,62.82) v5(109.72,62.82) ; v5(105.86,57.37) v6(106.19,57.29) ; v4(112.37,99.89) v5(112.77,99.89) ; v5(133.36,48.11) v7(133.58,47.86) ; v13(117.71,50.46) v5(117.95,50.22) ; v5(107.65,86.01) v17(107.88,85.77) ; v8(96.87,64.47) v5(96.54,64.47) ; v5(74.69,51.31) v14(74.46,51.07) ; v7(96.9,72.13) v5(97.23,72.13) ; v5(85.36,83.4) v6(85.6,83.17) ; v5(92.07,78.84) v6(92.3,78.61) ; v5(82.62,81.44) v6(82.85,81.21) ; v5(131.67,69.28) v6(131.75,68.95) ; v5(93.26,59.97) v6(93.59,59.89) ; v5(128.56,62.57) v6(128.23,62.5) ; v5(82.21,83.4) v6(82.45,83.17) ; v7(110.89,67.15) v5(111.24,67.15) ; v5(124.84,80.14) v14(124.61,79.91) ; v5(121.58,80.19) v14(121.87,79.91) ; v5(114.07,84.8) v14(114.07,84.47) ; v7(94.32,73.55) v5(94.65,73.55) ; v13(97.26,50.56) v5(97.03,50.8) ; v5(87.75,62.63) v6(88.08,62.55) ; v5(76.34,83.12) v6(76.57,82.89) ; v5(102.62,84.7) v17(102.86,84.94) ; v5(112.68,85.35) v14(112.45,85.12) ; v6(86.39,86.42) v5(86.15,86.66) ; v5(100.11,85.35) v14(99.87,85.12) ; v5(88.1,81.44) v6(88.34,81.21)
  GND2 w0.305: v5(106.65,64.23) 106.74,64.14 v7(106.74,63.62) ; v7(107.07,64.65) 106.8,64.65 v5(106.66,64.79) ; v7(107.9,60.94) v5(107.9,60.56)
  GND2 w0.508: v5(90.18,61.64) 90.2,61.67 v7(90.12,61.99)
  VCC w0.203: JUSBC1.3 4.34,87.62 ; JUSBC1.3 4.34,88.32 ; JUSBC1.3 3.15,87.62 ; JUSBC1.3 3.15,89.02 ; JUSBC1.3 1.96,88.32 ; JUSBC1.3 1.96,87.62 ; JUSBC1.3 4.34,89.02 ; H6.1 8.66,75.68 ; H6.1 5.94,74.52 ; H6.1 6.34,75.68 ; H6.1 7.5,72.96 ; H6.1 7.5,76.08 ; H6.1 8.66,73.36 ; H6.1 6.34,73.36 ; H4.1 153.32,75.53 ; H4.1 152.77,77.04 ; H4.1 149.75,77.04 ; H4.1 149.75,74.02 ; H4.1 151.26,77.59 ; H4.1 152.77,74.02 ; H4.1 151.26,73.47 ; JUSBC1.2 7.38,78.42 ; JUSBC1.2 7.38,77.02 ; JUSBC1.2 8.51,77.72 ; JUSBC1.2 6.24,77.02 ; JUSBC1.2 8.51,77.02 ; 1.96,76.72 JUSBC1.4 ; JUSBC1.4 4.34,76.02 ; JUSBC1.4 3.15,76.02 ; JUSBC1.4 4.34,77.42 ; JUSBC1.4 4.34,76.72 ; JUSBC1.4 3.15,77.42 ; JUSBC1.4 1.96,76.02 ; JUSBC1.4 1.96,77.42 ; 6.24,88.02 JUSBC1.1 ; JUSBC1.1 8.51,87.32 ; JUSBC1.1 8.51,88.02 ; JUSBC1.1 7.38,86.62 ; JUSBC1.1 7.38,88.02 ; JUSBC2.B12 8.16,101.52 ; JUSBC2.B12 8.07,101.15 ; JUSBC2.B12 7.33,101.89 ; JUSBC2.B12 7.7,101.06 ; JUSBC2.B12 7.24,101.52 ; 7.24,95.92 JUSBC2.B1 ; JUSBC2.B1 8.07,96.29 ; JUSBC2.B1 7.33,95.55 ; JUSBC2.B1 7.7,96.38 ; 6.34,107.88 H1.1 ; H1.1 8.66,105.56 ; H1.1 9.06,106.72 ; H1.1 7.5,108.28 ; H1.1 8.66,107.88 ; H1.1 5.94,106.72 ; H1.1 7.5,105.16 ; H1.1 6.34,105.56 ; JUSBC2.3 3.15,105.22 ; JUSBC2.3 3.15,103.82 ; JUSBC2.3 1.96,103.82 ; JUSBC2.3 1.96,104.52 ; JUSBC2.3 4.34,104.52 ; JUSBC2.3 4.34,103.82 ; JUSBC2.3 4.34,105.22 ; JUSBC2.3 1.96,105.22 ; 5,90.62 H3.1 ; H3.1 5.4,89.46 ; H3.1 7.72,89.46 ; H3.1 6.56,89.06 ; H3.1 6.56,92.18 ; H3.1 7.72,91.78 ; H3.1 8.12,90.62 ; H3.1 5.4,91.78 ; JUSBC2.4 4.34,92.92 ; JUSBC2.4 1.96,92.92 ; JUSBC2.4 4.34,93.62 ; JUSBC2.4 1.96,93.62 ; JUSBC2.4 3.15,92.22 ; JUSBC2.4 4.34,92.22 ; JUSBC2.4 3.15,93.62 ; 11.81,107.95 H26.1 ; H26.1 13.61,107.95 ; H26.1 11.5,108.85 ; H26.1 11.81,109.75 ; H26.1 13.61,109.75 ; H26.1 13.92,108.85 ; H26.1 12.71,107.64 ; JUSBC1.B1 8.07,80.09 ; JUSBC1.B1 7.24,79.72 ; JUSBC1.B1 7.7,80.18 ; JUSBC1.B1 7.33,79.35 ; JCR1.23 6.61,71.65 ; JCR1.23 6.61,70.95 ; JCR1.23 4.39,71.65 ; JCR1.23 4.39,70.95 ; JCR1.23 5.5,72.34 ; JCR1.23 4.39,72.34 ; JCR1.23 6.61,72.34 ; JCR1.23 5.5,70.95 ; JUSBC2.1 8.51,104.22 ; JUSBC2.1 7.38,104.22 ; JUSBC2.1 8.51,103.52 ; JUSBC2.1 7.38,102.82 ; JUSBC2.1 6.24,104.22 ; JUSBC2.2 8.51,93.22 ; JUSBC2.2 7.38,94.62 ; JUSBC2.2 7.38,93.22 ; JUSBC2.2 6.24,93.22 ; JUSBC2.2 8.51,93.92 ; 7.7,84.86 JUSBC1.B12 ; JUSBC1.B12 7.24,85.32 ; JUSBC1.B12 7.33,85.69 ; JUSBC1.B12 8.16,85.32 ; JUSBC1.B12 8.07,84.95 ; 150.61,112.11 H16.1 ; H16.1 150.61,109.79 ; H16.1 152.93,112.11 ; H16.1 150.21,110.95 ; H16.1 151.77,109.39
  GND3 w0.102: v5(42.34,46.65) 42.02,46.65 v6(42.01,46.64) ; v5(80.46,60.33) 80.44,60.33 80.22,60.55 80.2,60.55 ; 100.56,16.63 100.56,16.64 ; 43.72,42.74 v6(44.05,42.74) ; v5(98.75,18.74) v15(99.11,18.74)
  GND3 w0.127: v5(32.91,66.79) v6(32.68,67.03) ; v5(46.07,57.67) 46.07,57.27 v6(46.17,57.17) ; v6(36.04,38.95) v5(35.81,39.18) ; v5(109.8,7.2) 109.89,7.11 110.07,7.11 v15(110.16,7.02) ; v6(29.06,38.12) v5(28.83,38.36) ; v6(38.47,36.94) v5(38.24,37.17) ; v6(40.36,39.3) v5(40.13,39.54) ; v6(47.06,55.06) v5(46.76,54.76) ; v6(31.65,36.94) v5(31.42,37.17) ; v6(42.78,38.96) v5(42.54,39.2) ; v6(33.15,37.32) v5(33.15,36.91) ; v6(32.64,36.96) v5(32.41,37.19) ; v6(43.02,36.94) v5(42.79,37.17) ; v6(30.67,38.36) v5(30.44,38.59) ; v17(41.74,36.96) v5(41.39,37.31) ; v6(31.11,36.68) v5(30.88,36.91) ; v5(46.64,56.29) v6(47.04,56.69) ; v6(43.8,37.32) v5(43.57,37.56) ; v6(44.95,38.71) v5(44.71,38.95) ; v5(37.15,53.47) 37.15,53.54 v6(37.38,53.77) ; v6(37.38,37.42) v5(37.14,37.66) ; v6(36.2,36.94) v5(35.97,37.17) ; v5(34.64,37.17) 34.46,37.34 v6(34.22,37.34) ; v6(32.64,39.81) v5(32.4,40.04) ; v6(43.79,40.28) v5(43.56,40.52) ; v5(46.32,55.92) 46.57,55.67 v6(46.57,55.65) ; v14(41.8,39.89) v5(41.56,40.12) ; v6(31.67,38.34) v5(31.44,38.57) ; v6(44.1,36.47) v5(44.1,36.81) ; v6(39.66,38.95) v5(39.43,39.18) ; v5(35.43,36.91) 35.48,36.86 v6(35.48,36.53) ; v14(39.66,40.47) v5(39.43,40.7) ; v6(31.16,40.32) v5(30.92,40.55) ; v6(47.17,57.17) v5(47.49,57.5) ; v6(47.52,55.82) 48.07,55.82 v5(48.14,55.75) ; v6(43.85,38.37) v5(43.62,38.6) ; v6(31.72,39.86) v5(31.49,40.09) ; v6(30.63,39.28) v5(30.4,39.51) ; v5(47.28,56.22) 47.52,56.46 v6(47.52,56.82) ; v14(39.08,36.63) 38.84,36.87 ; v6(37.93,36.68) v5(37.7,36.91) ; v6(40.78,53.67) v5(40.54,53.43) ; v6(42.75,40.81) 42.75,41.11 v5(42.85,41.2) ; v6(41.8,37.6) v5(41.56,37.84) ; v6(38.48,53.77) v5(38.2,54.05) ; v6(38.48,38.95) v5(38.25,39.18) ; v6(44.91,55.79) 44.85,55.79 v5(44.65,56) ; v6(45.16,56.66) 44.88,56.94 v5(44.88,56.98) ; v6(39.66,53.67) v5(39.39,53.94) ; v14(30,39.42) v5(29.76,39.66) ; v6(43.65,39.65) v5(43.41,39.88) ; v6(37.38,39.71) v5(37.14,39.94) ; v6(30.05,40.05) v5(29.81,40.28) ; v6(37.38,38.18) v5(37.14,38.42) ; v6(28.72,39.22) v5(28.48,39.45) ; v6(44.08,39.26) v5(44.41,39.6) ; v6(42.48,36.68) v5(42.25,36.91) ; v6(37.19,36.96) v5(36.96,37.19) ; v6(43.02,39.7) v5(42.79,39.93) ; v6(31.72,39.1) v5(31.49,39.33) ; v6(37.38,40.47) v5(37.14,40.7) ; v6(39.66,39.71) v5(39.43,39.94) ; v6(112.06,16.9) 111.95,16.9 v5(111.76,17.09) ; v6(37.38,38.95) v5(37.14,39.18) ; v6(40.8,39.73) v5(40.57,39.97) ; v6(43.62,36.63) v5(43.39,36.87) ; v5(43.47,55.56) 43.43,55.59 ; v6(40.21,36.68) v5(39.97,36.91) ; v6(30.53,37.47) v5(30.29,37.71) ; v6(29.71,38.42) v5(29.48,38.66)
  GND3 w0.152: v6(40.52,45.69) v5(40.28,45.93) ; v6(38.48,50.72) v5(38.17,51.04) ; 38.99,57.55 38.77,57.34 v5(38.77,57.3) ; v5(29.37,53.19) 29.65,53.19 v6(29.77,53.07) ; v6(39.81,48.68) v5(39.57,48.92) ; v6(31.58,48.13) v5(31.35,48.37) ; v6(32.17,57.55) v5(31.93,57.79) ; v6(36.04,53.01) v5(35.78,53.27) ; v6(39.66,41.99) v5(39.43,42.23) ; v6(39.66,51.39) 39.47,51.58 v5(39.34,51.58) ; v14(33.76,50.17) v5(33.49,50.43) ; v6(31.68,50.43) v5(31.45,50.66) ; v6(27.03,40.59) v5(26.79,40.82) ; v6(35.93,49.46) v5(35.65,49.74) ; v6(30.4,53.02) v5(30.13,53.29) ; v6(43.36,48.13) v5(43.13,48.37) ; v6(30.96,51.39) v5(31.22,51.12) ; v6(27.03,51.95) v5(26.79,52.19) ; v6(32.9,49.31) v5(32.67,49.55) ; v6(35.51,42.46) v5(35.75,42.22) ; v6(39.03,49.46) v5(38.8,49.69) ; v5(39.29,50.48) 39.6,50.17 v6(39.66,50.17) ; v6(32.61,53.75) 32.51,53.75 v5(32.31,53.96) ; v6(32.34,44.59) v5(32.11,44.82) ; v6(29.3,47.03) 29.06,47.26 ; v6(39.81,49.46) v5(39.57,49.69) ; v6(27.03,45.13) v5(26.79,45.37) ; v6(33.76,50.72) v5(33.49,50.99) ; v6(34.94,50.72) v5(34.67,50.99) ; v5(27.16,49.93) 27.16,49.9 v6(27.38,49.68) ; v6(41.07,45.69) v5(40.84,45.93) ; v6(32.61,50.7) v5(32.38,50.93) ; v6(25.89,56.82) 25.89,56.84 v5(25.6,57.13) ; v5(38.13,42.13) 38.26,41.99 v6(38.48,41.99) ; v6(40.52,49.31) v5(40.28,49.55) ; v6(44.26,49.7) 44.11,49.55 v5(43.89,49.55) ; v6(32.71,44.23) 32.71,44.78 v5(32.67,44.82) ; v6(38.26,49.46) v5(37.96,49.75) ; v17(41.26,57.55) v5(41.03,57.79) ; v6(34.38,49.46) v5(34.15,49.69) ; v5(29.28,54.58) 29.51,54.35 v6(29.57,54.35) ; v6(40.8,42.02) v5(40.57,42.25) ; v6(28.63,49.31) v5(28.4,49.55) ; v6(44.12,45.69) v5(43.89,45.93) ; v6(36.04,50.72) v5(35.81,50.96) ; v6(37.38,50.72) v5(37.09,51.01) ; v5(26.99,55.85) 26.86,55.85 26.52,56.18 v6(26.38,56.18) ; v6(34.94,53.77) v5(34.68,54.03) ; v6(33.21,56.04) 33.21,56.08 v5(32.98,56.31) ; v6(30.67,51.91) v5(30.44,52.14) ; v6(38.48,51.49) v5(38.83,51.14) ; v5(27.28,56.26) 26.8,56.26 v6(26.38,56.69) ; v5(32.95,51.26) 32.81,51.26 v6(32.61,51.46) ; v6(37.76,56.04) v5(37.52,56.27) ; v14(34.94,51.49) v5(34.7,51.72) ; v6(41.07,44.59) 40.84,44.82 ; v6(29.63,52.44) v5(29.39,52.67) ; v6(33.61,49.46) v5(33.38,49.69) ; v6(31.62,54.35) v5(31.39,54.59) ; v6(29.3,48.13) v5(29.06,48.37) ; v6(31.58,45.69) v5(31.35,45.93) ; v6(26.25,57.17) v5(25.97,57.45) ; v6(29.45,51.34) v5(29.21,51.58) ; v14(37.38,50.17) 37.38,50.18 v5(37.08,50.48) ; v6(29.4,50.43) v5(29.16,50.66) ; v6(37.38,41.99) v5(37.14,42.23) ; v6(39.66,50.67) v5(39.36,50.97) ; v6(35.16,49.46) v5(34.88,49.74) ; v5(28.4,53.6) 28.64,53.35 v6(28.77,53.35) ; v14(36.04,51.49) v5(35.81,51.72) ; v6(44.12,44.59) v5(43.89,44.82) ; v6(37.48,49.46) v5(37.2,49.74) ; v6(36.71,49.46) v5(36.43,49.74) ; v14(34.94,50.17) 34.8,50.3 v5(34.6,50.3) ; v6(28.47,54) v5(28.24,54.24) ; v6(38.48,50.17) v5(38.2,50.45) ; v6(39.66,42.55) v5(39.43,42.79) ; v6(32.9,47.03) v5(32.67,47.26) ; v6(33.76,53.01) v5(33.5,53.27) ; v6(32.34,43.41) v5(32.11,43.64) ; v6(37.38,42.55) v5(37.14,42.79) ; v6(41.02,43.41) 40.79,43.64 ; v6(44.02,43.41) v5(43.79,43.64) ; v6(30.94,56.04) v5(30.7,56.27) ; v6(27.03,42.86) v5(26.79,43.09) ; v6(41.84,47.03) v5(41.58,47.28) ; v6(28.71,41.27) v5(28.48,41.51) ; v6(35.48,56.04) v5(35.25,56.27)
  GND3 w0.203: 6.05,4.29 H7.1 ; H7.1 8.37,1.97 ; H7.1 7.21,4.69 ; H7.1 6.05,1.97 ; H7.1 5.65,3.13 ; H7.1 7.21,1.57 ; H7.1 8.77,3.13 ; H7.1 8.37,4.29 ; 111.96,47.38 v15(111.96,47) ; 1.96,93.62 JUSBC2.4 ; JUSBC2.4 4.34,93.62 ; JUSBC2.4 3.15,92.22 ; JUSBC2.4 3.15,93.62 ; JUSBC2.4 1.96,92.92 ; JUSBC2.4 4.34,92.92 ; JUSBC2.4 4.34,92.22 ; JUSBC1.B12 8.16,85.32 ; JUSBC1.B12 8.07,84.95 ; JUSBC1.B12 7.7,84.86 ; JUSBC1.B12 7.24,85.32 ; JUSBC1.B12 7.33,85.69 ; 1.96,76.02 JUSBC1.4 ; JUSBC1.4 1.96,77.42 ; JUSBC1.4 4.34,76.72 ; JUSBC1.4 1.96,76.72 ; JUSBC1.4 3.15,77.42 ; JUSBC1.4 4.34,76.02 ; JUSBC1.4 4.34,77.42 ; JUSBC1.4 3.15,76.02 ; 1.96,103.82 JUSBC2.3 ; JUSBC2.3 1.96,105.22 ; JUSBC2.3 1.96,104.52 ; JUSBC2.3 4.34,104.52 ; JUSBC2.3 4.34,105.22 ; JUSBC2.3 4.34,103.82 ; JUSBC2.3 3.15,103.82 ; JUSBC2.3 3.15,105.22 ; H4.1 151.26,77.59 ; H4.1 153.32,75.53 ; H4.1 152.77,77.04 ; H4.1 149.75,74.02 ; H4.1 149.2,75.53 ; H4.1 149.75,77.04 ; H4.1 152.77,74.02 ; H4.1 151.26,73.47 ; JUSBC1.2 7.38,78.42 ; JUSBC1.2 6.24,77.02 ; JUSBC1.2 8.51,77.02 ; JUSBC1.2 8.51,77.72 ; JUSBC1.2 7.38,77.02 ; 11.81,109.75 H26.1 ; H26.1 13.61,107.95 ; H26.1 12.71,107.64 ; H26.1 12.71,110.06 ; H26.1 11.81,107.95 ; H26.1 13.92,108.85 ; H26.1 13.61,109.75 ; H26.1 11.5,108.85 ; H28.1 154.93,31.77 ; H28.1 151.19,30.19 ; H28.1 151.19,33.35 ; H28.1 152.77,33.93 ; H28.1 154.35,30.19 ; H28.1 152.77,29.61 ; H28.1 154.35,33.35 ; H28.1 150.61,31.77 ; H5.1 15.79,13.36 ; H5.1 15.79,16.37 ; H5.1 14.28,16.92 ; H5.1 12.77,13.36 ; H5.1 12.77,16.37 ; H5.1 16.34,14.87 ; H5.1 12.22,14.87 ; H5.1 14.28,12.81 ; 6.34,75.68 H6.1 ; H6.1 7.5,76.08 ; H6.1 9.06,74.52 ; H6.1 8.66,75.68 ; H6.1 8.66,73.36 ; H6.1 5.94,74.52 ; H6.1 7.5,72.96 ; H6.1 6.34,73.36 ; JUSBC1.3 4.34,88.32 ; JUSBC1.3 3.15,89.02 ; JUSBC1.3 4.34,89.02 ; JUSBC1.3 1.96,88.32 ; JUSBC1.3 1.96,87.62 ; JUSBC1.3 4.34,87.62 ; JUSBC1.3 3.15,87.62 ; 132.36,15.5 BAT100.13 ; BAT100.13 133.71,16.48 ; BAT100.13 132.36,16.48 ; BAT100.13 133.04,15.5 ; BAT100.13 133.71,17.46 ; BAT100.13 133.71,15.5 ; BAT100.13 133.04,17.46 ; BAT100.13 132.36,17.46 ; BAT100.11 118.96,15.5 ; BAT100.11 117.61,17.46 ; BAT100.11 117.61,15.5 ; BAT100.11 118.96,16.48 ; BAT100.11 118.96,17.46 ; BAT100.11 117.61,16.48 ; BAT100.11 118.29,17.46 ; BAT100.11 118.29,15.5 ; 117.61,13.98 BAT100.12 ; BAT100.12 118.29,12.03 ; BAT100.12 118.96,13.01 ; BAT100.12 118.96,12.03 ; BAT100.12 118.29,13.98 ; BAT100.12 118.96,13.98 ; BAT100.12 117.61,12.03 ; H3.1 8.12,90.62 ; H3.1 7.72,91.78 ; H3.1 5.4,89.46 ; H3.1 5.4,91.78 ; H3.1 7.72,89.46 ; H3.1 6.56,89.06 ; H3.1 6.56,92.18 ; H3.1 5,90.62 ; 12.71,0.59 H20.1 ; H20.1 13.76,3.21 ; H20.1 11.66,3.21 ; H20.1 11.66,0.59 ; H20.1 11.66,1.9 ; H20.1 13.76,1.9 ; H20.1 12.71,3.21 ; H20.1 13.76,0.59 ; JUSBC2.1 8.51,104.22 ; JUSBC2.1 7.38,104.22 ; JUSBC2.1 7.38,102.82 ; JUSBC2.1 6.24,104.22 ; JUSBC2.1 8.51,103.52 ; H1.1 9.06,106.72 ; H1.1 5.94,106.72 ; H1.1 6.34,107.88 ; H1.1 8.66,105.56 ; H1.1 7.5,105.16 ; H1.1 6.34,105.56 ; H1.1 8.66,107.88 ; H1.1 7.5,108.28 ; 5.5,56.55 JCR1.22 ; JCR1.22 4.39,57.25 ; JCR1.22 4.39,57.94 ; JCR1.22 6.61,56.55 ; JCR1.22 6.61,57.94 ; JCR1.22 6.61,57.25 ; JCR1.22 5.5,57.94 ; JCR1.22 4.39,56.55 ; BAT100.14 133.71,13.01 ; BAT100.14 132.36,12.03 ; BAT100.14 132.36,13.98 ; BAT100.14 133.04,13.98 ; BAT100.14 133.71,13.98 ; BAT100.14 133.71,12.03 ; BAT100.14 132.36,13.01 ; BAT100.14 133.04,12.03 ; 7.24,101.52 JUSBC2.B12 ; JUSBC2.B12 8.07,101.15 ; JUSBC2.B12 8.16,101.52 ; JUSBC2.B12 7.7,101.06 ; JUSBC2.B12 7.33,101.89 ; JUSBC1.B1 7.7,80.18 ; JUSBC1.B1 8.07,80.09 ; JUSBC1.B1 7.33,79.35 ; JUSBC1.B1 7.24,79.72 ; 7.33,95.55 JUSBC2.B1 ; JUSBC2.B1 7.24,95.92 ; JUSBC2.B1 8.07,96.29 ; JUSBC2.B1 7.7,96.38 ; JUSBC1.1 8.51,87.32 ; JUSBC1.1 6.24,88.02 ; JUSBC1.1 7.38,86.62 ; JUSBC1.1 8.51,88.02 ; JUSBC1.1 7.38,88.02 ; JCR1.23 6.61,71.65 ; JCR1.23 4.39,70.95 ; JCR1.23 5.5,70.95 ; JCR1.23 5.5,72.34 ; JCR1.23 6.61,72.34 ; JCR1.23 4.39,71.65 ; JCR1.23 6.61,70.95 ; JCR1.23 4.39,72.34 ; JUSBC2.2 7.38,94.62 ; JUSBC2.2 7.38,93.22 ; JUSBC2.2 8.51,93.22 ; JUSBC2.2 6.24,93.22 ; JUSBC2.2 8.51,93.92 ; 69.81,98.44 H27.1 ; H27.1 71.81,98.44 ; H27.1 70.81,99.44 ; H27.1 70.05,97.68 ; H27.1 70.81,97.44 ; H27.1 71.57,99.2 ; H27.1 70.05,99.2 ; H27.1 71.57,97.68 ; v5(112.98,46.23) v15(112.98,45.85) ; H16.1 152.93,109.79 ; H16.1 151.77,112.51 ; H16.1 151.77,109.39 ; H16.1 150.61,112.11 ; H16.1 150.21,110.95 ; H16.1 150.61,109.79 ; H16.1 153.33,110.95 ; H16.1 152.93,112.11 ; v5(112.98,48.52) v15(112.98,48.14) ; v5(113.97,47.38) v15(113.97,47) ; 111.96,48.52 v15(111.96,48.14) ; v5(113.97,48.52) v15(113.97,48.14) ; v5(113.97,46.23) v15(113.97,45.85) ; v5(112.98,47.38) v15(112.98,47)
  GND3 w0.229: v6(87.17,83.17) v5(86.94,83.4)
  GND3 w0.254: v5(88.85,74.36) v15(89.2,74.36) ; v5(84.95,72.3) v15(85.3,72.3) ; v14(117.48,85.12) v5(117.24,85.35) ; v5(117.5,75.52) v15(117.88,75.52) ; v5(127.91,85.93) 127.7,85.93 v14(127.53,85.77) ; v6(39.03,44.04) v5(38.8,44.27) ; v5(90.48,66.25) v15(90.15,66.25) ; v14(37.48,45.58) v5(37.25,45.82) ; v5(139.86,65.74) v15(140.24,65.74) ; v6(78.52,82.1) 78.18,82.1 v5(78.15,82.07) ; v6(88.86,59.24) v5(88.53,59.17) ; v6(39.81,44.04) v5(39.57,44.27) ; v6(92.3,77.31) v5(92.07,77.54) ; v5(86.27,80.79) 86.51,80.56 v6(86.51,80.55) ; v5(82.93,77.68) 82.85,77.6 v6(82.85,77.31) ; v6(81.66,86.42) v5(81.43,86.66) ; v5(88.74,66.19) v15(89.07,66.19) ; v6(108.11,76.3) v5(107.88,76.54) ; v5(98.54,63.46) v15(98.21,63.46) ; v15(93.23,76.28) v5(93.62,76.28) ; v6(101.46,56.64) v5(101.13,56.57) ; v6(108.11,71.1) v5(107.88,71.33) ; v6(88.85,86.42) v5(88.62,86.66) ; v6(80.99,60.55) v5(80.76,60.78) ; v14(131.75,79.18) v5(131.98,79.42) ; v5(89.82,63.07) v15(90.15,63.07) ; v6(75.27,76.59) v5(75.04,76.83) ; v6(84.14,62.55) v5(83.91,62.78) ; v5(34.26,57.99) 34.26,57.54 v6(34.2,57.49) ; v5(116.05,64.46) 115.98,64.42 v6(115.64,64.5) ; v15(101.53,69.74) 101.54,69.73 v5(101.97,69.73) v15(102.38,69.73) ; v6(106.28,67.2) v5(106.05,67.43) ; v6(99.89,61.9) v5(99.56,61.82) ; 118.4,87.34 v5(118.17,87.1) ; v6(108.11,73.7) v5(107.88,73.93) ; v6(77.22,76.59) v5(76.99,76.83) ; v6(119.57,59.24) v5(119.9,59.17) ; v6(104.45,76.3) v5(104.22,76.54) ; v6(86.51,79.26) v5(86.27,79.49) ; v5(113.73,70.62) v15(113.5,70.86) ; v6(121.94,59.89) v5(122.27,59.97) ; v6(92.3,79.26) v5(92.07,79.49) ; v5(98.55,73.48) v15(98.21,73.48) ; v6(94.38,56.64) v5(94.05,56.57) ; v6(86.51,77.31) v5(86.27,77.54) ; v14(124.61,81.21) v5(124.84,81.44) ; v6(90.44,62.55) v5(90.11,62.63) ; v6(84.14,60.55) v5(83.91,60.78) ; v14(74.46,50.31) v5(74.69,50.54) ; v6(106.28,61.35) 106.05,61.58 ; v6(131.75,68.95) v5(131.67,69.28) ; v5(85.56,75.65) v15(85.23,75.65) ; v6(76.57,71.08) v5(76.34,71.31) ; v6(79.17,75.02) v5(78.94,75.25) ; v6(128.5,72.88) v5(128.27,73.12) ; v6(90.32,78.61) v5(90.08,78.84) ; v6(33.61,48.68) v5(33.38,48.92) ; v5(113.34,77.04) v15(112.96,77.04) ; v14(122.5,85.77) v5(122.27,86.01) ; v6(128.5,71.31) v5(128.27,71.54) ; v6(81.94,77.31) v5(81.7,77.54) ; v14(127.53,83.17) 127.73,83.37 v5(127.86,83.37) ; v5(82.53,75.65) v15(82.86,75.65) ; v6(115.64,56.64) v5(115.97,56.57) ; v6(85.59,80.54) v17(85.59,80.56) v5(85.36,80.79) ; v6(129.76,57.29) v5(129.99,57.06) ; v6(110.91,64.5) v5(111.24,64.42) ; v6(115.64,57.29) v5(115.97,57.37) ; v5(139.86,60.66) v15(140.24,60.66) ; v6(63.06,68.81) 63.04,68.84 63.04,68.99 v5(63.24,69.2) 63.45,68.99 v6(63.45,68.81) ; v5(141.4,54.44) v15(141.78,54.44) ; v14(120.95,77.96) v5(121.18,78.19) ; v5(96.08,84.61) 95.94,84.47 v14(95.68,84.47) ; v6(123.51,61.85) v5(123.84,61.77) ; v5(94.66,63.46) v8(94.33,63.46) ; v6(90.32,77.31) v5(90.08,77.54) ; v5(97.88,74.43) v15(98.23,74.43) ; v14(111.97,98.69) v5(111.57,98.29) ; v6(77.22,71.87) v5(76.99,72.1) ; v6(88.85,85.12) v5(88.62,85.35) ; v14(121.87,81.86) 121.63,82.1 v5(121.54,82.1) ; v6(79.17,71.87) v5(78.94,72.1) ; v6(76.57,77.38) v5(76.34,77.61) ; v14(91.02,50.95) v5(91.25,51.18) ; v6(122.72,57.29) v5(123.05,57.37) ; v5(139.86,58.12) v15(140.24,58.12) ; v6(90.44,61.9) 90.36,61.88 90.21,61.65 v5(90.18,61.64) ; v14(107.42,83.82) v5(107.65,84.05) ; v6(118,56.64) v5(118.33,56.57) ; v6(85.62,82.51) v5(85.39,82.74) ; v6(128.5,76.82) v5(128.27,77.05) ; v6(35.93,44.81) v5(35.7,45.04) ; v5(32.28,41.59) 32.41,41.71 v6(32.61,41.71) ; v14(99.87,83.17) v5(100.11,83.4) ; v14(117.48,83.82) v5(117.71,84.05) ; v6(88.34,81.21) v5(88.1,81.44) ; v14(122.78,79.26) v5(123.24,79.49) ; v14(97.2,82.51) v5(96.97,82.74) ; v5(112.84,72.58) v15(112.61,72.81) ; v6(94.64,83.17) 94.89,83.42 v5(94.89,83.52) ; v5(102.66,74.79) v15(102.33,74.79) ; v14(126.64,83.17) v5(126.88,83.4) ; v5(94,67.27) v8(94.33,67.27) ; v5(139.86,63.2) v15(140.24,63.2) ; v5(116.93,67.9) 116.84,67.9 ; v5(102,63.07) v8(102.33,63.07) ; v6(128.5,76.03) v5(128.27,76.27) ; v6(129.15,67.37) v5(129.07,67.7) ; v14(107.42,84.47) v5(107.65,84.7) ; v5(125.99,76.66) v15(126.23,76.43) ; v5(112.87,71.66) v15(112.64,71.9) ; v5(109.83,17.13) v6(110.06,16.9) ; v14(142.36,58.88) 142.16,58.68 v5(142.01,58.68) ; v6(89.65,56.64) v5(89.32,56.57) ; v6(84.14,57.29) v5(83.91,57.53) ; v6(125.09,64.5) v5(125.42,64.42) ; v14(126.95,50.48) v5(127.18,50.71) ; v5(98.54,64.85) v15(98.21,64.85) ; v14(105.41,79.26) v5(105,79.26) ; v5(81.99,65.74) v15(82.32,65.74) ; v6(120.36,57.29) v5(120.69,57.37) ; v5(101.13,57.37) v6(101.46,57.29) ; v5(93.97,73.17) v15(94.32,73.17) ; v6(78.51,83.82) v5(78.28,84.05) ; v5(86.03,74.65) v15(85.7,74.65) ; v6(84.68,81.21) v5(84.45,81.44) ; v14(104.9,85.77) v5(105.14,86.01) ; v6(90.78,83.17) v5(90.55,83.4) ; v6(35.16,48.68) v5(34.93,48.92) ; v6(113.27,56.64) v5(113.6,56.57) ; v5(103.27,79.46) 103.29,79.41 v14(103.58,79.26) ; v5(84.64,62.73) 84.75,62.73 v6(84.93,62.55) ; v14(104.9,86.42) v5(105.14,86.66) ; v6(33.61,47.91) v5(33.38,48.14) ; v6(81.78,57.94) v5(81.54,58.18) ; v5(94.66,64.85) v8(94.33,64.85) ; v14(122.5,84.47) v5(122.27,84.7) ; v14(126.95,49.69) v5(127.18,49.92) ; v6(85.6,83.17) v5(85.36,83.4) ; v6(35.16,47.13) v5(34.93,47.37) ; v6(84.68,77.31) v5(84.45,77.54) ; v14(132.4,80.76) v5(132.63,80.99) ; v5(83.71,58.69) 84.04,58.69 v6(84.14,58.59) ; v14(112.45,85.12) v5(112.68,85.35) ; v5(94.66,66.25) v8(94.33,66.25) ; v6(118,57.29) v5(118.33,57.37) ; v6(129.66,56.64) v5(129.89,56.41) ; v5(38.73,47.4) 38.76,47.4 v6(39.03,47.13) ; v6(84.81,83.82) v5(84.58,84.05) ; v6(80.99,62.55) 80.82,62.72 v5(80.82,62.95) ; v6(95.95,59.89) v5(95.62,59.97) ; v6(77.22,67.14) v5(76.99,67.38) ; v5(90.84,70.71) v15(90.51,70.71) ; v14(116.38,80.56) v5(116.07,80.87) ; v6(128.23,62.5) v5(128.56,62.57) ; v6(80.99,58.59) v5(80.76,58.83) ; v14(127.53,85.12) v5(127.77,85.35) ; v5(97.23,74.79) v15(96.89,74.79) ; v14(127.35,81.86) v5(127.59,82.09) ; v5(113.71,71.69) v15(113.47,71.92) ; v5(85.57,63.96) v15(85.9,63.96) ; v5(89.87,68.76) v15(89.53,68.76) ; v6(117.21,59.89) v5(117.54,59.97) ; 74.38,90.95 v5(73.95,90.95) ; v5(102.66,63.46) v8(102.33,63.46) ; v14(102.66,81.86) v5(102.43,81.54) v14(102.66,81.21) ; v5(89.87,69.76) v15(89.54,69.76) ; v14(115.85,83.17) v5(116.08,83.5) v14(115.85,83.82) ; v6(103.4,62.65) v5(103.17,62.88) ; v6(112.49,59.24) v5(112.82,59.17) ; v6(91.23,80.56) v5(91,80.79) ; v14(125.02,83.82) v5(124.79,84.05) ; v6(38.26,43.26) v5(38.02,43.49) ; v5(82.57,72.54) v15(82.9,72.54) ; v6(131.75,77.61) v5(131.52,77.84) ; v5(97.88,64.47) v15(98.21,64.47) ; v6(109.04,62) v5(109.31,62.27) ; v14(114.96,84.47) v5(115.19,84.7) ; v14(129.16,83.17) v5(129.39,83.4) ; v14(102.39,85.12) v5(102.62,85.35) ; v6(81.02,81.21) v5(80.79,81.44) ; v6(78.52,69.51) v5(78.29,69.74) ; v14(127.35,81.21) v5(127.59,81.44) ; v6(107.76,59.24) v5(108.09,59.17) ; v6(80.53,73.44) 80.3,73.68 ; v6(89.25,77.31) v5(89.02,77.54) ; v5(85.56,76.28) v15(85.23,76.28) ; v6(87.29,56.64) v5(86.96,56.57) ; v5(77.16,84.99) 77.19,85.02 v6(77.19,85.42) ; v14(74.44,51.81) v5(74.67,52.05) ; v14(128.18,79.14) v5(128.41,79.37) ; v6(92.3,81.21) v5(92.07,81.44) ; v6(81.02,77.31) 80.79,77.54 ; v6(121.94,59.24) v5(122.27,59.17) ; v6(85.6,85.12) v5(85.36,85.35) ; v5(127.77,84.7) 127.54,84.48 v14(127.53,84.47) ; v6(92.01,56.64) v5(91.68,56.57) ; v6(78.52,74.23) v5(78.29,74.46) ; v5(96.54,67.27) v8(96.87,67.27) ; v6(80.09,86.42) v5(79.85,86.66) ; v5(32.46,68.84) 32.41,68.79 v15(32.1,68.79) ; v14(119.12,82.51) v5(119.36,82.74) ; v5(127.23,73.31) v15(127.23,72.93) ; v14(124.61,79.26) v5(124.84,79.49) ; v6(119.57,59.89) v5(119.9,59.97) ; v14(75.09,51.07) v5(75.33,51.31) ; v15(101.54,68.71) v5(102,68.71) v15(102.4,68.71) ; v6(38.26,44.81) v5(38.02,45.04) ; v14(121.87,79.91) v5(121.58,80.19) ; v6(75.27,71.87) v5(75.04,72.1) ; v6(83.77,77.31) v5(83.53,77.54) ; v5(97.22,73.48) v15(96.88,73.48) ; v14(129.9,83.9) v5(130.13,84.13) ; v6(106.19,56.64) 105.95,56.59 v5(105.81,56.67) ; v14(109.04,83.17) 109.04,83.26 v5(108.84,83.47) ; v6(38.26,44.04) v5(38.02,44.27) ; v6(129.02,59.24) v5(129.35,59.17) ; v5(83.23,72.92) v15(82.9,72.92) ; v6(91.26,82.51) v5(91.02,82.74) ; v14(131.1,79.18) v5(131.33,79.42) ; v14(129.8,79.18) v5(130.03,79.42) ; v14(117.29,77.96) v5(117.53,78.19) ; v14(119.99,85.77) v5(120.22,86.01) ; v6(90.78,85.12) v5(90.55,85.35) ; v5(86.09,75.65) v15(86.42,75.65) ; v6(78.52,80.53) v5(78.29,80.76) ; v6(34.38,44.81) v5(34.15,45.04) ; v15(102.43,70.76) v5(101.98,70.76) 101.54,70.76 v15(101.53,70.77) ; v14(108.15,81.21) v5(107.92,81.44) ; v5(112.89,70.6) v15(112.66,70.83) ; v14(131.1,82.33) v5(131.33,82.57) ; v14(125.02,85.12) v5(124.79,85.35) ; v6(95.16,61.9) 94.86,61.83 v5(94.85,61.81) ; v6(97.53,62.55) v5(97.2,62.63) ; v14(105.41,81.21) v5(105.17,81.44) ; v14(86.13,50.16) v5(86.37,50.39) ; v14(132.4,73.67) v5(132.17,73.91) ; v6(33.76,42.55) v5(33.52,42.79) ; v5(117.5,74.5) v15(117.88,74.5) ; v14(124.13,83.17) v5(123.9,83.4) ; v6(107.2,60.7) 107.2,60.5 v5(107.48,60.22) ; v14(102.39,86.42) v5(102.62,86.66) ; v14(118.36,83.17) v5(118.6,83.4) ; v5(108.31,83.5) v14(108.31,83.17) ; v14(104.49,79.26) v5(104.03,79.49) ; v14(123.69,78.61) v5(123.93,78.84) ; v6(34.38,48.68) v5(34.15,48.92) ; v14(120.04,79.26) v5(120.27,79.49) ; v6(104.45,69.8) v5(104.22,70.03) ; v5(97.03,48.26) v13(97.26,48.02) ; v6(76.57,82.89) v5(76.34,83.12) ; v14(100.2,50.16) v5(100.43,50.39) ; v5(83.23,74.19) v15(82.9,74.19) ; v6(86.5,59.89) v5(86.17,59.97) ; v14(126.16,50.48) v5(126.39,50.71) ; v6(106.28,75) v5(106.05,75.24) ; v6(108.11,72.4) v5(107.88,72.63) ; v6(76.57,80.53) v5(76.34,80.76) ; v14(109.98,77.86) v5(110.21,78.09) ; v6(79.19,77.96) v5(78.96,78.19) ; v6(78.14,86.42) v5(77.9,86.66) ; v5(98.54,67.65) v15(98.21,67.65) ; v6(38.26,48.68) v5(38.02,48.92) ; v6(107.76,57.94) v5(108.09,57.87) ; v6(110.91,57.29) v5(111.24,57.37) ; v6(75.27,81.32) v5(75.04,81.55) ; v6(88.34,77.31) v5(88.1,77.54) ; v14(86.13,50.95) v5(86.37,51.18) ; v14(111.97,96.29) v5(112.24,96.02) ; v6(76.63,85.1) v5(76.39,85.33) ; v6(128.5,70.52) v5(128.27,70.76) ; v5(82.53,75.01) v15(82.86,75.01) ; v5(97.2,63.46) v8(96.87,63.46) ; v14(129.8,79.97) v5(130.03,80.36) ; v6(76.58,85.76) v5(76.35,86) ; v6(113.27,57.29) v5(113.6,57.37) ; v5(94.59,74.8) v15(94.25,74.8) ; v14(102.39,83.82) v5(102.62,84.05) ; v14(122.5,86.42) v5(122.27,86.66) ; v14(110.89,82.51) v5(110.66,82.28) ; v14(122.5,83.82) v5(122.27,84.05) ; v5(97.2,67.65) v8(96.87,67.65) ; v14(97.36,83.82) v5(97.59,84.05) ; v14(103.28,83.17) v5(103.28,83.5) ; v6(91.82,86.42) v5(91.59,86.66) ; v6(86.39,83.82) v5(86.15,84.05) ; v6(77.22,68.72) v5(76.99,68.95) ; v6(35.93,48.68) v5(35.7,48.92) ; v14(129.8,78.4) v5(130.03,78.63) ; v6(29.3,43.41) v5(29.06,43.64) ; v5(113.68,72.6) v15(113.45,72.84) ; v6(80.11,80.56) v5(79.87,80.79) ; v6(105.37,61.35) 105.25,61.46 v5(105,61.46) ; v6(111.7,62.5) v5(112.03,62.57) ; v6(84.68,80.56) v5(84.45,80.79) ; v5(97.49,48.89) v13(97.26,48.66) ; v5(120.32,75.52) v15(120.7,75.52) ; v5(97.88,65.87) v15(98.21,65.87) ; v6(87.42,77.31) v5(87.19,77.54) ; v14(113.64,80.56) v5(113.87,80.33) ; v14(74.46,51.07) v5(74.69,51.31) ; v6(64.26,68) 64.26,68.15 v5(64.03,68.38) 63.88,68.23 v6(63.88,68) ; v6(132.4,68.95) v5(132.48,69.28) ; v6(92.01,57.29) v5(91.68,57.37) ; v6(106.28,64.6) 106.47,64.79 v5(106.66,64.79) ; v6(124.3,59.24) v5(124.63,59.17) ; v6(106.19,57.29) v5(105.86,57.37) ; v6(28.53,44.59) v5(28.3,44.82) ; v6(80.09,83.82) v5(79.85,84.05) ; v5(34.54,46.72) 34.54,46.52 v6(34.38,46.36) ; v5(90.62,73.49) v15(90.28,73.49) ; v14(124.61,80.56) v5(124.84,80.79) ; v14(114.55,79.26) v5(114.78,79.49) ; v14(78.52,77.38) v5(78.29,77.61) ; v6(91.23,59.24) v5(90.9,59.17) ; v14(97.2,81.86) v5(96.97,82.09) ; v14(106.32,79.26) v5(105.86,79.49) ; v14(120.95,79.26) v5(121.18,79.49) ; v6(108.11,64.6) 108.11,64.66 108.1,64.67 v5(108.1,64.94) ; v14(129.8,80.76) v5(130.11,81.07) 130.14,81.07 v14(130.45,80.76) ; v6(108.11,75) v5(107.88,75.24) ; v6(89.65,57.29) v5(89.32,57.37) ; v5(97.86,71.77) v15(98.21,71.77) ; v6(123.51,62.5) v5(123.84,62.57) ; v6(79.19,78.61) v5(78.96,78.84) ; v5(81.99,64.73) v15(82.32,64.73) ; v5(89.94,73.11) v15(90.29,73.11) ; v5(97.2,66.25) v8(96.87,66.25) ; v6(122.72,56.64) v5(123.05,56.57) ; v14(124.61,79.91) v5(124.84,80.14) ; v14(108.15,79.91) v5(107.92,80.14) ; v6(33.76,42.04) 33.65,42.04 v5(33.46,42.23) ; v14(106.53,83.17) v5(106.76,83.4) ; v5(139.86,56.85) v15(140.24,56.85) ; v6(93.21,77.31) v5(92.98,77.54) ; v6(82.57,58.59) 82.38,58.78 v5(82.29,58.78) ; v14(112.45,85.77) v5(112.68,86.01) ; v6(112.49,59.89) v5(112.82,59.97) ; v6(99.1,57.29) v5(98.77,57.37) ; v14(99.41,50.95) v5(99.65,51.18) ; v6(77.22,82.89) v5(76.99,83.12) ; v6(82.45,83.17) v5(82.21,83.4) ; v6(106.28,72.4) v5(106.05,72.63) ; v6(84.81,86.42) v5(84.58,86.66) ; v6(76.57,69.51) v5(76.34,69.74) ; v5(97.88,63.07) v15(98.21,63.07) ; v6(36.71,47.13) v5(36.47,47.37) ; v6(111.7,61.85) v5(112.03,61.77) ; v14(110.89,79.91) v5(111.13,80.14) ; v6(117.21,59.24) v5(117.54,59.17) ; v14(102.66,82.51) v5(102.9,82.74) ; v6(88.85,83.82) v5(88.62,84.05) ; v6(130.45,71.31) v5(130.22,71.54) ; v6(81.66,83.82) v5(81.43,84.05) ; v15(93.23,75.65) v5(93.62,75.65) ; v5(112.08,71.66) v15(111.85,71.9) ; v6(99.1,56.64) v5(98.77,56.57) ; v6(83.24,83.82) v5(83,84.05) ; v5(97.49,47.56) v13(97.26,47.33) ; v5(97.23,72.13) v15(96.89,72.13) ; v14(105.41,79.91) 105.23,79.74 v5(105.01,79.74) ; v14(125.37,50.48) v5(125.6,50.71) ; v6(106.28,68.5) v5(106.05,68.73) ; v14(125.02,83.17) v5(124.79,83.4) ; v14(99.41,51.73) v5(99.65,51.97) ; v6(116.42,62.5) v5(116.75,62.57) ; v6(113.27,65.15) v5(113.6,65.22) ; v14(75.09,50.31) v5(75.33,50.54) ; v5(102,67.27) v8(102.33,67.27) ; v14(126.95,51.26) v5(127.18,51.5) ; v14(96.26,80.56) v5(96.03,80.79) ; v14(107.42,83.17) v5(107.65,83.4) ; v5(101.98,74.41) v15(102.34,74.41) ; v5(93.97,71.8) v15(94.32,71.8) ; v14(130.45,73.67) v5(130.22,73.91) ; v6(129.15,63.44) v5(129.07,63.77) ; v5(113.81,75.52) v15(114.19,75.52) ; v5(139.86,59.39) v15(140.24,59.39) ; v6(100.68,59.24) v5(100.35,59.17) ; v14(124.61,81.86) v5(124.84,82.09) ; v6(114.06,62.5) v5(114.39,62.57) ; v6(129.02,59.89) v5(129.35,59.97) ; v6(108.11,65.9) v5(107.88,66.13) ; v5(96.54,63.07) v8(96.87,63.07) ; v5(89.4,67.84) v15(89.07,67.84) ; v6(75.27,75.02) v5(75.04,75.25) ; v14(97.36,85.12) v5(97.59,85.35) ; v5(98.52,70.76) v15(98.18,70.76) ; v6(63.85,68.81) 63.85,69.02 v5(64,69.17) 64.23,68.94 v6(64.23,68.81) ; v5(114.74,77.04) v15(114.36,77.04) ; v6(83.35,57.94) 83.31,57.94 v5(83.02,58.24) ; v6(75.27,83.65) v5(75.04,83.88) ; v6(120.36,65.15) v5(120.69,65.22) ; v6(75.27,70.29) v5(75.04,70.53) ; v14(36.71,44.04) v5(36.47,44.27) ; v6(121.15,62.5) v5(121.48,62.57) ; v5(102.66,66.25) v8(102.33,66.25) ; v14(119.99,83.82) v5(120.22,84.05) ; v6(96.74,57.29) v5(96.41,57.37) ; v6(129.8,67.37) v5(129.88,67.7) ; v6(85.59,77.31) v5(85.36,77.54) ; v14(97.36,84.47) v5(97.59,84.7) ; v14(110.89,80.56) v5(111.13,80.79) ; v15(88.69,63.96) 88.62,63.96 v5(88.36,64.22) ; v5(97.49,51.43) v13(97.26,51.2) ; v5(116.07,65.12) 115.92,65.21 v6(115.64,65.15) ; v5(88.74,64.92) v15(89.07,64.92) ; v5(97.41,68.66) v15(97.08,68.66) ; v6(107.76,58.59) v5(108.09,58.67) ; v6(79.19,80.56) v5(78.96,80.79) ; v5(97.43,69.73) v15(97.1,69.73) ; v6(76.57,74.23) v5(76.34,74.46) ; v5(94,63.07) v8(94.33,63.07) ; v5(102,64.47) v8(102.33,64.47) ; v6(122.72,64.5) v5(123.05,64.42) ; v14(125.52,79.26) v5(125.98,79.49) ; v5(139.11,53.3) v15(139.49,53.3) ; v14(116.38,79.26) v5(116.61,79.49) ; v6(131.1,77.61) v5(130.87,77.84) ; v14(99.87,85.77) v5(100.11,86.01) ; v5(117.95,51.29) v13(117.71,51.05) ; v6(125.09,56.64) v5(125.42,56.57) ; v6(104.45,73.7) v5(104.22,73.93) ; v14(97.36,85.77) v5(97.59,86.01) ; v14(86.92,50.95) v5(87.15,51.18) ; v5(99.61,82.07) 99.71,82.07 v14(99.92,81.86) ; v6(76.57,72.65) v5(76.34,72.89) ; v5(94.65,73.55) v15(94.31,73.55) ; v14(123.39,83.17) v5(123.16,83.4) ; v14(108.15,81.86) v5(107.92,82.09) ; v6(88.34,80.56) v5(88.1,80.79) ; v6(99.89,62.55) v5(99.56,62.63) ; v5(102.66,67.65) v8(102.33,67.65) ; v6(108.11,68.5) v5(107.88,68.73) ; v5(98.54,66.25) v15(98.21,66.25) ; v6(126.66,59.89) v5(126.99,59.97) ; v6(96.57,83.17) 96.42,83.17 v5(96.26,83.33) ; v5(88.82,73.06) v15(89.17,73.06) ; v6(81.96,82.51) v5(81.73,82.74) ; v6(132.4,71.31) v5(132.17,71.54) ; v6(91.23,77.31) v5(91,77.54) ; v6(95.95,59.24) v5(95.62,59.17) ; v6(39.81,43.26) v5(39.57,43.49) ; v5(121.31,75.52) v15(121.69,75.52) ; v14(91.8,51.73) v5(92.04,51.97) ; v15(93.31,68.72) v5(93.79,68.72) v15(94.23,68.72) ; v14(126.16,49.69) v5(126.39,49.92) ; v14(114.96,83.82) v5(115.19,84.05) ; v5(89.92,71.77) v15(90.27,71.77) ; v6(114.06,61.85) v5(114.39,61.77) ; v14(110.89,79.26) v5(111.13,79.49) ; v6(82.57,62.55) v5(82.33,62.78) ; v14(112.45,83.82) v5(112.68,84.05) ; v14(35.93,44.04) v5(35.7,44.27) ; v14(113.64,77.96) v5(113.37,77.69) ; v5(127.61,82.77) 127.59,82.74 127.59,82.68 127.42,82.51 v14(127.35,82.51) ; v14(122.5,85.12) v5(122.27,85.35) ; v6(107.76,57.29) v5(108.09,57.37) ; v6(75.27,79.74) v5(75.04,79.98) ; v5(36.45,57.82) 36.69,57.58 v6(36.72,57.58) ; v6(106.28,62) v5(106.05,62.23) ; v6(107.76,56.64) v5(108.09,56.57) ; v5(98.56,74.81) v15(98.22,74.81) ; v14(119.12,80.56) v5(119.36,80.79) ; v6(91.23,78.61) v5(91,78.84) ; v14(114.96,85.12) v5(115.19,85.35) ; v5(94.65,72.19) v15(94.31,72.19) ; v5(98.56,68.73) v15(98.22,68.73) ; v5(141.96,60.03) 141.72,59.79 v14(141.72,59.64) ; v6(85.72,61.9) v5(85.38,61.82) ; v14(102.39,84.47) v5(102.62,84.7) ; v6(35.93,47.13) v5(35.7,47.37) ; v14(125.02,86.42) v5(124.79,86.66) ; v6(81.94,80.56) v5(81.7,80.79) ; v6(92.3,78.61) v5(92.07,78.84) ; v5(101.99,71.77) v15(102.35,71.77) ; v6(75.97,85.03) v5(75.74,85.27) ; v6(127.45,64.5) v5(127.78,64.42) ; v6(79.17,67.14) v5(78.94,67.45) ; v5(97.03,49.53) v13(97.26,49.29) ; v5(123.33,76.71) v15(123.33,76.38) ; v6(114.85,59.89) v5(115.18,59.97) ; v14(119.12,81.86) v5(119.36,82.09) ; v6(82.85,81.21) v5(82.62,81.44) ; v6(109.04,63.3) 108.81,63.53 ; v6(78.52,72.65) v5(78.29,72.89) ; v6(75.92,84.36) v5(75.69,84.6) ; v5(94,65.87) v8(94.33,65.87) ; v6(91.23,59.89) v5(90.9,59.97) ; v5(90.89,68.72) v15(90.56,68.72) ; v6(81.02,79.26) v5(80.79,79.49) ; v6(128.5,75.25) v5(128.27,75.48) ; v5(36.3,67.7) v15(36.02,67.41) ; v5(127.23,67.85) v15(127.23,67.47) ; v15(93.31,70.72) v5(93.76,70.72) v15(94.2,70.72) ; v6(90.78,85.77) v5(90.55,86.01) ; v6(125.09,57.29) v5(125.42,57.37) ; v5(89.82,64.47) v15(90.15,64.47) ; v6(125.09,65.15) v5(125.42,65.22) ; v5(93.85,81.11) 93.95,81.21 v6(94.28,81.21) ; v6(78.52,71.08) v5(78.29,71.31) ; v6(35.16,47.91) v5(34.93,48.14) ; v15(89.72,76.28) v5(89.26,76.28) v15(88.78,76.28) ; v14(117.48,84.47) v5(117.71,84.7) ; v6(103.4,62) v5(103.17,62.23) ; v5(88.74,67.46) v15(89.07,67.46) ; v6(77.22,78.17) v5(76.99,78.4) ; v6(83.77,80.56) v5(83.53,80.79) ; v6(128.23,61.85) v5(128.56,61.77) ; v6(82.57,56.64) v5(82.33,56.88) ; v6(92.8,61.9) v5(92.47,61.82) ; v5(97.2,64.85) v8(96.87,64.85) ; v6(79.17,73.44) v5(78.94,73.68) ; v14(96.26,79.26) v5(96.03,79.49) ; v5(141.96,59.26) v14(141.69,59) ; v5(126.08,73.31) v15(126.08,72.98) ; v14(86.92,50.16) v5(87.15,50.39) ; v5(90.6,72.15) v15(90.26,72.15) ; v5(89.82,67.27) v15(90.15,67.27) ; v14(117.48,86.42) v5(117.71,86.66) ; v6(108.11,67.2) v5(107.88,67.43) ; v14(113.64,81.21) v5(113.87,80.98) ; v6(131.75,66.58) v5(131.67,66.92) ; v14(125.02,84.47) v5(124.79,84.7) ; v14(104.9,83.82) v5(105.14,84.05) ; v6(80.11,77.31) 79.87,77.54 ; v5(129.92,81.87) 129.94,81.78 v14(129.8,81.55) ; v6(118,65.15) v5(118.33,65.22) ; v5(93.91,74.42) v15(94.26,74.42) ; v6(92.71,85.12) 92.71,85.12 v5(92.44,85.39) ; v6(118,64.5) v5(118.33,64.42) ; v6(79.3,83.17) v5(79.07,83.4) ; v14(37.48,44.81) v5(37.25,45.04) ; v14(111.97,101.09) v5(111.57,100.69) ; v6(39.03,45.58) v5(38.8,45.82) ; v14(128.37,83.17) v5(128.61,83.4) ; v6(84.02,83.17) v5(83.79,83.4) ; v6(82.85,79.26) v5(82.62,79.49) ; v5(85.64,70.4) v15(85.31,70.4) ; v6(131.75,61.86) v5(131.67,62.19) ; v5(85.57,63.07) v15(85.9,63.07) ; v14(121.87,81.21) 121.64,81.44 v5(121.54,81.44) ; v6(132.4,61.86) v5(132.48,62.19) ; v5(139.86,64.47) v15(140.24,64.47) ; v6(95.16,62.55) 94.96,62.6 v5(94.79,62.5) ; v5(141.4,53.3) v15(141.78,53.3) ; v6(37.48,47.13) v5(37.25,47.37) ; v6(104.45,75) v5(104.22,75.24) ; v14(96.29,81.86) v5(96.05,82.09) ; v6(98.31,59.24) v5(97.98,59.17) ; v6(106.28,73.7) v5(106.05,73.93) ; v14(110.89,81.86) v5(111.13,82.09) ; v6(77.87,84.36) v5(77.64,84.6) ; v6(32.37,42.26) v5(32.13,42.5) ; v14(125.91,83.17) v5(126.14,83.4) ; v6(34.38,43.26) v5(34.15,43.49) ; v5(125.9,75.9) v15(125.9,75.57) ; v5(141.94,60.77) 141.7,60.53 v14(141.7,60.38) ; v5(86.09,76.28) v15(86.42,76.28) ; v6(110.91,65.15) v5(111.24,65.22) ; v6(104.45,68.5) v5(104.22,68.73) ; v6(131.75,64.22) v5(131.67,64.55) ; v6(100.68,59.89) v5(100.35,59.97) ; v14(86.92,51.73) v5(87.15,51.97) ; v14(107.42,86.42) v5(107.65,86.66) ; v6(118.79,62.5) v5(119.12,62.57) ; v14(112.45,83.17) v5(112.68,82.94) ; v5(127.45,77.55) 127.47,77.57 v6(127.85,77.57) ; v6(125.87,61.85) v5(126.2,61.77) ; v6(86.39,86.42) v5(86.15,86.66) ; v6(84.02,85.12) v5(83.79,85.35) ; v14(127.35,79.26) v5(127.59,79.49) ; v5(97.03,45.65) v13(97.26,45.42) ; v5(97.88,67.27) v15(98.21,67.27) ; v5(96.54,64.47) v8(96.87,64.47) ; v6(86.5,59.24) v5(86.17,59.17) ; v14(104.9,85.12) v5(105.14,85.35) ; v6(98.31,59.89) v5(97.98,59.97) ; v5(85.58,67.65) v15(85.91,67.65) ; v14(117.29,78.61) v5(117.53,78.84) ; v6(80.53,65.57) v5(80.3,65.8) ; v6(108.11,69.8) v5(107.88,70.03) ; v14(129.82,85.46) v5(130.06,85.69) ; v14(127.35,79.91) v5(127.59,80.14) ; v14(104.01,83.17) v5(104.25,83.4) ; v15(89.72,75.65) v5(89.26,75.65) v15(88.78,75.65) ; v6(106.28,65.9) v5(106.05,66.13) ; v6(79.19,77.31) v5(78.96,77.54) ; v5(89.4,66.57) v15(89.07,66.57) ; v6(106.28,69.8) v5(106.05,70.03) ; v6(89.25,80.56) v5(89.02,80.79) ; v5(85.63,72.68) v15(85.3,72.68) ; v6(104.45,64.6) v5(104.22,64.83) ; v6(75.27,78.17) v5(75.04,78.4) ; v14(83.24,86.42) v5(83,86.66) ; v14(119.12,79.91) v5(119.36,80.14) ; v14(116.38,79.91) v5(116.61,80.14) ; v6(80.87,83.17) v5(80.64,83.4) ; v14(96.26,79.91) v5(96.03,80.14) ; v6(83.35,62.55) v5(83.12,62.78) ; v14(113.64,81.86) v5(113.87,82.09) ; v5(96.29,75.65) v15(95.89,75.65) ; v6(128.5,77.61) v5(128.27,77.84) ; v14(111.81,79.26) v5(112.04,79.49) ; v14(98.98,83.17) v5(99.22,83.4) ; v14(125.02,85.77) v5(124.79,86.01) ; v14(113.64,82.51) v5(113.4,82.74) ; v14(126.44,77.96) v5(126.67,78.19) ; v14(107.23,79.26) v5(106.78,79.49) ; v14(99.87,86.42) v5(100.11,86.66) ; v6(130.45,77.61) v5(130.22,77.84) ; v14(129.8,82.33) v5(130.03,82.57) ; v14(112.45,84.47) v5(112.68,84.7) ; v14(99.92,80.56) v5(99.69,80.79) ; v6(114.85,59.24) v5(115.18,59.17) ; v5(92.43,62.57) 92.51,62.62 v6(92.8,62.55) ; v6(84.68,79.26) v5(84.45,79.49) ; v6(88.86,59.89) v5(88.53,59.97) ; v14(91.02,51.73) v5(91.25,51.97) ; v6(106.28,71.1) v5(106.05,71.33) ; v14(130.45,79.18) v5(130.68,79.42) ; v14(119.99,84.47) v5(120.22,84.7) ; v14(108.15,82.51) v5(107.92,82.74) ; v14(104.9,84.47) v5(105.14,84.7) ; v6(80.53,63.99) v5(80.3,64.23) ; v6(39.03,46.36) v5(38.8,46.59) ; v14(99.01,79.26) v5(98.55,79.49) ; v5(90.64,74.8) v15(90.3,74.8) ; v6(80.13,82.51) v5(79.9,82.74) ; v6(110.12,59.89) v5(110.45,59.97) ; v14(99.87,85.12) v5(100.11,85.35) ; v5(97.03,50.8) v13(97.26,50.56) ; v14(91.8,50.16) v5(92.04,50.39) ; v14(97.18,81.21) v5(96.94,81.44) ; v6(132.4,66.58) v5(132.48,66.92) ; v6(82.45,85.12) v5(82.21,85.35) ; v14(97.18,79.91) v5(96.94,80.14) ; v14(107.42,85.77) v5(107.65,86.01) ; v6(90.78,84.47) v5(90.55,84.7) ; v5(96.54,65.87) v8(96.87,65.87) ; v14(107.42,85.12) v5(107.65,85.35) ; v14(95.2,80.56) 94.85,80.56 v5(94.74,80.45) ; v6(129.8,65.8) v5(129.88,66.13) ; v6(75.27,73.44) v5(75.04,73.68) ; v6(83.35,59.89) v5(83.12,60.13) ; v14(100.2,50.95) v5(100.43,51.18) ; v6(94.38,57.29) v5(94.05,57.37) ; v6(38.26,47.91) v5(38.02,48.14) ; v6(36.71,44.81) v5(36.47,45.04) ; v6(129.15,65.8) v5(129.07,66.13) ; v6(90.32,79.26) v5(90.08,79.49) ; v14(127.53,83.82) v5(127.77,84.05) ; v14(80.87,85.12) v5(80.64,85.35) ; v5(98.49,69.76) v15(98.15,69.76) ; v6(76.57,75.8) v5(76.34,76.04) ; v14(122.5,83.17) v5(122.27,83.4) ; v14(102.39,85.77) v5(102.62,86.01) ; v14(127.79,86.42) v5(128.02,86.66) ; v14(108.15,80.56) v5(107.92,80.79) ; v6(113.27,64.5) v5(113.6,64.42) ; v6(107.76,59.89) v5(108.09,59.97) ; v5(88.84,71.75) v15(89.19,71.75) ; v5(97.87,73.1) v15(98.22,73.1) ; v6(104.45,67.2) v5(104.22,67.43) ; v5(98.54,72.15) v15(98.21,72.15) ; v5(96.55,71.75) v15(96.9,71.75) ; v6(82.57,57.29) v5(82.33,57.53) ; v6(104.45,72.4) v5(104.22,72.63) ; v14(105.41,80.56) v5(105.17,80.79) ; v6(90.78,83.82) v5(90.55,84.05) ; v5(120.81,67.9) v15(120.43,67.9) ; v6(87.29,57.29) v5(86.96,57.37) ; v14(109.98,78.61) v5(110.21,78.84) ; v14(105.41,82.51) v5(105.17,82.74) ; v14(125.37,51.26) v5(125.6,51.5) ; v6(77.22,81.32) v5(76.99,81.55) ; v6(121.15,61.85) v5(121.48,61.77) ; v5(117.95,50.22) v13(117.71,50.46) ; v6(89.28,81.86) v5(89.04,82.09) ; v6(88.08,62.55) v5(87.75,62.63) ; v14(33.61,44.04) v5(33.38,44.27) ; v14(96.29,82.51) v5(96.05,82.74) ; v6(76.57,82.1) v5(76.34,82.34) ; v5(102.66,64.85) v8(102.33,64.85) ; v5(114.74,76.41) v15(114.36,76.41) ; v5(94.66,67.65) v8(94.33,67.65) ; v6(120.36,56.64) v5(120.69,56.57) ; v5(122.15,82.72) 122.07,82.72 v14(121.87,82.51) ; v5(102.68,73.48) v15(102.35,73.48) ; v14(110.82,83.17) v5(111.05,83.4) ; v6(90.32,81.21) v5(90.08,81.44) ; v6(128.5,73.67) v5(128.27,73.91) ; v6(79.17,70.29) v5(78.94,70.53) ; v5(97.49,50.16) v13(97.26,49.93) ; v5(86,73.63) v15(85.67,73.63) ; v14(99.92,79.26) v5(99.69,79.49) ; v6(95.68,86.42) 95.42,86.16 v5(95.4,86.16) ; v14(75.07,51.81) v5(75.3,52.05) ; v6(90.78,86.42) v5(90.55,86.66) ; v6(81.78,62.55) v5(81.78,62.95) ; v14(100.2,51.73) v5(100.43,51.97) ; v14(96.26,81.21) v5(96.03,81.44) ; v14(99.87,84.47) v5(100.11,84.7) ; v6(93.59,59.89) v5(93.26,59.97) ; v6(129.8,63.44) v5(129.88,63.77) ; v6(87.17,85.12) v5(86.94,85.35) ; v5(112.06,72.58) v15(111.82,72.81) ; v14(117.48,85.77) v5(117.71,86.01) ; v6(81.02,80.56) v5(80.79,80.79) ; v5(116.63,74.5) v15(117.01,74.5) ; v5(82.57,73.81) v15(82.9,73.81) ; v5(82.53,76.28) v15(82.86,76.28) ; v6(77.22,75.02) v5(76.99,75.25) ; v14(121.87,79.26) v5(122.1,79.49) ; v6(127.45,65.15) v5(127.78,65.22) ; v6(125.87,62.5) v5(126.2,62.57) ; v6(79.17,68.72) v5(78.94,69.03) ; v6(82.85,80.56) v5(82.62,80.79) ; v6(128.5,74.46) v5(128.27,74.69) ; v14(124.61,82.51) v5(124.84,82.74) ; v14(131.75,82.33) v5(131.98,82.57) ; v6(32.9,43.41) v5(32.67,43.64) ; v14(115.46,79.26) v5(115.7,79.49) ; v6(37.48,43.26) v5(37.25,43.49) ; v6(130.45,76.03) v5(130.22,76.27) ; v5(120.23,86.66) v14(119.99,86.42) ; v6(87.42,80.56) v5(87.19,80.79) ; v6(118.79,61.85) v5(119.12,61.77) ; v14(111.56,83.17) v5(111.32,82.94) ; v5(94,64.47) v8(94.33,64.47) ; v6(86.51,81.21) v5(86.27,81.44) ; v14(119.12,81.21) v5(119.36,81.44) ; v14(37.48,44.04) v5(37.25,44.27) ; v6(34.38,47.91) v5(34.15,48.14) ; v5(90.88,69.7) v15(90.54,69.7) ; v14(100.83,79.26) v5(100.38,79.49) ; v5(90.48,63.46) v15(90.15,63.46) ; v5(85.58,65.11) v15(85.91,65.11) ; v5(89.52,72.13) v15(89.18,72.13) ; v5(97.03,46.92) v13(97.26,46.69) ; v14(123.69,79.26) v5(124.15,79.49) ; v5(139.86,67.01) v15(140.24,67.01) ; v14(119.99,85.12) v5(120.22,85.35) ; v6(88.34,79.26) v5(88.1,79.49) ; v6(35.16,44.81) v5(34.93,45.04) ; v14(112.77,97.89) v5(113.17,97.49) ; v6(77.29,86.42) v5(77.05,86.66) ; v5(139.86,61.93) v15(140.24,61.93) ; v6(96.74,56.64) v5(96.41,56.57) ; v14(119.1,83.17) 119.33,83.4 ; v14(130,83.25) v5(130.24,83.49) ; v14(99.92,79.91) v5(99.69,80.14) ; v5(89.4,65.3) v15(89.07,65.3) ; v14(101.75,79.26) v5(101.29,79.49) ; v14(112.45,86.42) v5(112.68,86.66) ; v6(77.22,70.29) v5(76.99,70.53) ; v5(90.48,64.85) v15(90.15,64.85) ; v5(105.22,82.14) 105.41,81.96 v14(105.41,81.86) ; v14(113.64,79.26) v5(113.87,79.49) ; v6(120.36,64.5) v5(120.69,64.42) ; v14(34.38,44.04) v5(34.15,44.27) ; v6(81.78,59.89) v5(81.54,60.13) ; v5(102.67,72.15) v15(102.34,72.15) ; v5(89.5,73.44) v15(89.16,73.44) ; v5(139.86,55.58) v15(140.24,55.58) ; v6(110.12,59.24) v5(110.45,59.17) ; v6(110.91,56.64) v5(111.24,56.57) ; v6(106.28,76.3) v5(106.05,76.54) ; v14(126.44,79.26) v5(126.89,79.49) ; v6(87.45,82.51) v5(87.21,82.74) ; v5(112.11,70.6) v15(111.87,70.83) ; v14(132.4,79.18) v5(132.63,79.42) ; v6(63.04,68) 63.04,68.2 v5(63.22,68.38) 63.42,68.18 v6(63.42,68) ; v6(80.53,68.72) 80.3,68.95 ; v5(116.63,75.52) v15(117.01,75.52) ; v6(104.45,71.1) v5(104.22,71.33) ; v6(77.22,73.44) v5(76.99,73.68) ; v14(132.4,76.03) v5(132.17,76.27) ; v6(30.08,42.26) v5(29.85,42.5) ; v5(85.58,66.38) v15(85.91,66.38) ; v14(129.9,84.81) v5(130.13,85.04) ; v14(36.71,45.58) v5(36.47,45.82) ; v6(85.72,62.55) v5(85.38,62.63) ; v6(34.38,47.13) v5(34.15,47.37) ; v14(100.76,83.17) v5(101,83.4) ; v14(127.35,80.56) v5(127.59,80.79) ; v14(114.96,86.42) v5(115.19,86.66) ; v6(97.53,61.9) v5(97.2,61.82) ; v5(89.53,74.74) v15(89.19,74.74) ; v14(129.15,78.4) v5(129.38,78.63) ; v14(91.02,50.16) v5(91.25,50.39) ; v6(105.37,76.3) v5(105.13,76.54) ; v14(114.96,85.77) v5(115.19,86.01) ; v14(126.44,78.61) v5(126.67,78.84) ; v5(120.81,66.5) v15(120.43,66.5) ; v5(89.88,70.77) v15(89.54,70.77) ; v5(113.34,76.41) v15(112.96,76.41) ; v5(89.82,65.87) v15(90.15,65.87) ; v6(39.03,44.81) v5(38.8,45.04) ; v14(119.12,79.26) v5(119.36,79.49) ; v6(132.4,77.61) v5(132.17,77.84) ; v14(99.92,82.51) v5(99.69,82.74) ; v14(126.16,51.26) v5(126.39,51.5) ; v14(102.66,80.56) v5(102.43,80.79) ; v5(96.29,76.28) v15(95.89,76.28) ; v6(122.72,65.15) v5(123.05,65.22) ; v6(124.3,59.89) v5(124.63,59.97) ; v5(102,65.87) v8(102.33,65.87) ; v6(38.26,45.58) v5(38.02,45.82) ; v5(121.31,74.5) v15(121.69,74.5) ; v14(109.98,79.26) v5(110.21,79.49) ; v6(79.3,85.12) v5(79.07,85.35) ; v5(97.49,46.29) v13(97.26,46.06) ; v6(93.59,59.24) v5(93.26,59.17) ; v6(128.5,72.1) v5(128.27,72.33) ; v14(91.8,50.95) v5(92.04,51.18) ; v6(104.45,65.9) v5(104.22,66.13) ; v5(102,73.09) v15(102.35,73.09) ; v5(85.6,71.35) v15(85.27,71.35) ; v6(88.85,85.77) v5(88.62,86.01) ; v14(99.92,81.21) v5(99.69,81.44) ; v5(120.32,74.5) v15(120.7,74.5) ; v6(132.4,64.22) v5(132.48,64.55) ; v5(89.96,74.42) v15(90.31,74.42) ; v5(139.11,54.44) v15(139.49,54.44) ; v6(83.79,82.51) v5(83.56,82.74) ; v6(33.61,43.26) v5(33.38,43.49) ; v14(121.87,80.56) v5(121.57,80.85) ; v5(96.54,73.09) v15(96.89,73.09) ; v6(126.66,59.24) v5(126.99,59.17) ; v6(109.34,57.94) v5(109.67,58.02) ; v14(125.37,49.69) v5(125.6,49.92) ; v6(84.14,56.64) v5(83.91,56.88) ; v6(116.42,61.85) v5(116.75,61.77) ; v6(78.52,75.8) v5(78.29,76.04) ; v5(97.4,70.74) v15(97.06,70.74) ; v6(84.93,57.94) v5(84.69,58.18) ; v15(94.19,69.69) v5(93.77,69.69) v15(93.34,69.69) ; v14(97.18,80.56) v5(96.94,80.79) ; v6(82.57,60.55) v5(82.84,60.82) ; v5(96.55,74.41) v15(96.9,74.41) ; v14(99.41,50.16) v5(99.65,50.39) ; v5(90.48,67.65) v15(90.15,67.65) ; v14(86.13,51.73) v5(86.37,51.97) ; v14(99.87,83.82) v5(100.11,84.05) ; v14(130.45,82.33) v5(130.68,82.57)
  GND3 w0.508: v6(103.55,29.8) 103.42,30.07 103.4,30.11 v5(103.42,30.15)
  IN3 w0.305: v6(77.22,70.29) 76.57,70.94 v6(76.57,71.08) 75.79,71.87 v6(75.27,71.87) v6(75.27,73.44) v6(75.27,75.02) v6(75.27,76.59) v6(75.27,78.17) v6(75.27,79.74) v6(75.27,81.32) 75.27,81.62 75.27,81.62 75.27,83.65 v6(75.27,83.65) 75.27,88.61 71.19,92.7 71.19,94.3 70.61,94.87 70.27,94.87 66.46,98.68 57.14,98.68 56.03,99.79 45.81,99.79 42.81,96.8 42.81,94.07 43.43,93.46 43.43,92.72 44.29,91.86 48.08,91.86 48.74,91.2 48.74,86.44 v8(48.63,86.34) ; v8(48.24,82.95) 48.81,82.95 50.92,85.06 50.92,89.6 51.54,90.23 51.66,90.23 v9(51.71,90.28) 51.76,90.23 52.09,90.23 53.38,91.52 v9(53.39,91.52) 53.67,91.8 v9(54.02,91.8) 54.66,92.44 62.23,92.44 v6(62.38,92.28) 62.78,91.88 63.62,91.88 64.89,90.61 64.89,89.53 68.2,86.23 68.2,82.32 69.1,81.42 69.1,79.7 69.59,79.2 69.59,68.89 v6(69.49,68.79) 69.49,68.09 v13(69.59,67.99)
  GND4 w0.203: 4.39,56.55 JCR1.22 ; JCR1.22 5.5,56.55 ; JCR1.22 5.5,57.94 ; JCR1.22 6.61,56.55 ; JCR1.22 6.61,57.94 ; JCR1.22 6.61,57.25 ; JCR1.22 4.39,57.25 ; JCR1.22 4.39,57.94 ; 151.19,33.35 H28.1 ; H28.1 152.77,29.61 ; H28.1 150.61,31.77 ; H28.1 154.93,31.77 ; H28.1 151.19,30.19 ; H28.1 154.35,33.35 ; H28.1 154.35,30.19 ; H28.1 152.77,33.93 ; 4.39,70.95 JCR1.23 ; JCR1.23 4.39,72.34 ; JCR1.23 6.61,72.34 ; JCR1.23 6.61,70.95 ; JCR1.23 6.61,71.65 ; JCR1.23 5.5,70.95 ; JCR1.23 4.39,71.65 ; JCR1.23 5.5,72.34 ; JUSBC2.3 3.15,105.22 ; JUSBC2.3 1.96,105.22 ; JUSBC2.3 4.34,105.22 ; JUSBC2.3 4.34,103.82 ; JUSBC2.3 1.96,103.82 ; JUSBC2.3 3.15,103.82 ; JUSBC2.3 4.34,104.52 ; JUSBC2.3 1.96,104.52 ; 151.77,109.39 H16.1 ; H16.1 152.93,112.11 ; H16.1 150.61,112.11 ; H16.1 153.33,110.95 ; H16.1 150.61,109.79 ; H16.1 151.77,112.51 ; H16.1 152.93,109.79 ; H16.1 150.21,110.95 ; H5.1 16.34,14.87 ; H5.1 15.79,16.37 ; H5.1 12.77,13.36 ; H5.1 12.77,16.37 ; H5.1 14.28,12.81 ; H5.1 14.28,16.92 ; H5.1 12.22,14.87 ; H5.1 15.79,13.36 ; 1.96,77.42 JUSBC1.4 ; JUSBC1.4 4.34,77.42 ; JUSBC1.4 1.96,76.02 ; JUSBC1.4 1.96,76.72 ; JUSBC1.4 3.15,77.42 ; JUSBC1.4 4.34,76.72 ; JUSBC1.4 3.15,76.02 ; JUSBC1.4 4.34,76.02 ; 7.24,101.52 JUSBC2.B12 ; JUSBC2.B12 7.33,101.89 ; JUSBC2.B12 8.07,101.15 ; JUSBC2.B12 7.7,101.06 ; JUSBC2.B12 8.16,101.52 ; JUSBC1.3 3.15,89.02 ; JUSBC1.3 3.15,87.62 ; JUSBC1.3 4.34,87.62 ; JUSBC1.3 4.34,89.02 ; JUSBC1.3 4.34,88.32 ; JUSBC1.3 1.96,87.62 ; JUSBC1.3 1.96,88.32 ; 133.04,15.5 BAT100.13 ; BAT100.13 133.71,16.48 ; BAT100.13 132.36,15.5 ; BAT100.13 132.36,16.48 ; BAT100.13 133.04,17.46 ; BAT100.13 132.36,17.46 ; BAT100.13 133.71,17.46 ; BAT100.13 133.71,15.5 ; JUSBC2.1 8.51,104.22 ; JUSBC2.1 7.38,104.22 ; JUSBC2.1 7.38,102.82 ; JUSBC2.1 8.51,103.52 ; JUSBC2.1 6.24,104.22 ; JUSBC2.2 8.51,93.92 ; JUSBC2.2 7.38,93.22 ; JUSBC2.2 6.24,93.22 ; JUSBC2.2 7.38,94.62 ; JUSBC2.2 8.51,93.22 ; 6.05,1.97 H7.1 ; H7.1 8.37,1.97 ; H7.1 6.05,4.29 ; H7.1 7.21,1.57 ; H7.1 5.65,3.13 ; H7.1 8.37,4.29 ; H7.1 8.77,3.13 ; H7.1 7.21,4.69 ; 12.71,107.64 H26.1 ; H26.1 11.81,107.95 ; H26.1 13.92,108.85 ; H26.1 11.5,108.85 ; H26.1 13.61,107.95 ; H26.1 11.81,109.75 ; H26.1 12.71,110.06 ; H26.1 13.61,109.75 ; 70.05,99.2 H27.1 ; H27.1 71.57,99.2 ; H27.1 71.81,98.44 ; H27.1 70.05,97.68 ; H27.1 71.57,97.68 ; H27.1 69.81,98.44 ; H27.1 70.81,99.44 ; H27.1 70.81,97.44 ; JUSBC1.2 7.38,78.42 ; JUSBC1.2 8.51,77.72 ; JUSBC1.2 8.51,77.02 ; JUSBC1.2 6.24,77.02 ; JUSBC1.2 7.38,77.02 ; 7.33,95.55 JUSBC2.B1 ; JUSBC2.B1 7.24,95.92 ; JUSBC2.B1 8.07,96.29 ; JUSBC2.B1 7.7,96.38 ; 11.66,0.59 H20.1 ; H20.1 11.66,1.9 ; H20.1 12.71,3.21 ; H20.1 13.76,3.21 ; H20.1 13.76,1.9 ; H20.1 12.71,0.59 ; H20.1 11.66,3.21 ; H20.1 13.76,0.59 ; 117.61,15.5 BAT100.11 ; BAT100.11 117.61,16.48 ; BAT100.11 117.61,17.46 ; BAT100.11 118.29,17.46 ; BAT100.11 118.96,17.46 ; BAT100.11 118.96,15.5 ; BAT100.11 118.29,15.5 ; BAT100.11 118.96,16.48 ; 151.26,73.47 H4.1 ; H4.1 149.75,77.04 ; H4.1 152.77,77.04 ; H4.1 152.77,74.02 ; H4.1 153.32,75.53 ; H4.1 149.2,75.53 ; H4.1 149.75,74.02 ; H4.1 151.26,77.59 ; 6.56,89.06 H3.1 ; H3.1 5,90.62 ; H3.1 5.4,91.78 ; H3.1 7.72,89.46 ; H3.1 8.12,90.62 ; H3.1 6.56,92.18 ; H3.1 7.72,91.78 ; H3.1 5.4,89.46 ; BAT100.12 118.29,13.98 ; BAT100.12 117.61,13.98 ; BAT100.12 118.96,13.01 ; BAT100.12 118.96,12.03 ; BAT100.12 118.96,13.98 ; BAT100.12 118.29,12.03 ; BAT100.12 117.61,12.03 ; 7.7,84.86 JUSBC1.B12 ; JUSBC1.B12 7.33,85.69 ; JUSBC1.B12 7.24,85.32 ; JUSBC1.B12 8.16,85.32 ; JUSBC1.B12 8.07,84.95 ; JUSBC2.4 4.34,92.22 ; JUSBC2.4 3.15,93.62 ; JUSBC2.4 3.15,92.22 ; JUSBC2.4 4.34,93.62 ; JUSBC2.4 1.96,92.92 ; JUSBC2.4 1.96,93.62 ; JUSBC2.4 4.34,92.92 ; 6.34,73.36 H6.1 ; H6.1 6.34,75.68 ; H6.1 9.06,74.52 ; H6.1 7.5,72.96 ; H6.1 5.94,74.52 ; H6.1 8.66,75.68 ; H6.1 7.5,76.08 ; H6.1 8.66,73.36 ; 7.24,79.72 JUSBC1.B1 ; JUSBC1.B1 7.33,79.35 ; JUSBC1.B1 7.7,80.18 ; JUSBC1.B1 8.07,80.09 ; 6.34,107.88 H1.1 ; H1.1 8.66,107.88 ; H1.1 7.5,108.28 ; H1.1 5.94,106.72 ; H1.1 7.5,105.16 ; H1.1 6.34,105.56 ; H1.1 8.66,105.56 ; H1.1 9.06,106.72 ; 132.36,13.98 BAT100.14 ; BAT100.14 133.71,13.01 ; BAT100.14 133.71,12.03 ; BAT100.14 133.04,12.03 ; BAT100.14 133.71,13.98 ; BAT100.14 133.04,13.98 ; BAT100.14 132.36,12.03 ; BAT100.14 132.36,13.01 ; JUSBC1.1 7.38,88.02 ; JUSBC1.1 7.38,86.62 ; JUSBC1.1 8.51,88.02 ; JUSBC1.1 6.24,88.02 ; JUSBC1.1 8.51,87.32
  GND4 w0.254: v15(32.1,68.79) 32.18,68.71 v14(32.18,68.53)
  BOTTOM w0.127: UH4.AR42 v6(30.94,56.04) ; v17(44.12,49.31) v6(44.26,49.7) ; v17(44.12,48.13) v14(44.34,48.46) ; UH4.AU1 v14(29.86,35.16) ; v16(76.79,108.59) 76.6,108.59 v9(76.23,108.22) ; v6(29.76,57.53) 29.76,57.3 29.87,57.19 UH4.AU45 ; v14(66.65,14.46) 67.67,14.46 v16(67.8,14.33) ; v14(46.44,53.27) UH4.B37 47.45,53.27 UH4.A37 ; v6(161.71,15.96) 161.71,16.65 v16(161.24,17.12) ; UH4.AG4 34.54,37.17 v6(34.22,37.34) ; UT2.A6 v14(33.25,83.98) ; UH4.BB11 v6(27.03,40.59) ; v6(46.61,52.13) UH4.D35 ; CD299.2 136.31,92.8 v16(136.3,92.79) ; UH4.BB34 v6(27.03,51.95) ; v17(32.9,44.59) v6(32.71,44.23) ; UH4.AK4 33.15,37.27 v6(33.15,37.32) ; UH4.BB16 v6(27.03,42.86) ; v6(35.48,36.53) 35.66,36.71 UH4.AE4 ; UH4.AC45 v6(36.72,57.58) ; UH4.AP4 v6(31.11,36.68) ; v17(44.12,47.03) v6(43.8,46.49)
  BOTTOM w0.145: JNGFF2.27 96.83,12.12 v9(96.67,11.96) ; JNGFF2.39 v9(96.67,15.12) ; JNGFF2.15 v9(96.67,9.12)
  BOTTOM w0.152: v14(45.61,47.43) 45.76,47.58 UH4.D25 ; UH4.A32 47.81,50.9 v14(47.88,50.83) ; UH4.AY45 28.25,57.6 v14(28.01,57.84) ; UH4.BE14 25.84,41.82 25.84,41.83 25.57,41.82 v14(25.56,41.81) ; v9(39.48,75.23) 39.4,75.23 39.23,75.4 UT2.R23 ; UH4.AM45 v6(32.17,57.55) ; UT2.W23 v6(41.07,75.7) ; UT2.AC10 v14(43.45,82.14) ; UH4.V45 v14(38.99,57.64) ; v14(25.5,39.45) 25.57,39.52 UH4.BE9 ; UT2.N23 v9(38.31,75.51) ; v14(43.45,81.22) UT2.AC12 UT2.AB12 42.08,81.22 ; UH4.BE18 24.49,44.09 v14(24.43,44.15) ; UT2.J23 36.47,75.56 v9(36.4,75.49) ; v9(32.3,84.09) 32.41,83.98 UT2.A6 ; UT2.AA23 v6(41.99,75.72) ; v14(34.54,35.24) 34.54,35.43 UH4.AH1 ; UH4.T2 UH4.T1 40.21,35.31 v6(40.33,35.18) ; UT2.AC22 43.17,76.62 v9(43.43,76.36) ; v9(43.45,77.54) UT2.AC20 UT2.AB20 42,77.54 ; UH4.BE32 v14(25.43,50.91) ; v6(40.15,75.46) UT2.U23 ; v6(24.96,48.67) 25.21,48.67 25.24,48.64 UH4.BE28 ; v14(41.07,57.47) 41.26,57.28 UH4.P45 ; v14(47.9,53.37) 47.73,53.2 UH4.A37 ; UT2.AB6 UT2.AC6 v14(43.45,83.98) ; 42.01,80.3 UT2.AB14 UT2.AC14 v9(43.45,80.3) ; UT2.G23 v9(35.55,75.51) ; v14(25.25,46.19) 25.32,46.27 25.8,46.27 UH4.BE23 ; 42.04,78.46 UT2.AB18 UT2.AC18 v9(43.45,78.46) ; UH4.AC1 v14(36.7,35.16) ; 42.06,79.38 UT2.AB16 UT2.AC16 v9(43.45,79.38) ; UT2.AC8 v14(43.45,83.06) ; UH4.D30 46.03,50.3 v14(46.13,50.4) ; UH4.BE37 v14(25.5,53.21)
  BOTTOM w0.178: v14(33.25,78.46) UT2.A18 v9(32.18,78.46) ; v9(32.2,81.22) UT2.A12 v14(33.25,81.22) ; 41.92,84.15 42.09,83.98 UT2.AB6 ; v6(34.2,57.49) 34.26,57.49 34.44,57.31 UH4.AH45 ; v14(33.25,80.3) UT2.A14 v9(32.25,80.3) ; v14(33.25,79.38) UT2.A16 v9(32.18,79.38) ; UT2.A20 v9(32.12,77.54) ; v14(33.25,83.06) UT2.A8 v9(32.23,83.06) ; v14(33.25,82.14) UT2.A10 v9(32.23,82.14) ; v9(32.2,76.49) 32.33,76.62 UT2.A22 ; v14(34.62,75.55) 34.63,75.55 UT2.E23
  BOTTOM w0.203: v9(147.77,53.69) 147.8,53.69 147.83,53.72 PU1300.13 ; UH4.AA42 v6(37.76,56.04) ; v6(112.67,36.42) 112.73,36.36 PU1200.13 ; UH4.AA4 v6(37.93,36.68) ; v6(119.86,36.16) 120,36.02 120.3,36.02 120.37,35.95 PU1201.13 ; PU1302.13 105.87,37.31 v6(105.79,37.39) ; UH4.T4 v6(40.21,36.68) ; PU1301.13 v9(148.29,63.52) ; PR605.2 14.72,23.23 PR606.2 13.85,23.23 13.48,22.87 v3(13.18,22.87) ; UH4.AE42 v6(35.48,56.04) ; v17(41.74,36.96) 41.74,37.55 v6(41.8,37.6) ; v14(127.05,37.53) 127.23,37.35 PU1202.13 ; UH4.A25 v14(47.95,47.58) ; UH4.L4 v6(42.48,36.68)
  BOTTOM w0.254: v6(10.94,83.27) v6(11.31,83.27) v6(11.69,83.27) ; UE2.16 v3(21.59,8.36) ; v6(11.72,86.63) 11.72,86.63 v6(11.72,86.63) ; v6(11.72,86.63) v6(11.31,86.63) ; UE2.32 25.09,15.5 v9(25.26,15.66) ; v6(11.69,99.45) v6(11.31,99.45) v6(10.94,99.45) ; v6(11.31,78.38) v6(11.31,78.02) ; v6(11.31,78.38) v6(10.94,78.38) ; v6(11.31,78.38) v6(11.69,78.38) ; v6(44.08,39.26) 44.18,39.36 v17(44.64,39.36) ; v6(11.31,94.91) v6(11.71,94.91) ; v6(11.31,94.91) v6(10.94,94.91) ; v6(11.31,94.91) v6(11.31,94.57) ; UH4.J39 43.7,54.29 v14(43.97,54.03) ; v6(11.69,81.74) v6(11.31,81.74) v6(10.94,81.74) ; v6(11.72,84.45) v6(11.31,84.45) v6(10.89,84.45) ; v6(10.94,100.49) v6(11.31,100.49) v6(11.69,100.49) ; UH4.C10 46.11,39.96 v6(46.11,40.02) ; v6(11.31,86.63) v6(10.89,86.63) ; v6(11.31,86.63) v6(11.31,87.01) ; v6(10.94,85.11) v6(11.31,85.11) v6(11.72,85.11) ; UD6.N1 v14(101.98,105.49) ; v6(10.94,79.9) v6(11.31,79.9) v6(11.69,79.9) ; UD1.N1 v14(138.27,105.49) ; UD1.N9 v14(132.67,106.29) ; JNGFF2.51 v9(96.69,18.12) ; v11(121.87,103.49) v14(122.27,103.89) ; v6(11.31,102.57) v6(11.69,102.57) ; v6(11.31,102.57) v6(10.94,102.57) ; v6(11.31,102.57) v6(11.31,102.9) ; v6(25.05,8.97) 25.09,9.01 UE2.9 ; v6(43.04,54.92) 42.89,55.08 UH4.L41 ; UD5.N1 v14(112.37,105.49) ; UD2.N1 v14(127.87,105.49) ; v6(10.94,96.33) v6(11.31,96.33) v6(11.69,96.33) ; CD319.2 130.29,109.73 v9(130.27,109.75) ; v17(36.04,41.99) 35.98,41.99 v6(35.51,42.46) ; v6(110.6,15.35) 111.05,14.9 v17(111.06,14.9) ; RE29.2 29.33,13.29 v14(29.51,13.12) ; UH4.AL13 32.64,41.68 v6(32.61,41.71) ; v6(11.69,96.99) v6(11.31,96.99) v6(10.94,96.99) ; JESPI1.9 24.7,23.1 25.05,22.75 v6(25.74,22.75) ; v14(46.5,49.76) 46.13,49.76 UH4.D30 ; v6(10.94,80.6) v6(11.31,80.6) v6(11.69,80.6) ; UH4.BB25 v14(27.03,47.41) ; v6(10.94,98.03) v6(11.31,98.03) v6(11.69,98.03) ; PC634.2 125.46,26.21 125.37,26.12 125.37,26.1 125.2,25.93 PU602.10 ; UC1.F41 v6(78.52,60.42) ; v11(132.27,103.49) v14(132.67,103.89) ; PU2304.18 v14(148.79,87.87) ; v11(106.37,103.49) v14(106.77,103.89) ; v14(76.43,93.25) 76.55,93.25 77.34,94.04 PU800.4 ; UD2.N9 v14(122.27,106.29) ; v17(41.84,44.59) 41.83,44.59 v6(41.55,44.3) ; v6(11.69,101.15) v6(11.31,101.15) v6(10.94,101.15) ; JNGFF2.3 v14(98.99,6.12) ; JNGFF2.1 v14(98.93,5.62)
  BOTTOM w0.305: 89.38,109.24 88.48,109.24 v9(88.46,109.23) ; CE43.2 v14(48.55,8.85) ; v9(89.11,103.73) 89.44,104.06 CD337.2 ; CD315.2 133.45,94.67 v6(133.42,94.7) ; U18.5 v14(68.3,17.46) ; CD299.2 136.31,94.1 v9(135.61,94.8) ; JDGPU1.7 v6(69.77,6.94) ; JKB1.26 v14(25.42,8.73) ; U18.6 v14(68.3,16.96) ; CD370.2 v6(114.91,110.11) ; 89.38,108.35 v9(88.41,108.35) ; UD5.N9 v14(106.77,106.29) ; U18.8 v14(67.28,15.96) ; U18.7 v14(67.78,15.91) ; CD361.2 v9(88.4,105.43)
  BOTTOM w0.356: v9(36.3,95.99) 36.15,95.84 PQ201.3 ; PQ202.3 38.69,95.35 v9(39.19,95.85) ; RH531.2 v6(71.6,9.16)
  BOTTOM w0.381: v9(147.77,53.69) 147.68,53.6 PC1306.2 ; v9(21.03,101.91) 20.67,101.56 PC117.2 20.37,102.02 PC122.2 ; CD346.2 v9(103.63,110.38) CD327.2 ; v6(159.87,3.8) 160.19,3.49 JFP1.10 ; 114.91,106.64 115.62,106.64 v6(115.74,106.51)
  BOTTOM w0.406: JCCG1.11 v6(63.36,19.83) ; v9(66.78,5.67) 67.03,5.67 67.27,5.43 JDGPU1.12 ; v6(82.58,4.21) 82.85,4.47 JSPI2.11 ; v9(22.32,24.4) 22.12,24.6 JESPI1.12 ; JSPI2.12 77.11,5.12 v9(77.31,4.92) ; JESPI1.11 v9(20.74,18.1)
  BOTTOM w0.457: PC1309.2 148.29,62.98 v9(148.29,63.52)
  BOTTOM w0.508: v9(22.07,4.65) 22.68,5.26 JKB1.28 ; v9(94.01,93.05) UC8.4 ; PQ133.3 38.04,100.24 v6(38.37,100.57) ; v3(7.16,27.32) v16(7.16,26.82) PC605.1 ; PC1413.2 135.53,50.08 136.38,50.93 v6(136.38,50.93) ; YC1.2 84.98,52.2 85.57,52.79 v9(85.82,52.79) ; v9(90.12,103.21) 90.6,103.69 CD342.2 ; v9(126.21,27.14) 125.93,26.85 PC634.2 ; v9(148.14,36.11) 148.06,36.11 JFAN1.7 ; RH81.2 v6(134.33,53.17) ; v9(40.31,99.38) 40.37,99.45 PQ132.3 ; v9(168.94,1.73) 168.61,2.07 JRTC1.3 ; PC1406.2 136.83,48.32 v6(137.39,47.76) ; v9(148.56,109.15) JCAM1.21 146.71,109.15 ; PC1300.2 148.82,61.8 v9(148.36,61.35)
  vias: v2(8.54,26.12) v2(14.25,30.26) v2(14.25,29.93) v2(14.25,29.57) v2(14.25,29.22) v2(15.47,29.95) v2(15.47,29.57) v2(15.47,29.17) v2(16.33,20.66) v2(16.67,29.61) v2(18.18,29.98) v2(18.18,29.6) v2(18.18,29.22) v2(19.22,26.75) v2(22.85,72.92) v2(24.33,30.84) v2(24.61,29.17) v2(24.61,28.53) v2(24.61,27.9) v2(24.74,30.84) v2(27.31,31.07) v2(27.63,31.07) v2(37.18,52.57) v2(37.94,52.57) v2(38.71,52.57) v2(39.52,20.28) v2(42.27,20.28) v2(108.12,24.72) v2(134.53,30.18) v2(134.53,27.26) v3(18.18,13.16) v3(19.81,37.06) v3(22.27,41.27) v3(28.88,16.08) v3(29,10.62) v3(32.04,66.5) v3(48.46,98.34) v3(48.54,53.7) v3(49.91,54.26) v3(49.98,56.09) v3(50.9,54.29) v3(53.79,54.13) v3(53.79,52.94) v3(53.82,51.9) v3(53.9,55.3) v3(53.87,54.84) v3(54.94,53.12) v3(75.27,58.81) v3(121.62,83.17) v3(123.53,21) v3(140.76,95.47) v4(32.08,68.66) v4(32.15,67.54) v4(32.18,68.03) v4(32.51,66.88) v4(32.68,68.53) v4(32.68,68.03) v4(32.76,67.19) v4(33.07,67.27) v4(33.18,68.53) v4(33.3,67.87) v4(33.27,66.88) v4(33.6,69.04) v4(33.64,67.99) v4(33.58,66.91) v4(33.68,67.53) v4(34.18,67.03) v4(34.26,67.87) v4(34.52,68.94) v5(16.04,48.28) v5(26.11,65.59) v5(29.49,31.25) v5(32.41,68.26) v5(32.41,67.29) v5(32.95,67.79) v5(33.45,68.28) v5(33.41,67.29) v5(33.91,67.79) v5(33.88,66.76) v5(34.11,68.66) v5(34.24,65.06) v5(34.41,67.29) v5(34.67,67.85) v5(34.7,41.47) v5(34.7,40.7) v5(36.93,67.14) v5(40.74,80.17) v5(40.74,79.53) v5(41.78,49.82) v5(42.71,55.52) v5(44.15,91.55) v5(45.11,46.16) v5(45.26,49.21) v5(45.95,96.3) v5(45.92,91.95) v5(47.11,96.42) v5(47.7,91.95) v5(49.53,96.5) v5(49.53,91.98) v5(50.52,49.66) v5(50.59,47.78) v5(51.3,95.41) v5(51.28,92) v5(52.87,30.22) v5(53.49,47.73) v5(53.57,49.46) v5(56.87,37.74) v5(56.87,35.64) v5(59.03,37.74) v5(59.03,35.64) v5(70.84,54.31) v5(70.84,52.66) v5(70.78,51.42) v5(75.7,86.02) v5(77.17,20.33) v5(77.76,20.34) v5(78.94,64.9) v5(89.57,80.22) v5(89.76,80.98) v5(90.14,80.22) v5(90.65,80.22) v5(90.84,79.33) v5(94.08,83.06) v5(96.9,85.32) v5(97.15,86.9) v5(104.06,11.41) v5(104.06,10.37) v5(105.06,11.33) v6(4.11,66.12) v6(4.11,65.11) v6(5.41,14.1) v6(6.95,62.5) v6(6.95,62.12) v6(6.95,61.74) v6(7.33,62.5) v6(7.33,62.12) v6(7.33,61.74) v6(7.71,62.5) v6(7.71,62.12) v6(7.71,61.74) v6(8.77,37.84) v6(8.77,37.36) v6(8.77,36.57) v6(8.77,36.09) v6(8.77,35.3) v6(8.77,34.82) v6(8.77,34.16) v6(8.77,33.67) v6(9.15,69.11) v6(9.08,37.84) v6(9.08,37.36) v6(9.08,36.57) v6(9.08,36.09) v6(9.08,35.3) v6(9.08,34.82) v6(9.08,34.16) v6(9.08,33.67) v6(9.45,55.02) v6(9.44,54.69) v6(9.45,53.74) v6(9.43,53.41) v6(9.47,66.79) v6(9.78,55.01) v6(9.77,54.67) v6(9.78,53.73) v6(9.76,53.39) v6(10,61.55) v6(10.2,53.71) v6(10.18,53.37) v6(10.26,48.11) v6(10.27,70.66) v6(10.42,52.86) v6(10.53,53.69) v6(10.51,53.35) v6(10.47,47.83) v6(10.61,69.41) v6(10.74,71.74) v6(10.75,52.84) v6(10.79,76.73) v6(10.84,53.47) v6(10.85,53.17) v6(10.87,104.02) v6(10.87,103.74) v6(11.24,74.4) v6(11.39,75.65) v6(11.39,75.34) v6(11.45,72.65) v6(12.37,64.34) v6(12.47,76.71) v6(13.24,77.36) v6(13.26,20.78) v6(13.71,75.66) v6(14.04,49.43) v6(14.03,48.47) v6(14.12,76.68) v6(14.2,32.85) v6(14.2,32.47) v6(14.2,32.09) v6(14.32,27.51) v6(14.32,27.13) v6(14.63,75.66) v6(15.24,77.6) v6(15.47,32.85) v6(15.47,32.47) v6(15.47,32.09) v6(16.42,76.21) v6(16.74,32.78) v6(16.74,32.4) v6(16.74,32.09) v6(17.64,89.77) v6(18.01,76.62) v6(18.08,70.48) v6(18.87,70.06) v6(19.1,8.72) v6(19.4,40.54) v6(19.48,70.06) v6(19.66,94.15) v6(19.71,69.07) v6(19.97,76.62) v6(20.23,94.15) v6(20.25,89.74) v6(20.93,75.42) v6(20.93,75.14) v6(20.93,74.86) v6(21.82,76.65) v6(21.82,13.86) v6(21.82,12.34) v6(21.82,10.81) v6(22.05,69.18) v6(22.51,6.93) v6(22.7,63.82) v6(23.34,13.86) v6(23.34,12.34) v6(23.34,10.81) v6(23.66,89.76) v6(23.57,76.62) v6(24.44,71.07) v6(24.56,66.99) v6(24.62,69.07) v6(24.8,12.34) v6(24.86,13.86) v6(24.86,10.81) v6(24.98,76.62) v6(25.84,34.79) v6(26.02,35.11) v6(26.13,92.36) v6(26.16,89.95) v6(26.07,69.06) v6(26.07,65.98) v6(26.18,76.62) v6(26.18,75.35) v6(26.18,74.08) v6(26.21,34.8) v6(26.34,72.24) v6(27.01,99.49) v6(27.63,91.37) v6(27.63,90.99) v6(27.61,90.18) v6(27.61,89.79) v6(27.61,89.01) v6(27.61,88.63) v6(28.1,72.27) v6(28.3,92.72) v6(29.24,72.27) v6(29.18,31.76) v6(29.44,59.84) v6(29.75,94.05) v6(29.79,95.89) v6(30.16,92.72) v6(30.07,86.96) v6(30.4,97.24) v6(30.52,102.11) v6(30.96,86.96) v6(31.11,72.4) v6(31.68,40.61) v6(31.86,104.91) v6(32,86.7) v6(32.12,103.41) v6(32.15,87.15) v6(32.31,86.37) v6(32.56,95.71) v6(32.53,86.82) v6(32.68,68.03) v6(32.68,67.53) v6(32.91,60.09) v6(33.18,68.03) v6(33.18,67.53) v6(33.18,67.03) v6(33.61,98.11) v6(33.68,69.03) v6(33.68,68.03) v6(33.68,67.53) v6(33.68,67.03) v6(33.95,82.52) v6(33.95,81.87) v6(33.95,81.22) v6(33.95,80.57) v6(33.95,79.92) v6(33.95,79.27) v6(34.18,68.03) v6(34.18,67.53) v6(34.18,67.03) v6(34.6,85.12) v6(34.6,82.52) v6(34.6,79.92) v6(34.6,79.27) v6(35.25,84.47) v6(35.25,82.52) v6(35.25,79.27) v6(35.29,104.03) v6(35.84,92.64) v6(35.9,84.47) v6(35.9,81.22) v6(35.9,80.57) v6(35.9,79.27) v6(36.01,85.82) v6(36.17,72.37) v6(36.55,83.17) v6(36.55,81.22) v6(36.55,80.57) v6(36.55,79.92) v6(36.47,76.62) v6(36.93,85.82) v6(37.11,66.67) v6(37.2,84.47) v6(37.2,80.57) v6(37.2,79.92) v6(37.39,76.62) v6(37.85,81.87) v6(37.85,77.97) v6(38.31,76.62) v6(38.38,92.61) v6(38.5,82.52) v6(38.5,81.87) v6(38.5,81.22) v6(38.5,80.57) v6(38.5,79.92) v6(38.77,85.82) v6(39.15,78.62) v6(39.13,72.28) v6(39.23,76.62) v6(39.66,107.75) v6(39.8,84.47) v6(39.8,83.82) v6(39.8,82.52) v6(39.8,80.57) v6(39.8,79.92) v6(39.8,79.27) v6(39.8,78.62) v6(40.13,73.23) v6(40.33,72.4) v6(40.45,84.47) v6(40.45,83.82) v6(40.45,83.17) v6(40.45,82.52) v6(40.45,79.92) v6(40.45,79.27) v6(40.78,51.39) v6(40.8,37.47) v6(41.1,84.47) v6(41.1,83.82) v6(41.1,83.17) v6(41.1,80.57) v6(41.1,78.62) v6(41.1,77.32) v6(41.07,76.62) v6(41.35,92.61) v6(41.75,80.57) v6(41.75,77.32) v6(41.73,42.29) v6(41.84,45.69) v6(42.3,55.68) v6(42.45,85.82) v6(42.45,82.14) v6(42.44,72.37) v6(42.5,42.29) v6(42.46,41.33) v6(42.91,86.28) v6(43.98,88.51) v6(44.25,90.32) v6(45.49,41.2) v6(45.96,87.39) v6(46.03,45.31) v6(46.03,40.76) v6(46.13,52.67) v6(46.11,51.39) v6(46.11,49.11) v6(46.11,44.57) v6(46.13,43.58) v6(46.44,48.73) v6(47.52,44.08) v6(47.68,85.83) v6(47.89,4.71) v6(48.24,90.76) v6(48.24,89.87) v6(48.29,89.05) v6(49.55,82.78) v6(49.55,80.63) v6(49.55,78.92) v6(49.63,91.52) v6(49.6,74.2) v6(51.03,59.96) v6(51.03,56.15) v6(52.81,81.32) v6(52.89,31.44) v6(54.71,103.38) v6(54.72,76.98) v6(54.72,76.5) v6(54.75,75.66) v6(54.75,75.18) v6(55.03,76.98) v6(55.03,76.5) v6(55.05,75.66) v6(55.05,75.18) v6(56.42,105.43) v6(57.54,45.59) v6(57.86,21.52) v6(59.69,77.81) v6(60.4,6.4) v6(61.74,78.34) v6(61.74,75.8) v6(61.74,73.54) v6(61.74,70.72) v6(61.74,68.18) v6(61.72,55.43) v6(61.79,59.8) v6(62.94,79.99) v6(64.08,81.59) v6(65.68,83.9) v6(66.34,78.62) v6(66.7,80.02) v6(66.7,79.66) v6(66.72,79.3) v6(66.7,78.95) v6(66.7,78.59) v6(67.05,80.02) v6(67.13,85.91) v6(67.08,79.69) v6(67.1,79.3) v6(67.1,78.95) v6(67.1,78.62) v6(67.56,104.98) v6(67.64,76.64) v6(67.64,76.28) v6(67.66,84.23) v6(67.97,76.64) v6(67.99,76.28) v6(68.55,83.98) v6(72.16,93.1) v6(73.77,5.12) v6(75.46,95.01) v6(75.92,60.06) v6(76.49,96.81) v6(76.57,78.95) v6(76.57,60.06) v6(76.67,57.36) v6(77.05,57.94) v6(77.24,92.59) v6(77.25,92.22) v6(77.25,91.9) v6(77.22,79.74) v6(77.22,62.42) v6(77.22,60.84) v6(77.22,59.27) v6(77.37,56.64) v6(77.59,91.98) v6(77.76,91.46) v6(77.77,91.75) v6(77.84,58.59) v6(77.84,57.29) v6(78.14,91.97) v6(78.14,91.59) v6(78.33,92.44) v6(78.46,91.97) v6(78.46,91.59) v6(78.52,78.95) v6(78.52,61.63) v6(78.65,92.44) v6(78.63,58.59) v6(78.63,57.94) v6(78.63,57.29) v6(78.96,110.71) v6(78.88,92.04) v6(78.88,91.73) v6(78.88,91.41) v6(79.19,79.91) v6(79.19,79.26) v6(79.17,76.59) v6(79.4,108.29) v6(79.42,60.55) v6(79.42,58.59) v6(79.65,29.65) v6(80.2,57.94) v6(80.53,75.02) v6(80.53,71.87) v6(80.53,70.29) v6(80.53,67.14) v6(80.99,56.64) v6(81.38,50.11) v6(81.49,19.56) v6(82.27,19.84) v6(82.52,29.67) v6(83.03,19.72) v6(83.12,94.34) v6(83.12,93.47) v6(83.12,92.58) v6(83.92,54.22) v6(84.81,53.47) v6(84.88,29.67) v6(84.97,100.09) v6(85.23,111.68) v6(85.25,99.88) v6(85.45,105.94) v6(85.84,105.94) v6(85.92,90.23) v6(86.2,53.47) v6(86.65,104.03) v6(86.66,98.79) v6(87.03,104.03) v6(87.04,98.79) v6(86.97,53.47) v6(87.04,29.65) v6(87.77,111.68) v6(87.92,104.03) v6(87.93,98.79) v6(88.08,61.9) v6(88.3,104.03) v6(88.31,98.79) v6(88.36,88.44) v6(88.85,84.47) v6(89.13,88.44) v6(89.35,107.49) v6(89.35,106.75) v6(89.58,29.67) v6(90.31,111.68) v6(90.84,89.44) v6(91.6,10.37) v6(91.73,89.44) v6(91.82,84.47) v6(91.97,29.67) v6(92.62,89.44) v6(92.72,10.18) v6(92.85,111.68) v6(93.4,18.86) v6(93.4,18.47) v6(94.28,77.31) v6(94.41,29.67) v6(94.54,18.22) v6(94.47,17.55) v6(94.64,85.12) v6(95.22,82.51) v6(95.2,77.31) v6(95.39,111.68) v6(95.48,16.69) v6(96.26,77.31) v6(96.52,29.7) v6(96.57,85.12) v6(97.18,77.31) v6(97.93,111.68) v6(98.09,77.31) v6(99.01,77.31) v6(99.13,29.72) v6(99.92,77.31) v6(100.47,111.68) v6(100.83,77.31) v6(101.58,101.09) v6(101.65,29.8) v6(101.75,77.31) v6(102.06,13.9) v6(102.38,103.49) v6(102.38,101.89) v6(102.66,77.31) v6(103.01,111.68) v6(103.04,59.24) v6(103.4,76.95) v6(103.4,63.3) v6(103.83,57.29) v6(103.83,56.64) v6(103.91,54.63) v6(103.91,54.06) v6(103.91,53.49) v6(103.91,52.85) v6(104.06,13.9) v6(104.38,102.39) v6(104.45,61.35) v6(104.62,21.99) v6(104.71,54.63) v6(104.71,54.06) v6(105.06,16.9) v6(105.4,59.89) v6(105.4,59.24) v6(105.55,111.68) v6(106.33,27.51) v6(106.33,26.88) v6(106.33,26.18) v6(106.33,25.48) v6(106.41,52.37) v6(106.41,51.15) v6(106.56,54.63) v6(106.56,54.06) v6(106.73,29.83) v6(106.78,27.51) v6(106.78,26.88) v6(106.78,26.18) v6(106.78,25.48) v6(107.06,14.9) v6(107.2,63.3) v6(107.22,27.51) v6(107.22,26.88) v6(107.22,26.18) v6(107.22,25.48) v6(107.67,27.51) v6(107.67,26.88) v6(107.67,26.18) v6(107.67,25.48) v6(107.83,54.63) v6(107.83,54.06) v6(107.92,47.9) v6(107.92,47.52) v6(108.09,111.68) v6(108.11,63.3) v6(108.11,27.51) v6(108.11,26.88) v6(108.11,26.18) v6(108.11,25.48) v6(109.93,86.42) v6(109.93,85.77) v6(109.93,85.12) v6(109.93,84.47) v6(110.06,19.9) v6(110.06,10.9) v6(110.63,111.68) v6(111.06,18.9) v6(111.06,17.9) v6(112.06,18.9) v6(112.06,17.9) v6(112.3,49.1) v6(112.3,48.72) v6(112.3,47.9) v6(112.3,47.52) v6(112.3,31.29) v6(112.3,30.98) v6(112.37,50.06) v6(112.79,31.29) v6(112.79,30.98) v6(113.06,18.9) v6(113.17,111.68) v6(113.52,49.07) v6(113.52,48.68) v6(113.51,31.29) v6(113.51,30.98) v6(113.64,50.06) v6(113.99,31.29) v6(113.99,30.98) v6(115.03,51.58) v6(115.71,111.68) v6(116.05,109.87) v6(116.3,51.58) v6(116.68,52.58) v6(116.87,14.53) v6(118.25,111.68) v6(118.73,108.83) v6(118.68,31.29) v6(118.68,30.98) v6(119.16,31.29) v6(119.16,30.98) v6(119.8,109.24) v6(119.95,31.29) v6(119.95,30.98) v6(120.43,31.29) v6(120.43,30.98) v6(120.79,111.68) v6(123.33,111.68) v6(125.52,48.8) v6(125.87,111.68) v6(125.9,48.8) v6(126.29,48.8) v6(126.69,48.8) v6(126.84,28.44) v6(127.31,77.96) v6(127.28,31.3) v6(127.28,30.99) v6(127.47,101.09) v6(127.47,98.69) v6(127.76,31.3) v6(127.76,30.99) v6(127.99,22.66) v6(127.99,22.35) v6(128.27,101.89) v6(128.41,111.68) v6(128.46,31.38) v6(128.46,31.08) v6(128.37,22.66) v6(128.37,22.35) v6(128.63,27.58) v6(128.94,31.38) v6(128.94,31.08) v6(129.15,69.73) v6(129.26,110.45) v6(129.8,69.73) v6(130.54,50.74) v6(130.95,111.68) v6(131.1,60.29) v6(131.1,59.5) v6(132.27,108.29) v6(133.49,111.68) v6(134.64,11.51) v6(134.64,10.56) v6(134.64,9.48) v6(134.64,8.53) v6(134.64,7.58) v6(134.85,13.86) v6(135.23,13.86) v6(136.03,111.68) v6(136.22,6.69) v6(136.37,43.71) v6(136.37,43.01) v6(137,43.71) v6(137,43.01) v6(137.55,6.69) v6(137.64,43.71) v6(137.64,43.01) v6(137.87,101.09) v6(138.27,43.71) v6(138.27,43.01) v6(138.57,111.68) v6(138.67,103.49) v6(138.67,101.89) v6(140.88,111.33) v6(141.07,109.81) v6(141.2,38.06) v6(141.22,31.07) v6(141.77,105.24) v6(142.02,103.46) v6(142.34,101.05) v6(142.72,97.94) v6(143.1,95.97) v6(143.19,41.42) v6(143.33,111.13) v6(143.29,93.81) v6(144.05,7.13) v6(144.05,6.81) v6(144.03,5.42) v6(144.03,5) v6(144.08,111.22) v6(144.16,104.05) v6(144.16,103.55) v6(144.16,103.05) v6(144.16,99.05) v6(144.16,98.05) v6(144.31,86.95) v6(144.34,5.42) v6(144.34,5) v6(144.37,7.13) v6(144.37,6.81) v6(144.69,84.41) v6(144.97,111.22) v6(145.9,30.4) v6(145.89,30.01) v6(146.06,47.9) v6(146.28,72.98) v6(146.38,30.4) v6(146.37,30) v6(146.71,95.45) v6(146.82,30.39) v6(146.8,30) v6(147.07,42.72) v6(147.11,38.69) v6(147.21,30.4) v6(147.2,30) v6(147.49,47.82) v6(147.49,47.49) v6(148,47.82) v6(148.03,47.49) v6(148.15,71.33) v6(148.22,93.18) v6(148.62,93.3) v6(148.87,38.5) v6(149.04,93.62) v6(148.97,93.28) v6(148.97,92.96) v6(149.31,93.33) v6(149.32,92.98) v6(149.39,93.63) v6(149.66,93.33) v6(149.73,93.65) v6(150.04,93.65) v6(149.99,93.34) v6(150.32,94.43) v6(150.82,71.33) v6(151.33,67.01) v6(151.36,66.68) v6(151.86,67.01) v6(151.86,66.68) v6(153.08,71.25) v6(153.08,68.71) v6(153.08,66.17) v6(153.08,63.63) v6(153.08,61.09) v6(153.08,58.55) v6(153.08,56.01) v6(153.08,53.47) v6(153.08,50.93) v6(153.08,48.39) v6(153.08,45.85) v6(154.47,10.6) v6(154.47,10.28) v6(154.85,10.6) v6(154.85,10.28) v6(155.74,10.6) v6(155.74,10.28) v6(156.12,10.6) v6(156.12,10.28) v6(157.01,10.6) v6(157.01,10.28) v6(157.39,10.6) v6(157.39,10.28) v6(158.28,10.6) v6(158.28,10.28) v6(158.66,10.6) v6(158.66,10.28) v6(161.71,15.64) v6(161.71,14.69) v6(161.71,14.37) v6(162.02,15.96) v6(162.02,15.64) v6(162.02,14.69) v6(162.02,14.37) v6(162.59,4.1) v6(164.07,4.62) v6(166.97,8.42) v7(1.8,61.14) v7(8.63,101.47) v7(8.68,95.98) v7(8.68,85.28) v7(8.68,79.77) v7(9.01,101.47) v7(9.06,79.77) v7(9.06,95.98) v7(9.06,85.28) v7(9.99,93.45) v7(9.99,90.91) v7(9.99,88.37) v7(11.45,74.86) v7(11.45,73.97) v7(11.45,73.08) v7(12.02,93.45) v7(12.02,90.91) v7(12.02,88.37) v7(12.93,24.75) v7(14.21,73.54) v7(14.21,72.9) v7(14.74,71.75) v7(14.74,57.15) v7(15.8,74.4) v7(18.21,65.11) v7(18.21,64.22) v7(18.34,57.62) v7(18.39,23.77) v7(18.6,72.21) v7(18.77,23.77) v7(19.08,23.77) v7(19.4,23.77) v7(19.58,72.66) v7(19.83,61.28) v7(19.83,60.33) v7(19.78,23.77) v7(20.26,93.34) v7(21.07,71.64) v7(21.17,99.57) v7(21.31,26.69) v7(21.31,26.24) v7(21.31,25.48) v7(21.31,24.97) v7(21.37,66.15) v7(21.37,63.92) v7(21.61,102.08) v7(21.61,101.49) v7(21.69,26.69) v7(21.69,26.24) v7(21.69,25.48) v7(21.69,24.97) v7(22.16,91.02) v7(22.21,100.32) v7(22.49,65.04) v7(22.76,54.3) v7(22.88,93.86) v7(23.46,92.62) v7(23.61,66.16) v7(23.61,63.92) v7(23.86,69.61) v7(27.11,95.26) v7(27.07,94.33) v7(27.21,101.11) v7(27.46,55.7) v7(27.67,40.18) v7(28,95.26) v7(28.22,101.64) v7(29.09,94.56) v7(29.27,91.99) v7(29.76,98.2) v7(29.76,53.84) v7(29.94,67.15) v7(30.39,102.11) v7(30.39,101.73) v7(31.66,96.9) v7(32.11,99.56) v7(32.09,70.03) v7(32.09,69.09) v7(32.95,93.44) v7(33.46,97.24) v7(33.94,68.14) v7(34.09,69) v7(34.46,65.34) v7(34.73,94.35) v7(35.07,11.64) v7(35.19,50.82) v7(35.28,54.74) v7(36.29,98.87) v7(36.55,71.27) v7(36.5,67.29) v7(36.72,8.34) v7(37.11,11.85) v7(37.18,74.52) v7(37.23,13.7) v7(37.75,65.88) v7(38.73,22.1) v7(40.61,73.68) v7(41.82,73.69) v7(42.95,22.13) v7(43.32,85.11) v7(43.32,83.84) v7(44.75,17.39) v7(45.01,102.99) v7(45.53,105.67) v7(46.8,101.6) v7(46.83,4.55) v7(46.97,88.09) v7(47.7,86.24) v7(48.27,103.52) v7(48.71,102.76) v7(49.08,105.53) v7(49.42,51.77) v7(49.37,3.03) v7(50.72,53.67) v7(51.53,73.19) v7(52.8,12.38) v7(54.54,38.06) v7(54.54,35.93) v7(54.54,33.81) v7(55.7,12.02) v7(56.66,38.06) v7(56.66,35.93) v7(56.66,33.81) v7(58.78,38.06) v7(58.78,35.93) v7(58.78,33.81) v7(59.03,57.17) v7(59.09,56.66) v7(59.6,56.66) v7(61.76,21.09) v7(62.25,107.22) v7(65.12,83.57) v7(67.84,65.92) v7(68.17,65.92) v7(68.68,65.92) v7(68.93,78.81) v7(69.01,65.92) v7(71.84,106.43) v7(71.84,106.11) v7(72.41,106.43) v7(72.41,106.11) v7(73.08,107.04) v7(73.08,106.72) v7(73.66,107.04) v7(73.66,106.72) v7(74.46,107.08) v7(74.46,106.76) v7(74.9,107.08) v7(74.9,106.76) v7(75.79,107.08) v7(75.79,106.76) v7(76.17,107.08) v7(76.17,106.76) v7(77.47,107) v7(78.33,8.4) v7(78.99,111.22) v7(79.33,8.4) v7(79.5,64.43) v7(79.47,63.66) v7(80.02,97.17) v7(80.33,8.4) v7(80.36,63.66) v7(80.65,94.7) v7(80.67,95.65) v7(80.93,61.75) v7(81.57,109.05) v7(81.57,108.16) v7(81.57,107.27) v7(81.76,106.11) v7(81.89,61.75) v7(82.14,109.05) v7(82.14,108.16) v7(82.14,107.27) v7(82.78,109.05) v7(82.78,108.16) v7(82.78,107.27) v7(83.07,63.61) v7(83.24,66) v7(83.22,64.84) v7(83.46,61.8) v7(83.46,60.92) v7(84.4,104.5) v7(84.43,67.67) v7(84.81,104.5) v7(84.85,75.04) v7(84.83,63.06) v7(85.28,61.42) v7(85.28,60.79) v7(85.7,81.03) v7(86.03,109.56) v7(86.71,81.03) v7(87.35,111.02) v7(87.35,109.62) v7(87.35,108.29) v7(87.35,106.44) v7(87.35,104.79) v7(87.35,102.63) v7(87.35,100.09) v7(87.42,68.74) v7(88.39,61.37) v7(88.71,63.58) v7(88.71,62.95) v7(89.63,100.03) v7(89.76,79.9) v7(89.95,80.66) v7(90.25,79.9) v7(90.65,79.65) v7(90.84,79.9) v7(90.89,61.51) v7(91.03,109.26) v7(92.05,99.97) v7(92.11,97.24) v7(92.11,94.95) v7(92.17,92.03) v7(92.68,49.49) v7(92.68,48.85) v7(92.68,48.22) v7(92.68,47.58) v7(92.74,44.85) v7(92.74,44.21) v7(92.74,43.58) v7(92.74,42.94) v7(93.54,61.55) v7(93.76,62.54) v7(93.89,102.08) v7(94.01,49.49) v7(94.01,48.85) v7(94.01,48.22) v7(94.01,47.58) v7(94.08,44.85) v7(94.08,44.21) v7(94.08,43.58) v7(94.08,42.94) v7(94.35,62.59) v7(94.36,61.55) v7(94.46,60.53) v7(96.66,61.55) v7(97.91,61.49) v7(97.94,44.71) v7(97.94,44.28) v7(99.41,43.36) v7(99.41,42.93) v7(99.41,42.14) v7(99.41,41.71) v7(99.41,40.94) v7(99.41,40.51) v7(99.41,39.69) v7(99.41,39.26) v7(99.75,62.19) v7(99.75,61.55) v7(100.24,62.82) v7(102.43,62.19) v7(102.43,61.55) v7(102.43,60.92) v7(102.84,27.39) v7(103.45,27.39) v7(104.4,76.9) v7(104.44,75.95) v7(104.47,75) v7(104.88,73.94) v7(104.88,73.56) v7(105.04,63.2) v7(105.05,62.67) v7(105.08,63.72) v7(105.24,61.77) v7(105.83,63.62) v7(105.94,18.02) v7(106.33,19.22) v7(107.4,73.85) v7(108.49,81.74) v7(109.19,77.35) v7(109.26,16.64) v7(109.65,7.81) v7(109.62,6.59) v7(109.81,17.74) v7(110.08,77.35) v7(110.42,24.63) v7(111.03,77.49) v7(111.29,64.85) v7(111.5,61.19) v7(111.65,80.16) v7(112.18,81.49) v7(112.43,64.09) v7(112.43,62.69) v7(112.43,61.3) v7(113.75,26.88) v7(114.43,28.57) v7(114.84,109) v7(115.92,108.98) v7(116.25,62.82) v7(116.24,61.3) v7(117.24,62.57) v7(117.34,61.68) v7(118.72,108.98) v7(119.64,61.68) v7(120.11,63.84) v7(120.06,62.57) v7(120.33,61.68) v7(121.03,63.81) v7(121.19,65.11) v7(121.61,61.3) v7(123.48,93.94) v7(123.69,65.31) v7(124,63.86) v7(124.49,93.94) v7(125.32,64.83) v7(125.45,63.71) v7(125.45,26.82) v7(125.49,62.82) v7(125.49,62.19) v7(125.83,51.01) v7(126.08,61.36) v7(127.3,61.09) v7(127.42,91.9) v7(127.73,76.98) v7(127.78,71.08) v7(128.11,65.53) v7(128.11,63.71) v7(128.11,62.99) v7(128.11,61.13) v7(128.3,93.94) v7(130.91,91.9) v7(131.42,5.42) v7(131.8,93.94) v7(133.45,91.9) v7(135.15,37.74) v7(136.12,46.7) v7(137.05,36.01) v7(137.07,43.97) v7(137.32,2.9) v7(137.32,2.52) v7(137.32,2.14) v7(137.32,1.76) v7(137.7,2.9) v7(137.7,2.52) v7(137.7,2.14) v7(137.7,1.76) v7(138.08,91.84) v7(138.08,2.9) v7(138.08,2.52) v7(138.08,2.14) v7(138.08,1.76) v7(138.86,81.38) v7(139.43,41.67) v7(139.43,39.62) v7(139.43,37.56) v7(139.48,68.28) v7(141.49,101.85) v7(141.53,41.67) v7(141.53,39.62) v7(141.53,37.56) v7(141.65,110) v7(141.73,109.01) v7(142.15,91.84) v7(142.85,110.56) v7(143.62,41.67) v7(143.62,39.62) v7(143.62,37.56) v7(144.75,108.35) v7(144.75,106.89) v7(144.75,105.49) v7(144.75,104.03) v7(144.75,102.51) v7(144.75,100.92) v7(144.75,99.4) v7(147.61,111.08) v7(148.28,36.82) v7(148.38,43.83) v7(148.38,42.75) v7(148.38,40.6) v7(149.53,44.72) v7(150.1,42.75) v7(150.1,41.67) v7(150.1,40.6) v7(154.48,9.8) v7(156.66,9.8) v7(157.2,7.16) v7(158.59,18.7) v7(159.81,11.42) v7(160.4,17.71) v7(160.68,12.44) v7(162.17,8.12) v7(162.17,7) v7(162.17,5.88) v7(162.49,13.85) v7(163.29,8.12) v7(163.29,7) v7(163.29,5.88) v7(164.41,8.12) v7(164.41,7) v7(164.41,5.88) v7(165.55,11.64) v7(166.51,10.43) v7(167.76,9.47) v7(168.13,3.9) v7(168.26,5.48) v7(168.91,3.32) v7(170,7.88) v7(169.96,6.89) v7(169.97,5.96) v7(171.32,6.99) v8(74.95,67.38) v8(75.26,65.56) v8(75.92,65.57) v8(95.98,108.29) v8(97.36,86.42) v8(102.66,79.26) v8(111.97,99.49) v8(113.7,87.62) v8(116.38,81.21) v8(117.03,87.92) v8(117.03,87.09) v8(121.87,108.29) v8(123.69,77.96) v8(142.34,60.38) v8(142.36,59.64) v9(1.11,108.69) v9(1.11,72.64) v9(1.09,70.69) v9(1.09,60.05) v9(1.09,58.32) v9(1.09,56.59) v9(1.16,54.89) v9(1.09,20.32) v9(1.09,18.59) v9(1.09,16.87) v9(1.09,15.14) v9(1.09,13.41) v9(1.09,11.69) v9(1.09,9.96) v9(1.09,8.23) v9(1.09,6.5) v9(1.09,4.78) v9(1.09,3.05) v9(1.18,87.62) v9(1.23,45.09) v9(1.23,43.82) v9(1.23,42.55) v9(1.23,41.28) v9(1.23,40.01) v9(1.23,38.74) v9(1.23,37.47) v9(1.23,36.2) v9(1.23,34.93) v9(1.23,33.66) v9(1.23,32.39) v9(1.23,31.12) v9(1.23,29.85) v9(1.27,93.68) v9(1.32,46.29) v9(1.27,28.59) v9(1.85,105.66) v9(1.81,103.66) v9(1.81,75.86) v9(2.04,47.9) v9(2.24,27.22) v9(2.24,25.49) v9(2.24,23.76) v9(2.24,22.03) v9(2.24,1.85) v9(2.26,91.3) v9(2.26,89.58) v9(2.37,77.61) v9(2.71,110.6) v9(2.89,0.43) v9(3.67,72.68) v9(4.1,77.61) v9(4.44,110.6) v9(4.62,0.43) v9(4.79,90.62) v9(5.44,3.13) v9(5.73,106.72) v9(5.68,92.15) v9(5.68,89.09) v9(5.72,77.11) v9(5.73,74.52) v9(6.16,110.6) v9(6.33,4.66) v9(6.33,1.6) v9(6.62,108.25) v9(6.62,105.19) v9(6.62,76.05) v9(6.62,72.99) v9(7.44,92.15) v9(7.44,89.09) v9(7.88,110.43) v9(7.97,21.04) v9(7.97,20.4) v9(7.97,19.77) v9(7.97,19.18) v9(8.09,4.66) v9(8.09,1.6) v9(8.33,90.62) v9(8.38,108.25) v9(8.38,105.19) v9(8.38,76.05) v9(8.38,72.99) v9(8.63,21.62) v9(8.61,21.04) v9(8.61,20.4) v9(8.61,19.77) v9(8.61,19.18) v9(8.98,3.13) v9(9.12,21.93) v9(9.12,21.29) v9(9.12,20.66) v9(9.27,106.72) v9(9.27,74.52) v9(9.6,110.22) v9(9.8,0.43) v9(10.13,22.23) v9(10.13,21.47) v9(10.18,50.3) v9(10.98,110.2) v9(11.53,0.43) v9(13.05,110.22) v9(13.25,0.43) v9(13.41,81.16) v9(14.4,95.13) v9(14.47,97.19) v9(14.59,109.87) v9(14.91,81.13) v9(14.98,0.43) v9(15.18,108.27) v9(15.18,106.54) v9(15.34,104.85) v9(15.75,82.58) v9(16.74,103.46) v9(16.74,98.63) v9(16.71,0.43) v9(16.89,93.1) v9(16.99,97.87) v9(18.11,93.6) v9(18.44,0.43) v9(18.71,103.3) v9(20.16,0.43) v9(20.44,103.3) v9(20.89,81.33) v9(21.22,86.2) v9(21.92,82.52) v9(21.89,0.43) v9(22.16,103.3) v9(22.26,87.39) v9(23.62,0.43) v9(23.89,103.3) v9(25.34,0.43) v9(25.71,103.34) v9(26.48,63.8) v9(27.15,2.7) v9(27.07,0.43) v9(27.22,104.33) v9(27.66,106.01) v9(27.68,65.27) v9(28.31,107.92) v9(28.8,0.43) v9(30.04,108.22) v9(30.53,0.43) v9(31.76,108.22) v9(32.25,0.43) v9(33.49,108.22) v9(33.98,0.43) v9(35.22,108.22) v9(35.71,0.43) v9(37.43,0.43) v9(39.16,0.43) v9(40.89,0.43) v9(42.62,0.43) v9(42.8,34.52) v9(43.85,108.22) v9(43.93,33.65) v9(44.34,0.43) v9(45.41,33.69) v9(45.58,108.22) v9(46.07,0.43) v9(47.31,108.22) v9(47.8,0.43) v9(49.03,108.22) v9(49.52,0.43) v9(50.76,108.22) v9(51.25,0.43) v9(51.74,89.69) v9(51.74,89.08) v9(52.98,0.43) v9(53.39,78.52) v9(53.39,77.93) v9(53.82,78.87) v9(53.95,78.31) v9(53.95,77.76) v9(54.02,77.17) v9(54.18,4.27) v9(54.4,78.92) v9(54.53,78.36) v9(54.53,77.81) v9(54.71,0.43) v9(54.99,78.92) v9(55.09,78.36) v9(55.09,77.81) v9(55.55,78.9) v9(55.75,91.7) v9(56.36,91.73) v9(56.43,0.43) v9(56.56,79.61) v9(56.59,79) v9(57.65,57.89) v9(57.73,58.45) v9(57.81,59.59) v9(57.78,59.04) v9(57.79,53.26) v9(58.16,0.43) v9(58.89,2.91) v9(58.98,80.32) v9(59.15,56.19) v9(59.28,55.63) v9(59.4,108.22) v9(59.38,53.78) v9(59.71,56.22) v9(59.85,55.64) v9(59.94,53.78) v9(59.89,0.43) v9(60.11,101.68) v9(60.23,57.42) v9(60.17,56.72) v9(60.3,56.18) v9(60.49,55.64) v9(60.74,101.68) v9(60.81,56.41) v9(60.98,103.1) v9(61.13,108.22) v9(61.31,101.49) v9(61.31,100.92) v9(61.38,102.57) v9(61.62,0.43) v9(61.67,103.13) v9(61.69,102) v9(61.95,101.49) v9(61.95,100.92) v9(62.01,102.57) v9(62.43,103.1) v9(62.46,102.06) v9(62.58,101.49) v9(62.58,100.92) v9(62.85,108.22) v9(63.17,103.08) v9(63.34,0.43) v9(64.3,105.43) v9(64.58,108.22) v9(64.59,106.7) v9(65.07,0.43) v9(66.31,108.22) v9(66.68,39.05) v9(66.68,38.46) v9(66.8,0.43) v9(67.08,39.88) v9(67.08,38.06) v9(67.08,37.47) v9(67.17,41.34) v9(67.22,39.24) v9(67.22,38.65) v9(67.65,41.69) v9(67.66,41.05) v9(67.66,40.47) v9(67.66,39.88) v9(67.66,38.06) v9(67.66,37.47) v9(67.8,39.19) v9(67.8,38.6) v9(68.23,42.22) v9(68.23,41.64) v9(68.25,41) v9(68.25,40.42) v9(68.25,39.83) v9(68.39,39.19) v9(68.39,38.6) v9(68.39,37.1) v9(68.52,0.43) v9(68.82,42.22) v9(68.82,41.64) v9(68.83,41) v9(68.83,40.42) v9(68.83,39.83) v9(68.94,37.81) v9(68.94,36.25) v9(69.76,108.22) v9(70.23,37.81) v9(70.23,36.25) v9(70.25,0.43) v9(71.49,108.22) v9(71.53,37.81) v9(71.53,36.25) v9(71.9,107.04) v9(71.91,35.1) v9(71.98,0.43) v9(72.13,105.59) v9(72.38,37.46) v9(72.51,107.02) v9(73.22,108.22) v9(73.71,0.43) v9(74.46,40.71) v9(74.47,40.07) v9(74.47,39.49) v9(74.47,38.91) v9(74.47,38.32) v9(74.47,37.74) v9(74.85,108.36) v9(75.04,40.71) v9(75.05,40.07) v9(75.05,39.49) v9(75.05,38.91) v9(75.05,38.32) v9(75.05,37.74) v9(75.43,0.43) v9(75.62,40.66) v9(75.64,40.02) v9(75.64,39.44) v9(75.64,38.86) v9(75.64,38.27) v9(75.64,37.69) v9(75.66,111.66) v9(75.66,109.9) v9(75.69,107.65) v9(76.21,40.66) v9(76.22,40.02) v9(76.22,39.44) v9(76.22,38.86) v9(76.22,38.27) v9(76.22,37.69) v9(76.35,107.65) v9(76.86,40.79) v9(76.84,39.46) v9(76.88,40.13) v9(76.88,38.8) v9(76.95,37.12) v9(77.16,0.43) v9(77.28,112.22) v9(77.5,37.82) v9(77.5,36.26) v9(77.75,92.49) v9(77.82,93.05) v9(78.41,92.94) v9(78.79,37.82) v9(78.79,36.26) v9(78.89,0.43) v9(79.01,112.22) v9(79.16,92.5) v9(79.37,93.63) v9(79.37,93.05) v9(80.09,37.82) v9(80.09,36.26) v9(80.44,20.83) v9(80.47,35.12) v9(80.61,0.43) v9(80.73,112.22) v9(80.94,37.48) v9(81.89,42.37) v9(82.34,0.43) v9(82.46,112.22) v9(82.58,42.37) v9(82.6,38.91) v9(82.58,38.31) v9(83.22,43.01) v9(83.22,42.37) v9(83.19,38.91) v9(83.19,38.32) v9(83.19,37.74) v9(83.85,43.01) v9(83.85,42.37) v9(83.78,38.91) v9(83.78,38.32) v9(83.78,37.74) v9(84.07,0.43) v9(84.19,112.22) v9(84.44,41.29) v9(84.44,40.7) v9(84.44,40.06) v9(84.36,38.86) v9(84.36,38.27) v9(84.36,37.69) v9(84.5,39.48) v9(84.6,36.96) v9(84.95,38.86) v9(84.95,38.27) v9(84.95,37.69) v9(85,41.29) v9(85.02,40.7) v9(85.02,40.06) v9(85.09,39.48) v9(85.62,38.73) v9(85.7,37.09) v9(85.78,39.38) v9(85.8,0.43) v9(85.91,112.22) v9(86.25,37.8) v9(86.25,36.24) v9(87.54,37.8) v9(87.54,36.24) v9(87.52,0.43) v9(87.64,112.22) v9(88.84,37.8) v9(88.84,36.24) v9(88.87,98.29) v9(89.22,35.09) v9(89.25,0.43) v9(89.37,112.22) v9(89.51,98.29) v9(89.69,37.45) v9(90.98,0.43) v9(91.1,112.22) v9(91.23,39.87) v9(91.28,39.13) v9(91.77,40.76) v9(91.83,40.1) v9(91.83,39.52) v9(91.83,38.93) v9(91.83,38.35) v9(91.83,37.76) v9(92.4,40.73) v9(92.41,40.1) v9(92.41,39.52) v9(92.41,38.93) v9(92.41,38.35) v9(92.41,37.76) v9(92.7,0.43) v9(92.82,112.22) v9(92.99,40.68) v9(93,40.05) v9(93,39.46) v9(93,38.88) v9(93,38.3) v9(93,37.71) v9(93.42,21.9) v9(93.57,40.68) v9(93.58,40.05) v9(93.58,39.46) v9(93.58,38.88) v9(93.58,38.3) v9(93.58,37.71) v9(94.34,38.84) v9(94.38,39.49) v9(94.43,0.43) v9(94.55,112.22) v9(94.55,37.1) v9(94.91,22.3) v9(94.94,20.55) v9(94.89,15.12) v9(94.92,11.94) v9(94.92,9.12) v9(95.04,17.51) v9(95.1,37.81) v9(95.1,36.25) v9(96.16,0.43) v9(96.28,112.22) v9(96.39,37.81) v9(96.39,36.25) v9(97.69,37.81) v9(97.69,36.25) v9(97.77,1.84) v9(98,112.22) v9(98.07,35.1) v9(98.54,37.46) v9(98.52,20.17) v9(99.54,1.18) v9(99.73,112.22) v9(101.34,0.43) v9(101.46,112.22) v9(103.07,0.43) v9(103.19,112.22) v9(104.8,0.43) v9(104.91,112.22) v9(106.52,0.43) v9(106.64,112.22) v9(108.25,0.48) v9(108.37,112.22) v9(108.58,2.27) v9(109.52,34.7) v9(109.94,3.14) v9(110.1,112.22) v9(110.13,36.38) v9(110.13,35.77) v9(110.11,35.11) v9(110.59,34.75) v9(110.93,55) v9(111.05,39.33) v9(111.05,38.64) v9(111.07,35.24) v9(111.15,34.65) v9(111.2,39.96) v9(111.65,39.53) v9(111.63,38.87) v9(111.65,38.23) v9(111.65,37.6) v9(111.65,36.96) v9(111.65,36.38) v9(111.65,34.4) v9(111.68,35.74) v9(111.68,35.08) v9(111.66,3.14) v9(111.82,112.22) v9(111.77,55.84) v9(111.77,55) v9(113.39,3.14) v9(113.55,112.22) v9(113.66,27.54) v9(114.27,28.12) v9(114.27,27.56) v9(115.12,3.14) v9(115.28,112.22) v9(116.02,33.81) v9(116.02,33.23) v9(116.84,2.43) v9(117,112.22) v9(117.01,35.69) v9(117.01,35.13) v9(117.04,34.52) v9(117.36,33.81) v9(117.36,33.23) v9(117.94,33.81) v9(117.94,33.23) v9(118.07,39.66) v9(118.07,39.07) v9(118.07,38.49) v9(118.07,37.9) v9(118.53,37.32) v9(118.53,36.73) v9(118.53,36.15) v9(118.53,35.57) v9(118.53,34.98) v9(118.53,34.4) v9(118.53,33.81) v9(118.53,33.23) v9(118.65,39.66) v9(118.65,39.07) v9(118.65,38.49) v9(118.65,37.9) v9(118.57,2.43) v9(118.73,112.22) v9(118.97,15.58) v9(119.11,37.32) v9(119.11,36.73) v9(119.11,36.15) v9(119.11,35.57) v9(119.11,34.98) v9(119.11,34.4) v9(119.11,33.81) v9(119.11,33.23) v9(119.24,39.66) v9(119.24,39.07) v9(119.24,38.49) v9(119.24,37.9) v9(119.2,16.85) v9(119.22,16.21) v9(119.54,15.7) v9(119.82,17.37) v9(119.81,16.78) v9(119.86,16.21) v9(119.86,15.13) v9(120.18,15.7) v9(120.29,2.43) v9(120.46,112.22) v9(120.43,17.37) v9(120.43,16.81) v9(120.43,15.13) v9(120.49,16.21) v9(120.75,15.7) v9(121.05,17.39) v9(121.07,16.81) v9(121.13,16.21) v9(121.07,15.13) v9(121.13,9.4) v9(121.45,15.7) v9(121.64,16.78) v9(121.64,15.13) v9(121.69,17.39) v9(121.7,16.21) v9(122.02,15.7) v9(122.02,2.43) v9(122.19,112.22) v9(123.28,33.36) v9(123.28,32.77) v9(123.75,2.43) v9(123.91,112.22) v9(124.27,35.08) v9(124.27,34.5) v9(124.27,33.91) v9(124.61,33.33) v9(124.61,32.75) v9(125.19,38.39) v9(125.19,37.8) v9(125.19,37.22) v9(125.19,33.91) v9(125.19,33.33) v9(125.19,32.75) v9(125.47,2.43) v9(125.64,112.22) v9(125.78,39.17) v9(125.78,38.59) v9(125.78,38) v9(125.78,37.42) v9(125.78,36.84) v9(125.78,36.25) v9(125.78,35.67) v9(125.78,35.08) v9(125.78,34.5) v9(125.78,33.91) v9(125.78,33.33) v9(125.78,32.75) v9(126.36,39.17) v9(126.36,38.59) v9(126.36,38) v9(126.36,37.42) v9(126.36,36.84) v9(126.36,36.25) v9(126.36,35.67) v9(126.36,35.08) v9(126.36,34.5) v9(126.36,33.91) v9(126.36,33.33) v9(126.36,32.75) v9(126.78,22.88) v9(126.78,22.31) v9(126.87,23.89) v9(126.91,21.74) v9(127.2,2.43) v9(127.35,23.2) v9(127.35,22.62) v9(127.37,112.22) v9(127.42,22.05) v9(127.8,25.61) v9(127.92,23.2) v9(128.11,21.8) v9(128.43,25.61) v9(128.5,23.2) v9(128.88,26.5) v9(128.93,2.43) v9(129.09,112.22) v9(129.07,23.2) v9(129.07,22.62) v9(129.07,22.05) v9(130.36,34.17) v9(130.53,34.78) v9(130.66,2.43) v9(130.82,112.22) v9(131.42,36.51) v9(131.42,35.92) v9(131.42,35.34) v9(131.8,34.71) v9(131.8,34.13) v9(132.38,38.99) v9(132.38,35.3) v9(132.38,34.71) v9(132.38,34.13) v9(132.37,2.43) v9(132.55,112.22) v9(132.5,39.58) v9(132.75,15.22) v9(132.97,38.99) v9(132.97,38.41) v9(132.97,37.83) v9(132.97,37.24) v9(132.97,36.66) v9(132.97,36.07) v9(132.97,35.49) v9(132.97,34.91) v9(132.97,34.32) v9(133.07,40.15) v9(133.07,39.57) v9(133.38,15.22) v9(133.55,38.99) v9(133.55,38.41) v9(133.55,37.83) v9(133.55,37.24) v9(133.55,36.66) v9(133.55,36.07) v9(133.55,35.49) v9(133.55,34.91) v9(133.55,34.32) v9(133.65,40.73) v9(133.65,40.15) v9(133.65,39.57) v9(133.6,18.12) v9(133.58,17.53) v9(134.02,15.22) v9(134.15,18.37) v9(134.15,17.8) v9(134.15,17.23) v9(134.15,16.66) v9(134.15,16.08) v9(134.11,2.32) v9(134.24,40.73) v9(134.24,40.15) v9(134.24,39.57) v9(134.28,112.22) v9(134.72,14.94) v9(135.09,0.43) v9(135.29,14.94) v9(135.54,21.48) v9(135.54,20.91) v9(136,112.22) v9(136.18,21.48) v9(136.81,0.43) v9(137.73,112.22) v9(138.26,24.72) v9(138.26,24.14) v9(138.54,0.43) v9(138.83,24.72) v9(138.83,24.14) v9(139.46,112.22) v9(140.27,0.43) v9(141.18,112.22) v9(142,0.43) v9(142.21,8.65) v9(142.78,8.65) v9(142.91,112.22) v9(143.35,8.65) v9(143.57,71.34) v9(143.57,70.71) v9(143.57,70.07) v9(143.57,69.44) v9(143.72,0.43) v9(143.81,10.5) v9(143.93,8.65) v9(144.42,10.5) v9(144.54,8.77) v9(144.64,112.22) v9(144.71,9.94) v9(145.04,10.52) v9(145.03,9.38) v9(145.14,8.77) v9(145.32,9.94) v9(145.45,0.43) v9(145.64,9.38) v9(145.68,10.52) v9(145.77,8.79) v9(145.78,8.16) v9(145.94,9.96) v9(146.28,10.52) v9(146.26,9.4) v9(146.37,112.22) v9(146.4,8.79) v9(146.41,8.21) v9(146.58,9.96) v9(146.76,103.98) v9(146.78,59.71) v9(146.78,59.14) v9(146.86,10.52) v9(146.9,9.4) v9(147.04,60.32) v9(147.18,0.43) v9(147.27,105.96) v9(147.29,60.84) v9(147.35,59.71) v9(147.35,59.14) v9(147.42,11.32) v9(147.55,10.62) v9(147.6,60.29) v9(147.69,69.59) v9(147.88,60.81) v9(147.93,59.71) v9(147.93,59.14) v9(147.93,11.07) v9(148,70.15) v9(148,69.04) v9(148.09,112.22) v9(148.15,60.29) v9(148.28,69.59) v9(148.5,59.71) v9(148.5,59.14) v9(148.58,70.15) v9(148.58,69.04) v9(148.74,60.29) v9(148.79,90.22) v9(148.76,57.56) v9(148.95,112.29) v9(148.86,69.59) v9(148.9,0.43) v9(149,75.53) v9(149.02,60.84) v9(149.07,59.71) v9(149.07,59.14) v9(149.17,70.15) v9(149.17,69.04) v9(149.17,67.33) v9(149.3,60.29) v9(149.32,57.59) v9(149.41,104.01) v9(149.45,69.59) v9(149.63,60.86) v9(149.64,59.71) v9(149.64,59.14) v9(149.75,70.15) v9(149.75,69.04) v9(149.77,67.33) v9(149.89,60.28) v9(149.96,57.59) v9(150,110.95) v9(150.03,69.59) v9(150.01,58.55) v9(150.13,77.49) v9(150.13,73.57) v9(150.21,59.71) v9(150.21,59.14) v9(150.34,70.15) v9(150.34,69.04) v9(150.35,68.4) v9(150.36,67.33) v9(150.47,60.28) v9(150.47,57.99) v9(150.62,69.59) v9(150.6,30.65) v9(150.63,0.43) v9(150.67,58.55) v9(150.71,33.12) v9(150.83,67.98) v9(150.83,66.77) v9(150.78,59.71) v9(150.78,59.14) v9(150.89,112.48) v9(150.89,109.42) v9(150.94,103.38) v9(150.92,70.15) v9(150.92,69.04) v9(150.94,67.39) v9(151.09,68.49) v9(151.2,69.59) v9(151.43,68.04) v9(151.5,70.15) v9(151.5,69.1) v9(151.61,67.51) v9(151.76,69.62) v9(151.68,68.54) v9(152.09,107.86) v9(152.09,106.63) v9(152.09,104.9) v9(152.09,103.18) v9(152.09,101.45) v9(152.09,99.72) v9(152.09,97.99) v9(152.1,96.28) v9(152.14,36.26) v9(152.36,0.43) v9(152.39,77.49) v9(152.39,73.57) v9(152.4,34.88) v9(152.65,112.48) v9(152.65,109.42) v9(152.76,34.26) v9(152.82,29.33) v9(153.03,94.67) v9(153.52,75.53) v9(153.59,92.81) v9(153.59,91.08) v9(153.59,89.35) v9(153.59,87.63) v9(153.59,85.9) v9(153.59,84.17) v9(153.59,82.44) v9(153.59,80.72) v9(153.59,78.99) v9(153.59,72.08) v9(153.59,70.35) v9(153.59,68.63) v9(153.59,66.9) v9(153.59,65.17) v9(153.59,63.44) v9(153.59,61.72) v9(153.59,59.99) v9(153.59,58.26) v9(153.59,56.54) v9(153.59,54.81) v9(153.59,53.08) v9(153.59,51.35) v9(153.59,49.63) v9(153.59,47.9) v9(153.59,46.17) v9(153.59,44.45) v9(154.06,0.44) v9(154.79,33.13) v9(154.91,30.52) v9(155.8,1.43) v9(155.99,29.1) v9(156.12,22.12) v9(156.56,27.56) v9(157.24,25.95) v9(157.53,1.43) v9(157.97,24.38) v9(158.77,22.82) v9(159.26,1.43) v9(159.63,21.31) v9(160.55,19.83) v9(161.22,0.45) v9(161.53,18.4) v9(162.56,17) v9(162.72,0.43) v9(163.66,15.64) v9(164.45,0.43) v9(164.8,14.34) v9(166,13.07) v9(166.18,0.43) v9(167.25,11.86) v9(167.9,0.43) v9(168.55,10.7) v9(169.63,0.43) v9(169.89,9.59) v9(171.28,8.54) v9(171.32,0.54) v9(172.3,7.16) v9(172.31,5.42) v9(172.31,3.69) v9(172.31,1.97) v11(8.91,77.54) v11(9.13,78.25) v11(9.61,77.27) v11(10,77.91) v11(10.8,77.73) v11(12.39,77.81) v11(13.15,77.79) v11(14.09,102.39) v11(14.17,78.15) v11(14.55,76.78) v11(14.6,101.85) v11(15.15,101.24) v11(15.13,5.66) v11(15.25,66.35) v11(15.16,6.58) v11(15.53,79.36) v11(15.82,100.4) v11(15.96,2.77) v11(16.28,99.38) v11(16.42,98.13) v11(16.43,97.08) v11(16.43,95.95) v11(16.42,94.99) v11(16.66,93.99) v11(16.81,101.19) v11(16.8,100.22) v11(16.81,92.28) v11(17.19,79.39) v11(17.17,43.71) v11(17.29,66) v11(17.38,91.48) v11(17.51,95.41) v11(17.5,94.44) v11(17.86,16.1) v11(17.86,13.6) v11(18.14,92.2) v11(18.08,90.84) v11(18.08,79.24) v11(18.08,41.17) v11(18.21,66.88) v11(18.84,91.55) v11(18.77,90.1) v11(18.87,48.71) v11(19.12,79.24) v11(19.53,90.81) v11(19.61,89.26) v11(19.73,51.67) v11(19.77,69.74) v11(20.32,79.25) v11(20.37,89.97) v11(20.8,89.25) v11(20.85,78.71) v11(20.98,68.66) v11(21.37,79.13) v11(21.73,88.77) v11(22.07,70.58) v11(22.36,78.68) v11(22.74,88.56) v11(22.76,56.97) v11(23.42,87.85) v11(23.73,68.73) v11(23.82,88.65) v11(24.15,86.92) v11(24.13,86.01) v11(24.38,88.08) v11(24.55,78.44) v11(24.61,85.24) v11(24.89,88.93) v11(24.91,86.15) v11(25.21,87.48) v11(25.17,84.7) v11(25.21,40.85) v11(25.5,78.43) v11(25.51,68.73) v11(25.71,88.3) v11(25.68,85.51) v11(25.73,84.13) v11(25.71,27.78) v11(25.76,86.91) v11(26.23,84.98) v11(26.27,87.76) v11(26.32,86.33) v11(26.29,83.55) v11(26.51,78.43) v11(26.48,47.45) v11(26.64,88.82) v11(26.83,87.19) v11(26.79,84.41) v11(26.93,82.89) v11(26.97,85.67) v11(26.97,67.42) v11(27.2,88.23) v11(27.24,72.79) v11(27.35,83.83) v11(27.34,76.23) v11(27.29,71.93) v11(27.39,86.61) v11(27.54,78.44) v11(27.49,74) v11(27.59,82.23) v11(27.71,89.1) v11(27.85,87.57) v11(27.91,43.06) v11(28,83.17) v11(28.11,27.77) v11(28.27,103.27) v11(28.27,88.51) v11(28.42,81.77) v11(28.46,42.12) v11(28.55,84.09) v11(28.55,39.79) v11(28.55,38.35) v11(28.61,86.57) v11(28.63,78.44) v11(28.74,48.21) v11(28.69,46.56) v11(28.69,45.69) v11(28.84,82.64) v11(28.79,49.31) v11(28.8,43.06) v11(28.89,70.63) v11(29.13,107.03) v11(29.24,74.93) v11(29.35,62.09) v11(29.31,39.29) v11(29.31,38.51) v11(29.45,81.77) v11(29.47,78.03) v11(29.55,77.06) v11(29.87,82.64) v11(30.21,76.14) v11(30.41,81.77) v11(30.71,74.27) v11(30.68,4.35) v11(30.83,82.64) v11(30.98,84.98) v11(31.23,75.66) v11(31.36,59.89) v11(31.52,82) v11(31.56,42.25) v11(31.54,38.44) v11(31.59,83.36) v11(32.09,6.14) v11(32.19,84.98) v11(32.17,44.59) v11(32.48,75.86) v11(32.52,59.26) v11(32.67,87.53) v11(32.88,77.62) v11(32.89,76.74) v11(32.89,39.88) v11(32.91,35.72) v11(33.08,20.15) v11(33.25,87.03) v11(33.25,83.29) v11(33.21,82.23) v11(33.19,80.68) v11(33.22,76.08) v11(33.35,35.72) v11(33.29,2.5) v11(33.42,39.88) v11(33.39,7.95) v11(33.63,77.69) v11(34.02,81.86) v11(34.02,81.22) v11(34.02,80.56) v11(34.01,29.21) v11(34.13,103.92) v11(34.12,84.4) v11(34.12,83.76) v11(34.12,83.13) v11(34.22,14.13) v11(34.32,89.78) v11(34.32,3.03) v11(34.46,67.16) v11(34.52,77.69) v11(34.62,79.91) v11(34.73,24.59) v11(35.02,103.92) v11(34.97,28.02) v11(34.98,12.4) v11(35.15,19.46) v11(35.2,96.63) v11(35.25,79.98) v11(35.25,78.03) v11(35.25,76.51) v11(35.31,9.99) v11(35.42,79.34) v11(35.56,71.77) v11(35.85,81.86) v11(35.85,81.22) v11(35.9,78.03) v11(35.89,76.51) v11(36.01,80.52) v11(35.97,26.83) v11(36.04,19.46) v11(36.15,101.34) v11(36.1,86.35) v11(36.09,28.02) v11(36.09,5.74) v11(36.56,82.45) v11(36.61,81.22) v11(36.6,80.52) v11(36.61,79.27) v11(36.61,78.68) v11(36.75,69.3) v11(36.75,68.66) v11(37.1,95.33) v11(37.11,10.28) v11(37.21,84.4) v11(37.21,81.92) v11(37.21,80.52) v11(37.23,16.95) v11(37.27,83.17) v11(37.36,18.47) v11(37.4,17.61) v11(37.63,42.55) v11(37.84,81.92) v11(37.86,81.15) v11(38.02,41.23) v11(38.14,29.21) v11(38.45,98.67) v11(38.44,84.4) v11(38.44,83.81) v11(38.44,79.91) v11(38.49,31.45) v11(38.48,4.62) v11(38.48,2.93) v11(38.57,83.15) v11(38.57,82.52) v11(38.57,81.86) v11(38.57,81.22) v11(38.59,80.56) v11(38.58,7.46) v11(38.88,76.22) v11(38.96,89.72) v11(38.96,88.51) v11(39.15,78.68) v11(39.1,77.97) v11(39.16,84.41) v11(39.73,79.91) v11(39.72,78.68) v11(39.8,82.45) v11(40.27,102.64) v11(40.31,78.68) v11(40.37,84.42) v11(40.37,83.84) v11(40.4,83.15) v11(40.46,82.45) v11(40.42,81.15) v11(40.42,80.56) v11(40.38,37.37) v11(40.59,103.54) v11(40.72,46.61) v11(40.83,97.8) v11(40.84,37.37) v11(41,104.35) v11(41.07,82.45) v11(41.07,80.6) v11(41.3,30.05) v11(41.55,37.37) v11(41.59,99.21) v11(42.08,37.37) v11(42.67,99.17) v11(42.67,78.61) v11(43.15,15.79) v11(43.15,11.79) v11(43.15,3.22) v11(43.31,106.3) v11(43.41,25.21) v11(43.65,29.4) v11(44.75,27.64) v11(44.75,14.19) v11(45.12,4.55) v11(45.19,98.41) v11(46.33,26.32) v11(47.54,22.55) v11(48.55,71) v11(48.6,37.86) v11(48.75,106.25) v11(48.87,45.17) v11(49.25,45.17) v11(49.3,32.2) v11(49.44,26.51) v11(49.62,36.98) v11(49.62,36.59) v11(50.07,68.03) v11(50.26,45.17) v11(50.35,17.39) v11(50.39,22.1) v11(50.64,45.17) v11(51.37,69.63) v11(51.66,31.45) v11(51.77,45.8) v11(52.04,31.45) v11(52.17,26.93) v11(52.67,95.71) v11(52.68,71.6) v11(52.8,68.28) v11(52.8,67.27) v11(52.96,28.85) v11(52.99,94.04) v11(53.34,28.85) v11(53.31,22.42) v11(53.44,68.28) v11(53.44,67.27) v11(53.57,12.73) v11(53.67,7.96) v11(53.83,19.45) v11(53.83,18.56) v11(53.84,9.86) v11(54.2,68.28) v11(54.2,67.27) v11(54.21,31.46) v11(54.5,27.97) v11(55.29,8.97) v11(55.85,95.9) v11(55.95,97.11) v11(55.95,96.54) v11(56.09,17.55) v11(56.31,97.87) v11(56.95,23.77) v11(57.39,19.45) v11(58.06,75.01) v11(58.26,29.47) v11(58.51,14.16) v11(58.82,40.98) v11(58.81,24.34) v11(59.15,29.47) v11(59.36,76.91) v11(59.35,12.67) v11(59.48,42.75) v11(59.48,41.87) v11(59.66,18.67) v11(60.06,21.16) v11(60.55,93.8) v11(60.54,75.01) v11(60.55,18.67) v11(61.1,31.96) v11(61.25,11.37) v11(61.69,16.5) v11(61.84,76.91) v11(61.83,50.39) v11(62.25,55.73) v11(62.25,55) v11(62.57,50.45) v11(62.71,55.73) v11(62.71,55) v11(62.72,14) v11(62.95,23.58) v11(63.35,93.77) v11(63.79,107.16) v11(63.85,36.52) v11(64.02,15.9) v11(64.54,48.37) v11(64.6,47.78) v11(64.64,46.28) v11(64.56,33.55) v11(64.56,32.66) v11(64.56,31.77) v11(64.56,30.88) v11(64.56,29.99) v11(64.74,89.35) v11(64.74,66.15) v11(64.96,47.79) v11(65.12,86.9) v11(65.32,47.78) v11(65.4,52.83) v11(65.68,47.76) v11(65.78,96.6) v11(65.83,22.15) v11(65.88,66.07) v11(66.04,47.77) v11(66.07,100.16) v11(66.21,25.98) v11(66.27,20.47) v11(66.39,56.28) v11(66.39,55.64) v11(66.41,47.78) v11(66.49,52.13) v11(66.51,48.28) v11(66.67,96.6) v11(66.9,90.26) v11(66.9,66.07) v11(66.96,56.28) v11(66.96,55.64) v11(67.34,87.08) v11(67.41,79.01) v11(67.54,56.28) v11(67.54,55.64) v11(67.58,18.87) v11(67.79,90.26) v11(68.16,93.37) v11(68.11,56.28) v11(68.11,55.64) v11(68.57,46.17) v11(68.58,24.78) v11(69.08,101.75) v11(69.34,45.84) v11(69.46,95.27) v11(69.5,86.77) v11(69.95,89.92) v11(70.37,48.86) v11(70.36,48.52) v11(70.89,48.86) v11(70.88,48.52) v11(71.28,45.68) v11(71.28,45.04) v11(71.28,44.41) v11(71.28,43.77) v11(71.95,23.59) v11(72.3,45.68) v11(72.3,45.04) v11(72.3,44.41) v11(72.3,43.77) v11(77.19,98.52) v11(77.76,47.71) v11(78.14,47.71) v11(79.09,47.71) v11(79.49,67.1) v11(79.47,47.71) v11(80.37,82) v11(88.39,61.96) v11(88.39,60.79) v11(89.32,107.49) v11(89.33,106.58) v11(90.12,61.07) v11(90.89,62.15) v11(90.89,60.88) v11(93.01,109.43) v11(93.34,110.2) v11(93.49,94.06) v11(93.94,107.12) v11(93.94,106.25) v11(93.87,103.98) v11(93.89,99.38) v11(93.89,97.73) v11(93.87,95.99) v11(95.98,103.49) v11(95.98,101.89) v11(95.98,97.89) v11(96.3,91.84) v11(96.66,62.19) v11(96.66,60.92) v11(96.75,93.94) v11(96.78,101.09) v11(96.78,99.49) v11(96.78,98.69) v11(96.78,96.29) v11(97.47,60.92) v11(97.7,93.94) v11(98.51,32.99) v11(98.7,24.35) v11(99.03,91.84) v11(99.01,24.35) v11(99.31,24.35) v11(99.62,24.35) v11(99.73,81.68) v11(99.92,24.35) v11(100.34,60.92) v11(100.75,81.74) v11(100.75,80.47) v11(100.78,99.49) v11(101.34,24.69) v11(101.34,24.39) v11(101.51,93.94) v11(101.58,98.69) v11(101.58,97.09) v11(101.58,96.29) v11(101.65,24.69) v11(101.65,24.39) v11(101.95,24.69) v11(101.95,24.39) v11(102.21,91.84) v11(102.26,24.69) v11(102.26,24.39) v11(102.38,103.49) v11(102.38,101.89) v11(102.38,100.29) v11(102.38,99.49) v11(102.56,24.69) v11(102.56,24.39) v11(102.94,93.94) v11(104.38,107.57) v11(104.39,106.74) v11(104.38,105.11) v11(104.37,102.65) v11(104.37,99.95) v11(104.37,98.32) v11(104.39,96.63) v11(104.39,95.79) v11(104.56,81.74) v11(104.56,80.47) v11(104.56,79.2) v11(105.32,91.84) v11(105.36,30.31) v11(105.3,24.47) v11(105.83,39.36) v11(106.13,7.69) v11(106.21,93.94) v11(106.37,101.89) v11(106.37,97.89) v11(106.44,16.72) v11(106.88,8.66) v11(107.16,93.94) v11(107.11,29.23) v11(107.17,101.09) v11(107.17,99.49) v11(107.17,98.69) v11(107.17,96.29) v11(107.2,5.27) v11(107.74,19.96) v11(107.87,16.1) v11(107.98,29.24) v11(108.11,91.84) v11(108.67,8.76) v11(108.87,5.4) v11(109.45,19.3) v11(110.91,93.94) v11(110.89,65.93) v11(111.03,91.84) v11(111.65,79.14) v11(112.24,93.94) v11(113.51,38.49) v11(114.02,91.79) v11(114.28,110.37) v11(114.84,107.22) v11(114.84,104.53) v11(114.86,101.95) v11(114.84,99.13) v11(115.34,102.65) v11(115.29,81.68) v11(115.73,104.53) v11(116.11,97.69) v11(116.11,95.85) v11(116.46,91.83) v11(116.64,16.13) v11(116.67,107.49) v11(116.81,81.68) v11(117.08,96.96) v11(117.32,98.25) v11(117.32,97.87) v11(117.34,60.92) v11(117.7,98.25) v11(117.7,97.87) v11(117.93,93.99) v11(118.08,98.25) v11(118.08,97.87) v11(118.34,81.68) v11(118.46,98.25) v11(118.46,97.87) v11(119.2,106.62) v11(119.35,91.84) v11(119.64,60.92) v11(119.67,93.94) v11(119.8,109.86) v11(119.8,108.67) v11(119.8,106.64) v11(119.8,106.04) v11(119.8,101.75) v11(119.8,99.38) v11(119.8,97.72) v11(119.81,96.44) v11(119.81,95.15) v11(120.33,60.92) v11(120.7,38.55) v11(120.94,62.69) v11(121.47,77.04) v11(121.6,61.68) v11(121.6,60.92) v11(121.87,101.89) v11(121.87,97.89) v11(122.44,91.81) v11(122.67,101.09) v11(122.67,99.49) v11(122.67,98.69) v11(122.67,96.29) v11(122.94,20.1) v11(123.71,61.68) v11(123.71,60.92) v11(123.87,62.57) v11(124.01,77.04) v11(124.81,14.94) v11(124.94,91.84) v11(126.53,80.85) v11(126.53,80.22) v11(126.53,79.58) v11(126.53,78.95) v11(126.67,99.49) v11(126.84,14.94) v11(127.29,80.85) v11(127.29,80.22) v11(127.29,79.58) v11(127.29,78.95) v11(127.47,98.69) v11(127.47,97.09) v11(127.47,96.29) v11(128.03,39.96) v11(128.11,68.75) v11(128.11,68.07) v11(128.11,66.21) v11(128.27,101.89) v11(128.27,100.29) v11(128.27,99.49) v11(130.23,93.94) v11(130.27,107.37) v11(130.29,106.65) v11(130.3,105.01) v11(130.3,102.57) v11(130.27,101.19) v11(130.29,98.63) v11(130.27,97.85) v11(130.29,96.04) v11(132.27,101.89) v11(132.27,97.89) v11(133.07,101.09) v11(133.07,99.49) v11(133.07,98.69) v11(133.07,96.29) v11(135.15,35.96) v11(135.15,35.07) v11(135.54,32.77) v11(136.42,31.39) v11(136.62,93.94) v11(137.07,99.49) v11(137.87,98.69) v11(137.87,97.09) v11(137.87,96.29) v11(138.16,88.77) v11(138.36,110.37) v11(138.67,103.49) v11(138.67,101.89) v11(138.67,100.29) v11(138.67,99.49) v11(139.23,110.38) v11(140.43,93.94) v11(140.65,104.58) v11(140.75,96.16) v11(140.78,106.99) v11(140.94,51.09) v11(140.97,108.97) v11(141.23,101.02) v11(141.26,99.84) v11(141.41,98.35) v11(141.63,95.88) v11(141.66,99.08) v11(141.72,97.62) v11(142.08,89.64) v11(142.44,81.49) v11(142.49,108.81) v11(142.53,101.94) v11(142.85,109.39) v11(142.87,109.96) v11(143.42,108.29) v11(143.42,101.94) v11(144.75,97.75) v11(144.75,96.22) v11(144.75,91.84) v11(144.81,94.19) v11(145.01,46.31) v11(146.36,104.95) v11(146.4,76.07) v11(147.18,97.94) v11(147.27,101.24) v11(147.27,100.67) v11(148.38,41.67) v11(149.58,98.14) v11(150.27,80.66) v11(151.44,80.66) v11(152.17,89.94) v11(154.48,6.46) v11(155.64,26.05) v11(156.27,6.46) v11(160.44,3.55) v11(161.18,3.64) v11(161.64,2.86) v11(163.42,2.84) v12(32.08,68.66) v12(32.15,67.54) v12(32.18,68.03) v12(32.51,66.88) v12(32.68,68.53) v12(32.68,68.03) v12(32.76,67.19) v12(33.07,67.27) v12(33.18,68.53) v12(33.3,67.87) v12(33.27,66.88) v12(33.6,69.04) v12(33.64,67.99) v12(33.58,66.91) v12(33.68,67.53) v12(34.18,67.03) v12(34.26,67.87) v12(34.52,68.94) v13(74.95,67.38) v13(75.26,65.56) v13(75.92,65.57) v13(95.98,108.29) v13(97.36,86.42) v13(102.66,79.26) v13(111.97,99.49) v13(113.7,87.62) v13(116.38,81.21) v13(117.03,87.92) v13(117.03,87.09) v13(121.87,108.29) v13(123.69,77.96) v13(142.34,60.38) v13(142.36,59.64) v14(2.43,12.05) v14(3.31,21.4) v14(3.31,14.1) v14(5.41,21.4) v14(5.66,51.47) v14(5.66,50.54) v14(6.11,18.5) v14(8.85,15.91) v14(13.31,102.51) v14(14.18,53.24) v14(14.42,101.53) v14(14.4,52.25) v14(15.4,100.5) v14(16.54,90.95) v14(16.57,92.37) v14(16.74,39.96) v14(16.67,36.79) v14(16.91,41.93) v14(16.91,37.93) v14(17.8,19.81) v14(18.32,92.36) v14(18.3,90.94) v14(19.64,60.53) v14(19.63,32.98) v14(19.63,32.54) v14(19.63,32.01) v14(20.14,92.41) v14(20.11,90.99) v14(20.24,31.45) v14(20.21,30.97) v14(20.79,13.61) v14(20.86,31.2) v14(21.05,49.42) v14(21.43,31.45) v14(21.38,30.99) v14(21.75,17.07) v14(21.84,36.21) v14(22.04,31.45) v14(22.04,30.94) v14(22.27,36.9) v14(22.87,60.6) v14(23.09,28.44) v14(23.24,69.07) v14(23.17,38.63) v14(23.29,31.76) v14(23.29,31.32) v14(23.29,30.87) v14(23.42,22.22) v14(25.89,54.82) v14(25.94,27.89) v14(27.15,31.76) v14(27.15,30.1) v14(27.19,76.83) v14(27.19,75.56) v14(27.19,74.29) v14(27.36,73.31) v14(27.83,76.36) v14(27.92,7.86) v14(28.03,77.15) v14(28.13,76.05) v14(28.63,73.31) v14(28.83,17.04) v14(29.02,9.48) v14(29.3,77.15) v14(29.38,74.22) v14(29.68,73.92) v14(29.9,73.31) v14(29.92,7.86) v14(30.42,7.86) v14(30.57,77.15) v14(30.95,73.95) v14(30.92,7.86) v14(31.04,76.05) v14(31.42,7.86) v14(31.57,74.83) v14(31.94,75.77) v14(31.9,3.07) v14(32.14,60.28) v14(32.18,68.03) v14(32.18,67.53) v14(32.34,45.69) v14(32.39,49.31) v14(32.64,40.57) v14(32.68,68.53) v14(32.84,75.76) v14(32.84,74.83) v14(33.07,28.72) v14(33.25,77.54) v14(33.25,76.62) v14(33.18,68.53) v14(33.31,92.67) v14(33.33,10.7) v14(33.61,95.23) v14(33.71,76.62) v14(33.68,68.53) v14(33.95,84.47) v14(33.95,83.82) v14(33.95,83.17) v14(33.95,78.62) v14(34.06,74.99) v14(34.38,45.58) v14(34.6,84.47) v14(34.6,83.82) v14(34.6,83.17) v14(34.6,81.87) v14(34.63,76.62) v14(34.71,89.78) v14(34.71,88.51) v14(34.94,41.23) v14(34.94,40.47) v14(35.16,45.58) v14(35.16,44.04) v14(35.25,83.82) v14(35.25,77.32) v14(35.28,88.51) v14(35.55,76.62) v14(35.85,89.78) v14(35.9,83.17) v14(35.9,79.92) v14(35.9,77.32) v14(35.93,45.58) v14(36.55,84.47) v14(36.55,78.62) v14(36.55,77.97) v14(36.55,77.32) v14(37.11,65.07) v14(37.09,61.23) v14(37.2,77.32) v14(37.85,85.82) v14(37.85,84.47) v14(37.85,81.22) v14(37.85,77.32) v14(37.9,61.36) v14(38.13,88.51) v14(38.5,84.47) v14(38.5,83.17) v14(38.5,77.32) v14(38.74,89.24) v14(38.83,60.22) v14(38.83,31.67) v14(38.87,68.07) v14(38.92,5.26) v14(39.15,84.47) v14(39.15,77.97) v14(39.15,77.32) v14(39.46,36.96) v14(39.47,31.67) v14(39.69,85.82) v14(39.8,83.17) v14(39.8,77.32) v14(39.99,84.12) v14(40.03,55.68) v14(40.15,76.62) v14(40.23,31.67) v14(40.45,77.32) v14(40.61,89.78) v14(40.61,88.51) v14(40.75,84.13) v14(40.75,82.84) v14(40.78,84.59) v14(40.76,83.48) v14(40.97,11.81) v14(41.1,82.52) v14(41.24,10.54) v14(41.35,82.88) v14(41.37,84.65) v14(41.39,84.1) v14(41.36,83.52) v14(41.75,82.52) v14(41.69,52.86) v14(41.73,52.11) v14(42.01,96.19) v14(41.99,76.62) v14(42.08,69.28) v14(42.14,68.28) v14(42.26,52.4) v14(42.45,76.62) v14(42.39,5.86) v14(42.39,4.97) v14(42.92,66.01) v14(43.02,70.07) v14(43.05,55.76) v14(43.02,7.79) v14(43.18,51.45) v14(43.25,12.58) v14(43.33,15.58) v14(43.43,56.09) v14(43.37,52.67) v14(43.98,92.6) v14(44.1,52.43) v14(44.62,70.28) v14(44.59,6.69) v14(44.73,105.66) v14(44.97,12.59) v14(45.17,30.79) v14(45.17,29.52) v14(45.34,84.41) v14(45.31,72.35) v14(45.41,94.24) v14(45.39,31.6) v14(45.37,28.35) v14(45.39,27.34) v14(45.5,64.22) v14(45.46,51.45) v14(45.54,42.29) v14(45.56,69.35) v14(45.6,50.46) v14(45.7,65.54) v14(45.73,15.45) v14(46.03,43.04) v14(46.01,31.9) v14(46.13,48.12) v14(46.11,46.84) v14(46.11,42.3) v14(46.18,26.98) v14(46.28,27.84) v14(46.45,105.49) v14(46.45,103.71) v14(46.45,102.06) v14(46.49,36.6) v14(46.47,32.64) v14(46.58,37.85) v14(46.63,28.21) v14(46.67,35.16) v14(46.91,94.24) v14(46.89,2.21) v14(47.01,47.58) v14(46.97,12.4) v14(47.14,60.41) v14(47.18,33.33) v14(47.41,92.6) v14(47.45,26.98) v14(47.39,10.51) v14(47.52,35.29) v14(47.51,34.45) v14(47.68,103.75) v14(48.14,37.86) v14(48.41,94.24) v14(48.41,29.38) v14(48.6,37.03) v14(48.62,35.96) v14(48.62,34.69) v14(48.68,72.35) v14(48.68,31.9) v14(48.76,29.75) v14(48.9,27.03) v14(48.99,105.49) v14(48.99,103.71) v14(48.99,102.06) v14(49.04,33.11) v14(49.41,32.44) v14(49.41,31.17) v14(49.63,89.17) v14(49.56,85.62) v14(49.63,76.41) v14(49.58,29.83) v14(49.67,28.56) v14(49.67,27.36) v14(49.91,94.24) v14(50.75,37.78) v14(51.41,94.24) v14(51.91,94.24) v14(52.75,40.28) v14(52.8,101.26) v14(53.2,7.09) v14(53.35,69.43) v14(53.39,2.21) v14(53.5,72.32) v14(54.03,65.11) v14(54.25,40.3) v14(54.86,107.75) v14(55.29,42.35) v14(55.54,64.33) v14(55.72,71.46) v14(55.7,70.72) v14(55.72,70.01) v14(55.77,62.69) v14(55.81,14.58) v14(55.98,102.85) v14(56.23,71.46) v14(56.24,70.7) v14(56.21,70.01) v14(56.54,102.86) v14(56.64,100.31) v14(56.71,71.43) v14(56.69,70.69) v14(56.71,70.01) v14(56.86,19.02) v14(57.12,102.88) v14(57.29,101.76) v14(57.26,37.79) v14(57.44,65.63) v14(58.23,102.23) v14(58.2,62.97) v14(58.26,64.43) v14(58.41,94.24) v14(58.91,94.24) v14(59.09,68.4) v14(59.27,72.21) v14(59.41,94.24) v14(59.86,98.34) v14(60.41,94.24) v14(60.4,78.84) v14(60.91,94.24) v14(61.41,80.64) v14(61.76,51.33) v14(61.76,47.9) v14(61.76,44.15) v14(61.76,40.4) v14(61.76,36.98) v14(61.76,33.23) v14(61.76,29.74) v14(63.34,66.63) v14(63.34,66.12) v14(63.34,65.61) v14(63.34,63.96) v14(63.34,63.46) v14(63.34,62.95) v14(63.85,66.63) v14(63.85,66.12) v14(63.85,65.61) v14(63.85,63.96) v14(63.85,63.46) v14(63.85,62.95) v14(64.88,90.71) v14(65.61,52.67) v14(66.01,29.67) v14(66.01,14.46) v14(66.31,96.19) v14(68.18,19.03) v14(68.37,90.79) v14(68.55,67.39) v14(68.61,87.97) v14(68.87,15.6) v14(68.9,6.72) v14(69.06,67.39) v14(69.57,62.63) v14(69.63,29.67) v14(69.69,67.39) v14(69.9,4.22) v14(70.06,86.19) v14(70.06,85.3) v14(70.13,69.93) v14(70.13,61.42) v14(70.2,67.39) v14(70.27,90.38) v14(70.37,83.39) v14(70.96,71.91) v14(71.24,31.36) v14(71.24,31.06) v14(71.17,4.73) v14(71.68,31.36) v14(71.68,31.06) v14(73.12,29.67) v14(73.72,31.32) v14(73.72,31.02) v14(74.15,31.32) v14(74.15,31.02) v14(74.27,96.03) v14(74.63,94.13) v14(75.26,65.56) v14(75.27,63.99) v14(75.27,62.42) v14(75.27,60.4) v14(75.92,65.57) v14(76.17,98.76) v14(76.57,64.78) v14(76.57,63.21) v14(76.57,61.63) v14(76.62,29.67) v14(77.22,63.99) v14(77.77,21.04) v14(78.08,101.56) v14(78.33,28.23) v14(78.33,25.41) v14(78.52,63.21) v14(79.19,81.21) v14(79.17,63.99) v14(79.17,63.21) v14(79.17,62.42) v14(79.6,103.78) v14(79.8,31.32) v14(79.8,31.02) v14(80.2,59.89) v14(80.24,31.32) v14(80.24,31.02) v14(80.24,22.05) v14(80.26,23.25) v14(80.49,22.62) v14(80.72,23.25) v14(80.74,22.08) v14(81.06,105.81) v14(81.1,24.59) v14(81.59,23.37) v14(81.85,7.62) v14(82.32,31.36) v14(82.32,31.06) v14(82.28,27.98) v14(82.52,107.84) v14(82.75,31.36) v14(82.75,31.06) v14(83.66,28.1) v14(83.79,15.65) v14(83.87,4.73) v14(83.98,109.94) v14(85.19,24.8) v14(85.95,27.18) v14(86.08,24.8) v14(86.76,9.61) v14(87.03,24.8) v14(87.73,88.44) v14(87.86,7.5) v14(87.92,24.8) v14(88.62,31.35) v14(88.62,31.04) v14(89.05,31.35) v14(89.05,31.04) v14(89.15,26.88) v14(89.61,26.88) v14(89.89,88.44) v14(90.08,91.88) v14(90.84,91.88) v14(90.95,27.01) v14(91.03,109.26) v14(91.04,31.4) v14(91.04,31.1) v14(91.47,91.88) v14(91.47,31.4) v14(91.47,31.1) v14(92.11,91.88) v14(92.71,83.17) v14(93.24,82.51) v14(93.21,80.56) v14(93.21,78.61) v14(93.49,26.83) v14(93.75,84.47) v14(93.93,110.38) v14(93.95,108.41) v14(93.95,107.22) v14(93.95,105.87) v14(93.91,104.12) v14(93.89,101.75) v14(93.95,98.34) v14(94.28,79.26) v14(94.28,78.61) v14(94.33,28.23) v14(94.36,26.96) v14(94.59,27.58) v14(94.84,28.2) v14(94.84,26.98) v14(95.2,78.61) v14(95.28,110.41) v14(95.93,25.23) v14(95.98,108.29) v14(95.98,103.49) v14(95.98,101.89) v14(95.98,100.29) v14(95.98,99.49) v14(96.26,78.61) v14(96.78,98.69) v14(96.78,97.09) v14(96.78,96.29) v14(97.03,25.22) v14(97.03,4.52) v14(97.13,31.24) v14(97.13,30.93) v14(97.36,86.42) v14(97.56,31.24) v14(97.56,30.93) v14(97.58,99.49) v14(97.81,24.12) v14(97.81,23.62) v14(97.81,23.12) v14(97.81,19.62) v14(97.81,16.62) v14(97.81,13.62) v14(97.81,10.62) v14(97.81,7.62) v14(98.22,28.15) v14(98.17,25.23) v14(98.27,92.16) v14(98.27,91.14) v14(98.27,90.13) v14(99.03,92.16) v14(99.03,91.14) v14(99.03,90.13) v14(99.54,31.25) v14(99.54,30.94) v14(99.79,92.16) v14(99.79,91.14) v14(99.79,90.13) v14(99.97,31.25) v14(99.97,30.94) v14(101.58,99.49) v14(101.58,98.69) v14(101.58,96.29) v14(102.06,14.9) v14(102.06,10.9) v14(102.06,9.9) v14(102.06,8.9) v14(102.38,97.89) v14(102.49,1.78) v14(102.66,79.91) v14(102.66,79.26) v14(103.04,59.89) v14(103.04,1.78) v14(103.06,15.9) v14(103.06,12.9) v14(103.06,8.9) v14(103.58,77.86) v14(104.06,14.9) v14(104.06,10.9) v14(104.06,8.9) v14(104.37,106.64) v14(104.38,105.44) v14(104.39,104.82) v14(104.38,100.22) v14(104.37,98.57) v14(104.4,97.29) v14(104.37,96.41) v14(104.91,89.24) v14(105.06,15.9) v14(105.06,14.9) v14(105.06,9.9) v14(105.41,77.86) v14(106.06,11.9) v14(106.06,9.9) v14(106.28,63.3) v14(106.37,108.29) v14(106.37,101.89) v14(106.37,100.29) v14(106.37,99.49) v14(107.06,19.9) v14(107.06,10.9) v14(107.17,98.69) v14(107.17,97.09) v14(107.17,96.29) v14(107.97,99.49) v14(108.15,77.86) v14(110.06,15.9) v14(110.06,11.9) v14(111.06,13.9) v14(111.97,99.49) v14(114.28,110.37) v14(114.77,101.68) v14(114.84,97.87) v14(114.84,95.27) v14(115.74,100.3) v14(115.76,99.47) v14(116.38,81.86) v14(116.38,81.21) v14(117,29.74) v14(118.75,109.56) v14(119.02,106.38) v14(119.72,104.23) v14(119.76,101.83) v14(119.8,107.41) v14(119.77,101.24) v14(119.8,97.87) v14(119.8,96.03) v14(120.05,29.74) v14(121.87,108.29) v14(121.87,101.89) v14(121.87,100.29) v14(121.87,99.49) v14(122.67,98.69) v14(122.67,97.09) v14(122.67,96.29) v14(122.97,29.74) v14(123.47,99.49) v14(123.69,77.96) v14(125.89,29.74) v14(127.47,99.49) v14(127.47,96.29) v14(128.27,97.89) v14(128.5,78.52) v14(128.66,110.43) v14(129.07,29.74) v14(130.28,107.18) v14(130.29,105.99) v14(130.3,105.39) v14(130.27,103.02) v14(130.26,101.73) v14(130.29,100.08) v14(130.27,98.49) v14(130.29,96.35) v14(130.31,94.8) v14(131.35,94.06) v14(132.27,101.89) v14(132.27,100.29) v14(132.27,99.49) v14(132.31,29.74) v14(132.4,83.6) v14(133.07,98.69) v14(133.07,97.09) v14(133.07,96.29) v14(133.87,99.49) v14(134.59,81.12) v14(135.61,29.74) v14(135.95,110.32) v14(137.87,99.49) v14(137.87,98.69) v14(137.87,96.29) v14(138.4,94) v14(138.67,97.89) v14(139.35,29.74) v14(140.43,93.93) v14(140.6,99.64) v14(140.74,97.12) v14(141.1,83.27) v14(141.1,82.96) v14(141.1,79.31) v14(141.1,78.99) v14(141.6,83.27) v14(141.6,82.96) v14(141.6,79.31) v14(141.6,78.99) v14(142.34,60.38) v14(142.36,59.64) v14(145.03,47.88) v14(145.59,89.84) v14(146.94,78.09) v14(146.94,77.77) v14(147.44,78.09) v14(147.43,77.77) v14(148.48,5.3) v14(151.68,89.75) v14(151.77,87.04) v14(152.01,85.98) v14(152.15,92.88) v14(152.12,92.28) v14(152.12,91.06) v14(154.91,3.49) v14(156.7,8.92) v14(161.71,6.55) v14(162.56,7.65) v14(163.23,3.17) v14(164.56,9.94) v16(3.65,69.04) v16(8.04,21.99) v16(11.41,88.14) v16(11.59,5.48) v16(11.91,4.4) v16(12.04,89.81) v16(13.8,102.23) v16(16.29,77.62) v16(17.5,91.65) v16(24.86,86.82) v16(41.18,76.79) v16(52.36,92.67) v16(53.44,76.79) v16(54.96,91.46) v16(55.66,78.12) v16(58.14,101.94) v16(58.26,56.77) v16(59.98,58.5) v16(63.41,103.71) v16(65.76,107.21) v16(66.49,40.04) v16(72.87,36.09) v16(78.2,92.16) v16(98.65,36.21) v16(110.84,37.61) v16(117.64,36.47) v16(124.94,36.02) v16(128.75,23.96) v16(131.1,34.25) v16(135.92,15.7) v16(145.01,69.81) v16(145.83,60.09) v16(148.82,107.27) v16(148.94,58.57) v16(152.57,80.42) v17(42.59,55.14) v17(88.85,84.47) v17(93.21,78.61) v17(94.28,79.26) v17(94.28,77.31) v17(97.36,86.42) v17(101.91,103.63) v17(102.06,14.38) v17(102.43,80.12) v17(102.66,79.26) v17(102.92,8) v17(103.02,7.67) v17(103.06,13.9) v17(103.06,12.9) v17(104.06,14.9) v17(105.06,17.38) v17(105.06,14.9) v17(105.45,17.78) v17(112.02,103.87) v17(115.48,80.77) v17(116.38,81.21) v17(122.63,103.64) v17(123.69,77.96) v17(127.86,103.52) v17(133.83,103.63) v17(138.21,103.75) v17(140.39,103.26)
