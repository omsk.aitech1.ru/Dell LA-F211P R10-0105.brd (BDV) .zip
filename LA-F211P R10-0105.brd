# Allegro board LA-F211P R10-0105.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VALW on GND2 (solid shape): 30.23,100.74 30.23,100.49 29.39,99.65 28.18,99.65 28.05,99.77 28.05,100.27 28.42,100.64 29.31,100.64 29.51,100.84 30.13,100.84
+5VALW on IN2 (solid shape): 23.87,74.8 23.87,73.17 23.71,73.02 23.71,72 23.54,71.82 22.93,71.82 22.93,74.98 23,75.05 23.63,75.05
+5VALW on GND3 (solid shape): 30.24,100.67 30.24,100.46 29.46,99.68 28.2,99.68 28.06,99.82 28.06,100.24 28.75,100.93 29.99,100.93
+5VALW on VCC: 19,71.71 18.51,72.2 18.51,89.64 19.89,91.01 26.62,91.01 30.45,94.85 30.45,98.99 30.05,99.4 23.21,99.4 23.21,102.56 25.23,102.56 27.47,103.49 28.4,105.73 28.4,106.65 28.64,107.24 29.23,107.48 56.23,107.48 56.23,81.34 55.75,80.85 49.23,80.85 47.85,82.23 47.85,85.79 46.69,86.95 45,86.95 44.99,86.96 44.99,100.33 44.27,101.05 36.31,101.05 34.64,99.37 34.64,92.64 27.02,85.02 27.02,83.5 23.87,80.35 23.87,72.73 22.85,71.71
+5VALW on GND3: 22.81,73.54 22.96,73.39 23.87,73.39 24.01,73.53 24.01,75.46 23.87,75.6 22.96,75.6 22.81,75.44
+5VALW on GND3: 51.96,86.22 54.42,86.22 54.61,86.04 54.61,84.57 54.5,84.46 51.85,84.46 51.67,84.64 51.67,85.94
+5VALW on IN3: 51.77,84.45 54.39,84.45 54.61,84.67 54.61,86.11 54.48,86.24 51.92,86.24 51.7,86.01 51.7,84.52
+5VALW on GND4: 51.84,84.46 54.42,84.46 54.63,84.68 54.63,86.04 54.45,86.22 51.86,86.22 51.69,86.05 51.69,84.61
+5VALW_VCONN1 on BOTTOM (solid shape): 26.48,67.44 26.48,66.7 26.36,66.58 25.07,66.58 24.88,66.76 24.88,67.1 24.73,67.25 24.47,67.25 24.41,67.31 24.41,67.47 24.47,67.54 24.72,67.54 24.79,67.6 26.32,67.6
+5VALW_VCONN1 on BOTTOM (solid shape): 31.91,69.36 31.91,66.69 31.86,66.65 31.83,66.6 31.82,66.57 31.72,66.57 31.67,66.62 31.67,66.62 31.47,66.83 31.4,66.89 31.41,67.03 31.4,67.08 31.4,67.47 31.41,67.53 31.4,67.58 31.4,67.97 31.41,68.03 31.4,68.08 31.4,68.47 31.41,68.53 31.4,68.58 31.4,68.97 31.41,69.03 31.39,69.11 31.28,69.23 31.11,69.24 31.08,69.24 31.02,69.3 31.02,69.55 31.09,69.61 31.66,69.61
+5VALW_VCONN1 on IN3 (solid shape): 29.54,68.02 30.17,67.39 30.26,67.39 30.32,67.33 30.56,67.33 30.57,67.32 30.68,67.3 30.79,67.32 30.8,67.33 31.06,67.33 31.07,67.32 31.18,67.3 31.29,67.32 31.3,67.33 31.54,67.33 31.57,67.3 31.94,67.3 32.1,67.14 32.1,66.82 32.01,66.73 31.96,66.72 31.93,66.7 31.88,66.67 31.85,66.63 31.39,66.63 31.35,66.68 31.2,66.75 31.04,66.71 31.01,66.68 30.92,66.78 30.86,66.83 30.69,66.87 30.52,66.84 30.2,66.9 29.96,66.67 29.95,66.63 29.88,66.63 28.67,67.84 28.67,68.22 28.93,68.47 29.09,68.47
+5VALW_VCONN2 on BOTTOM (solid shape): 30.37,96.05 30.37,95.74 30.4,95.71 30.99,95.13 30.99,94.59 30.84,94.44 30.32,94.44 30.2,94.57 28.61,94.57 28.47,94.71 28.47,95.1 28.52,95.15 29.22,95.15 29.4,95.33 29.84,95.33 30.04,95.53 30.04,96.02 30.08,96.06 30.36,96.06
+5VALWP on BOTTOM (solid shape): 61.19,91.52 61.19,87.84 60.55,87.2 51.53,87.2 51.41,87.33 51.41,87.84 51.66,88.09 52.04,88.09 52.17,88.22 52.17,91.01 52.3,91.14 52.68,91.14 52.8,91.01 52.8,90.51 53.18,90.13 53.95,90.13 54.33,90.51 54.33,91.01 54.58,91.27 56.74,91.27 57.38,91.9 60.8,91.9
+5VD on TOP (solid shape): outline of 409 points within 99.01,2.38 113.61,23.47
+5VD on BOTTOM (solid shape): 109.45,24.34 110.44,24.34 110.47,24.32 110.47,23.85 110.49,23.82 111.11,23.82 111.14,23.85 111.14,24.31 111.17,24.34 111.64,24.34 111.66,24.32 111.66,23.85 111.68,23.83 112.32,23.83 112.34,23.85 112.34,24.31 112.37,24.34 113.76,24.34 114.08,24.02 114.08,21.18 113.75,20.85 110.33,20.85 109.38,21.8 109.38,22.56 108.45,23.5 108.45,23.95 109,24.5 109.28,24.5
+5VD on BOTTOM (solid shape): 97.71,28.63 97.71,27.88 98.47,27.12 98.98,27.12 99.76,26.33 99.76,24.99 99.77,24.99 99.77,24.89 99.87,24.89 99.87,24.88 100.45,24.88 100.54,24.78 100.54,23.79 100.5,23.74 98.94,23.74 98.66,24.02 98.68,24.16 98.63,24.28 98.63,25.8 98.5,25.92 97.86,25.92 96.09,27.69 95.32,27.69 95.27,27.74 95.27,28.56 95.48,28.76 97.58,28.76
+5VD on BOTTOM (solid shape): 110.62,9.24 110.62,7.5 110.75,7.36 111.35,7.36 111.45,7.26 111.45,4.77 111.14,4.46 108.71,4.46 107.65,3.39 107.65,2.78 107.45,2.57 107.44,2.57 107.12,2.25 103.73,2.25 103.48,2.5 103.48,4 103.86,4.38 105.29,4.38 105.55,4.63 105.55,5.28 105.32,5.51 104.98,5.51 104.7,5.79 104.7,6.43 104.75,6.52 104.85,6.52 105.49,6.9 104.85,7.28 104.75,7.28 104.7,7.37 104.7,8.04 104.89,8.23 106.22,8.23 106.36,8.09 106.36,7.54 106.36,7.53 106.31,7.3 106.29,7.05 106.78,5.92 107.92,5.47 107.94,5.47 109.46,6.75 108.56,8.52 108.56,9.29 108.68,9.42 110.44,9.42
+5VD on GND2 (solid shape): 111.62,8.04 111.62,7.47 111.49,7.34 110.11,7.34 110.01,7.44 110.01,7.91 110.38,8.28 111.37,8.28
+5VD on GND3 (solid shape): 111.12,8.12 110.84,7.85 111.21,7.72 111.21,7.39 111.15,7.33 110.17,7.33 109.92,7.58 109.92,7.95 110.2,8.23 111.01,8.23
+5VDP on BOTTOM (solid shape): 117.57,27.05 117.57,21.1 117.19,20.72 115.03,20.72 114.33,21.42 114.33,24.15 113.95,24.53 109.83,24.53 109.38,24.97 109.38,27.14 109.4,27.16 117.46,27.16
+5VS on TOP (solid shape): 60.84,78.55 60.84,77.63 60.74,77.53 58.65,77.53 58.52,77.66 58.52,78.36 58.78,78.62 60.77,78.62
+5VS on TOP (solid shape): 89.86,29.34 89.86,28.51 89.75,28.4 89.14,28.4 88.65,27.91 87.32,27.91 87.17,28.07 87.17,28.99 87.42,29.23 88.32,29.23 88.52,29.43 89.76,29.43
+5VS on TOP (solid shape): 100.72,36.26 100.72,35.61 100.49,35.38 100.11,35.38 100.02,35.29 99.87,35.16 99.83,34.97 99.08,34.22 98.85,34.22 98.44,34.63 98.44,34.99 99.23,35.79 99.23,35.97 99.76,36.5 100.48,36.5
+5VS on BOTTOM (solid shape): 90.79,28.83 90.79,27.7 87.24,27.7 87.13,27.82 87.13,28.75 87.27,28.9 90.73,28.9
+5VS on BOTTOM (solid shape): 145.01,32 145.01,30.82 144.69,30.5 143.16,30.5 142.64,31.02 142.64,32.09 142.72,32.17 143.6,32.17 144.84,32.17
+5VS on BOTTOM (solid shape): 89.58,34.09 89.58,33.4 89.75,33.23 90.47,33.23 90.78,33.53 91.64,33.53 91.85,33.32 91.85,32.19 91.73,32.08 89.66,32.08 89.49,32.24 89.49,32.9 89.25,33.14 89.25,34.1 89.35,34.2 89.47,34.2
+5VS on BOTTOM (solid shape): 80.83,34.11 80.83,33.43 81,33.25 81.77,33.25 82.03,33.51 82.83,33.51 83.09,33.25 83.09,32.25 82.95,32.1 80.91,32.1 80.74,32.27 80.74,32.93 80.5,33.17 80.5,34.12 80.6,34.22 80.72,34.22
+5VS on BOTTOM (solid shape): 72.27,34.14 72.27,33.55 72.48,33.34 73.27,33.34 73.45,33.51 74.47,33.51 74.72,33.26 74.72,32.31 74.56,32.14 72.35,32.14 72.21,32.29 72.21,33.05 71.93,33.32 71.93,33.35 71.93,34.14 72.01,34.21 72.2,34.21
+5VS on BOTTOM (solid shape): 101.37,36.09 101.37,34.16 101.16,33.95 101.16,32.7 100.55,32.09 98.17,32.09 98.06,32.2 98.06,33.12 98.09,33.15 98.09,34.11 98.19,34.21 98.31,34.21 98.42,34.1 98.42,33.41 98.59,33.24 99.31,33.24 99.75,33.68 99.75,34.02 100.49,34.75 100.49,35.25 100.36,35.38 99.18,35.38 99.08,35.48 99.08,35.6 99.18,35.71 99.86,35.71 99.97,35.82 99.97,36.42 100.07,36.52 100.95,36.52
+5VS on IN2 (solid shape): outline of 3875 points within 65.63,31.21 100.52,42
+5VS on IN3 (solid shape): 101.68,36.15 101.68,35.2 101.64,35.17 100.76,35.17 100.56,35.36 100.02,35.36 99.85,35.53 99.85,36.41 99.97,36.54 101.3,36.54
+5VS on IN3 (solid shape): 143.91,33.92 143.91,32.77 144.58,32.11 144.7,32.11 144.84,31.96 144.84,31.57 144.68,31.4 143.09,31.4 142.62,31.87 142.62,33.67 143.31,34.37 143.47,34.37
+5VS_FAN on BOTTOM (solid shape): 143.97,36.68 143.97,35.84 143.99,35.82 143.99,32.98 143.81,32.8 142.64,32.8 142.53,32.92 142.53,33.15 142.37,33.3 142.37,36.5 142.66,36.79 143.86,36.79
+VBATT on BOTTOM (solid shape): 137.25,6.85 137.25,6.42 137.33,6.33 137.84,6.33 138.01,6.17 138.01,4.92 138.27,4.65 140.05,4.65 140.43,4.27 141.58,4.27 141.76,4.09 141.76,1.31 141.6,1.15 137.1,1.15 136.99,1.25 136.99,4.72 136.69,5.02 136.69,6.22 136.7,6.23 136.7,6.83 136.79,6.93 137.17,6.93
+VBUS1_DC_SS on BOTTOM (solid shape): 15.98,68.81 19.41,68.81 19.41,68.79 20.58,68.79 20.58,68.81 20.99,68.81 21.06,68.73 21.06,67.25 19.77,65.96 17.34,65.96 16.99,66.31 13.61,66.31 13.38,66.54 13.38,68.83 13.49,68.94 15.85,68.94
+VBUS2_DC_SS on BOTTOM (solid shape): 26.01,98.38 26.01,95.33 25.75,95.08 23.85,95.08 23.21,94.44 23.21,92.09 23.15,92.03 20.99,92.03 20.93,92.09 20.93,95.21 21.43,95.71 22.83,95.71 22.96,95.84 22.96,98.51 23.21,98.76 25.63,98.76
+VBUS2_DC_SS on IN3 (solid shape): 25.75,97.49 25.75,96.28 25.32,95.85 24.33,95.85 23.34,94.87 23.34,93.3 22.96,92.92 21.56,92.92 21.18,93.3 21.18,96.6 22.39,97.81 25.43,97.81
+VCC0V9_CIO on TOP (solid shape): 40,83.33 40,82.97 39.98,82.95 39.57,82.95 39.49,82.87 39.49,81.1 39.44,81.04 38.96,81.04 38.93,81.07 38.93,83.33 38.96,83.36 39.98,83.36
+VCC0V9_CIO on BOTTOM (solid shape): 39.4,83.35 39.4,81.11 39.34,81.05 39,81.05 38.95,81.1 38.95,83.4 39.36,83.4
+VCC0V9_DP on TOP (solid shape): 41.3,82.04 41.3,81.02 41.25,80.97 40.89,80.97 40.84,81.02 40.84,81.55 40.74,81.65 39.65,81.65 39.62,81.68 39.62,82.06 39.65,82.09 41.25,82.09
+VCC0V9_DP on TOP (solid shape): 38.1,84.52 38.1,83.03 38.05,82.97 37.66,82.97 37.64,83 37.64,83.51 37.54,83.61 37.03,83.61 37.03,84.02 37.06,84.04 37.54,84.04 37.59,84.09 37.59,84.52 37.64,84.58 38.05,84.58
+VCC0V9_DP on BOTTOM (solid shape): 40.62,81.95 40.62,80.41 40.56,80.36 40.4,80.36 40.26,80.5 40.26,80.86 40.08,81.04 39.67,81.04 39.6,81.12 39.6,81.94 39.67,82.01 40.55,82.01
+VCC0V9_DP on IN2 (solid shape): outline of 208 points within 36.99,80.98 40.67,85.47
+VCC0V9_PCIE on TOP (solid shape): 38.07,80.71 38.07,78.99 38.71,78.35 38.71,77.79 38.68,77.77 37.03,77.77 37,77.79 37,78.15 37.03,78.17 37.51,78.17 37.64,78.3 37.64,80.71 37.69,80.77 38.02,80.77
+VCC0V9_USB on TOP (solid shape): 39.37,80.08 39.37,79.57 39.47,79.47 40.48,79.47 40.51,79.44 40.51,79.09 40.48,79.06 38.96,79.06 38.93,79.09 38.93,80.08 38.96,80.1 39.34,80.1
+VCC_CORE on TOP (solid shape): outline of 414 points within 112.81,45.48 133.96,78.57
+VCC_CORE on BOTTOM (solid shape): outline of 767 points within 113.19,77.17 121.19,79.01
+VCC_CORE on BOTTOM (solid shape): outline of 2016 points within 113.76,44.15 135.66,65.49
+VCC_CORE on IN1 (solid shape): outline of 2786 points within 115.29,45.8 133.7,72.62
+VCC_CORE on IN2 (solid shape): outline of 3920 points within 111.48,45.8 133.7,78.89
+VCC_CORE on IN3 (solid shape): outline of 1881 points within 111.48,54.89 127.1,76.21
+VCC_CORE on VCC: 115.29,45.8 115.29,50.78 117.07,52.55 117.07,66.86 114.38,69.55 111.84,69.55 111.48,69.91 111.48,73.76 113.38,75.67 113.38,78.95 121.26,78.95 121.26,71.48 125.19,67.54 125.19,62.21 126.08,61.32 126.08,59.54 126.84,58.78 126.84,56.62 133.7,49.76 133.7,46.29 133.22,45.8
+VCCGT on TOP (solid shape): outline of 709 points within 119.66,51.64 141.64,81.7
+VCCGT on BOTTOM (solid shape): outline of 3083 points within 121.41,52.41 142.85,79.05
+VCCGT on IN2 (solid shape): outline of 3882 points within 121.57,53.61 140.94,78.76
+VCCGT on IN3 (solid shape): outline of 1466 points within 122.02,54.69 133.58,78.7
+VCCGT on VCC: 134.06,50.12 127.35,56.83 127.35,58.99 126.59,59.75 126.59,61.53 125.7,62.42 125.7,67.75 121.76,71.69 121.76,78.95 140.45,78.95 140.94,78.46 140.94,50.12
+VCCIO on TOP (solid shape): 111.76,63.76 111.76,62.11 111.73,62.08 110.84,62.08 110.79,62.13 110.79,63.76 110.84,63.81 111.71,63.81
+VCCIO on TOP (solid shape): 112.81,78.25 112.81,77.04 112.75,76.98 112.11,76.98 112.05,77.04 112.05,77.87 111.86,78.06 111.22,78.06 111.1,78.19 111.1,78.44 111.22,78.57 112.49,78.57
+VCCIO on TOP (solid shape): 105.51,44.79 105.51,40.4 105.13,40.02 105.13,40.02 105.08,39.97 105.08,39.09 104.81,38.82 103.29,38.82 103.03,39.07 103.03,39.58 103.6,39.58 103.6,41.61 103.1,41.61 103.1,44.66 103.35,44.91 105.38,44.91
+VCCIO on BOTTOM (solid shape): outline of 253 points within 110.4,77.43 113.07,79
+VCCIO on BOTTOM (solid shape): outline of 1018 points within 104.37,41.23 113.45,65.55
+VCCIO on IN3 (solid shape): 106.4,44.66 106.4,41.87 106.14,41.61 103.98,41.61 103.73,41.87 103.73,44.66 103.98,44.91 106.14,44.91
+VCCIO on IN2: 111.29,65.11 109.5,65.11 109.2,64.81 109.2,63.69 108.04,62.53 108.04,61.14 107.31,60.41 107.31,53.58 106.12,52.39 106.12,47.44 104.06,45.37 104.06,41.57 104.32,41.31 105.82,41.31 106.28,41.77 106.28,44.97 106.62,45.32 107.83,45.32 108.46,45.95 108.46,50.82 108.96,51.32 108.96,52.44 111.37,54.84 111.37,65.03
+VCCIO on VCC: 104.47,41.61 103.41,42.67 103.41,76.81 105.55,78.95 112.87,78.95 112.87,75.88 110.97,73.97 110.97,55.05 110.33,54.42 110.33,42.88 108.83,42.88 107.56,41.61
+VCCSA on TOP (solid shape): outline of 125 points within 109.57,43.9 116.87,69
+VCCSA on BOTTOM (solid shape): outline of 821 points within 107.67,43.9 116.62,65.55
+VCCSA on IN1 (solid shape): outline of 1585 points within 109.13,43.26 116.56,69.35
+VCCSA on IN2 (solid shape): outline of 1427 points within 109.19,43.01 116.56,69.04
+VCCSA on IN3 (solid shape): outline of 2248 points within 108.05,43.64 116.81,69.23
+VCCSA on VCC: 110.84,42.88 110.84,54.21 111.48,54.84 111.48,68.68 111.84,69.04 114.17,69.04 116.56,66.65 116.56,52.77 114.78,50.99 114.78,45.65 112.01,42.88
+VCCST on IN3 (solid shape): outline of 196 points within 103.84,61.49 109.61,64.3
+VCCST on IN3 (solid shape): outline of 443 points within 83.02,55.21 84.93,63.58
+VCCSTG on IN2 (solid shape): outline of 579 points within 110.33,77.55 113.26,84.92
+VCCSTG on IN3 (solid shape): outline of 136 points within 104.85,60.76 107.59,62.37
+VDD08 on TOP (solid shape): 108.18,69.81 108.18,68.79 107.92,68.54 105.76,68.54 105.38,68.15 105.38,66.5 105,66.13 105,65.53 105.22,65.32 105.94,65.32 106.14,65.12 106.14,64.23 106.07,64.15 104.79,64.15 104.68,64.04 104.68,60.53 104.62,60.47 104.62,55.58 104.24,55.2 102.97,55.2 102.73,55.44 102.73,60.8 103.6,61.68 103.6,63.86 103.86,64.11 103.86,69.81 103.98,69.93 108.05,69.93
+VDD08 on BOTTOM (solid shape): 138.25,79.14 135.29,79.14 135.04,79.39 135.04,82.77 135.42,83.15 138.25,83.15
+VDD08 on BOTTOM (solid shape): outline of 241 points within 102.4,52.58 104.24,61.69
+VDD08 on IN1 (solid shape): outline of 2837 points within 103.09,54.44 137.39,82.25
+VDD08P on BOTTOM (solid shape): 150.83,83.25 150.83,81.14 148.08,78.38 146.59,78.38 146.38,78.59 146.38,83.14 146.83,83.59 150.49,83.59
+VDD08P on BOTTOM (solid shape): 140.61,82.48 143.65,82.48 143.79,82.33 143.79,80.05 143.59,79.85 141,79.85 140.23,79.07 139.37,79.07 138.96,79.48 138.96,82.87 139.07,82.99 140.1,82.99
+VDD08P on IN3 (solid shape): 147.65,83.3 147.65,79.87 147.44,79.65 144.83,79.65 144.19,80.29 142.96,80.29 142.8,80.45 142.8,83.23 143.18,83.62 147.34,83.62
+VDD12 on TOP (solid shape): 79.89,78.16 79.89,72.57 79.67,72.36 79.29,72.36 79,72.07 78.99,72.06 78.99,71.18 79.06,71.11 80.3,71.11 80.72,70.69 84.16,70.69 84.25,70.6 84.25,70.12 84.03,69.9 83.92,69.9 83.76,69.74 83.76,68.86 83.66,68.76 80.31,68.76 80.13,68.57 80.13,67.77 79.88,67.52 79.1,67.52 79,67.41 79,63.03 73.06,57.09 69.71,57.09 61.31,65.49 58.84,65.49 58.61,65.72 67.29,65.72 67.29,66.38 67.41,66.38 67.41,65.74 67.5,65.65 67.5,65.64 67.51,65.64 67.54,65.61 69.31,65.61 69.44,65.74 69.44,66.38 69.31,66.5 67.54,66.5 67.51,66.48 67.5,66.48 67.5,66.46 67.41,66.38 67.29,66.38 67.29,66.43 66.51,66.43 66.51,65.72 66.28,65.72 66.28,66.43 65.49,66.43 65.49,65.72 58.61,65.72 58.53,65.79 65.14,65.79 65.14,66.5 64.35,66.5 64.35,65.79 58.53,65.79 57.12,67.2 57.12,71.31 57.34,71.53 61.29,71.53 61.61,71.21 61.61,70.34 62.65,69.3 66.01,69.3 66.14,69.17 66.9,69.17 67.03,69.3 67.41,69.3 67.66,69.55 68.81,69.55 77.58,78.33 79.72,78.33
+VDD12 on BOTTOM (solid shape): outline of 1391 points within 65.5,57.11 80.2,71.46
+VDD12 on IN1 (solid shape): outline of 169 points within 76.93,66.76 84.13,76.79
+VDD12 on IN2 (solid shape): outline of 1175 points within 74.77,66.38 81.25,77.19
+VDD12 on VCC: 70.18,55.58 69.69,56.07 69.69,60.89 68.78,61.8 65.86,61.8 64.61,63.05 64.61,71.73 70.18,77.3 79.35,77.3 79.35,73.51 79.75,73.11 81.02,73.11 81.25,72.87 81.25,67.88 81.15,67.77 79.75,67.77 79.35,67.37 79.35,55.94 78.99,55.58
+VDD_18 on TOP (solid shape): 111.37,74.71 111.37,69.44 111.24,69.3 108.73,69.3 108.46,69.58 108.46,74.73 108.73,75.01 111.06,75.01
+VDD_18 on TOP (solid shape): 67.76,91.83 67.76,90.68 67.72,90.65 66.47,90.65 66.31,90.49 65.42,90.49 65.38,90.44 65.38,90.04 65.29,89.95 64.44,89.95 64.35,90.04 64.35,90.41 65.03,91.09 65.03,91.55 65.14,91.66 66.38,91.66 66.45,91.66 66.73,91.93 67.65,91.93
+VDD_18 on IN2 (solid shape): 110.37,75.71 110.37,73.99 110.26,73.88 109.41,73.88 109.29,74 109.29,75.71 109.54,75.96 110.11,75.96
+VDD_18 on IN2 (solid shape): outline of 171 points within 67.57,87.97 77.95,91.78
+VDD_18 on GND3 (solid shape): 77.67,88.8 77.67,88.3 77.41,88.04 76.38,88.04 76.16,88.26 76.16,89.11 76.25,89.2 77.27,89.2
+VDD_18 on GND2: 67.45,90.56 67.35,90.65 67.35,91.46 67.42,91.53 68.54,91.53 68.65,91.43 68.65,90.68 68.52,90.56
+VDD_18 on GND3: 110.58,75.88 110.42,76.03 109.15,76.03 109.05,75.93 109.05,74.01 109.18,73.88 110.41,73.88 110.58,74.05
+VDD_33 on TOP (solid shape): 82.61,81.7 82.61,80.66 82.65,80.62 82.65,80.01 82.45,79.8 81.66,79.8 80.85,80.61 80.85,81.57 80.94,81.66 81.99,81.66 82.06,81.74 82.57,81.74
+VDD_33 on TOP (solid shape): 108.04,62.95 108.04,62.34 107.96,62.26 107.43,62.26 107.36,62.19 107.36,60.1 106.55,59.29 104.9,59.29 104.75,59.44 104.75,60.43 104.8,60.48 105.68,60.48 105.83,60.63 105.83,62.14 105.52,62.45 105.52,62.95 105.57,63 107.98,63
+VDD_33 on BOTTOM (solid shape): 87.37,91.78 87.41,91.76 87.42,91.73 87.51,91.54 87.71,91.5 87.73,91.51 88.12,91.13 88.88,91.13 89.51,90.51 89.8,90.51 89.8,90.38 90.36,90.38 90.36,90.51 90.56,90.51 90.56,90.38 92.4,90.38 92.4,90.21 92.42,90.19 92.42,89.95 92.32,89.86 89.85,89.86 89.72,90 86.71,90 86.65,89.94 86.62,89.94 86.62,89.91 86.59,89.87 86.59,89.49 86.62,89.45 86.62,89.35 86.98,89.35 87.22,89.11 87.22,88.86 87.09,88.73 86.69,88.73 86.55,88.73 86.2,88.73 85.82,89.11 85.82,89.49 86.33,90 86.33,91.14 86.97,91.78
+VDD_33 on BOTTOM (solid shape): outline of 88 points within 104.3,56.03 105.76,61.04
+VDD_33_GPU on BOTTOM (solid shape): 106.06,91.85 106.06,90.11 105.54,89.59 104.72,89.59 104.49,89.36 104.49,88.09 103.86,87.46 93.44,87.46 93.32,87.59 93.32,87.97 93.44,88.09 102.97,88.09 103.22,88.35 103.22,88.73 103.1,88.86 101.57,88.86 101.44,88.98 101.44,89.36 101.7,89.62 103.98,89.62 104.75,90.38 104.75,90.89 104.62,91.01 104.11,91.01 103.98,91.14 103.98,92.01 104.26,92.29 105.62,92.29
+VDDAN_18 on TOP (solid shape): 109.79,68.57 109.79,65.58 109.67,65.46 108.4,65.46 108.3,65.55 108.3,68.41 108.5,68.61 109.75,68.61
+VDDAN_18 on BOTTOM (solid shape): 106.46,60.79 106.46,57.61 106.41,57.52 106.31,57.52 105.93,57.29 106.31,57.07 106.41,57.07 106.46,56.98 106.46,56.96 106.41,56.87 106.31,56.87 105.93,56.64 106.31,56.42 106.41,56.42 106.46,56.33 106.46,55.33 106.21,55.07 106.21,53.5 106.13,53.42 105.13,53.42 105.06,53.49 105.06,55.39 105.7,56.03 105.7,58.38 105.89,58.57 105.89,60.92 105.95,60.98 106.27,60.98
+VDDAN_18 on IN1 (solid shape): outline of 263 points within 105.76,55.26 109.64,66.38
+VDDAN_18 on IN3: 105.67,55.15 106.67,55.15 106.67,55.15 106.95,55.15 107.05,55.25 107.05,60.37 106.59,60.83 106.15,60.83 105.58,60.26 105.58,55.24
+VDDCI on TOP (solid shape): 75.58,52.63 75.58,49.5 74.31,48.23 72.81,48.23 72.74,48.29 72.74,48.66 73.31,48.66 73.31,50.06 72.74,50.06 72.74,52.47 72.95,52.69 73.87,52.69 74.04,52.85 75.36,52.85
+VDDCI on TOP (solid shape): 88.11,68.09 88.11,64.73 87.98,64.6 87.3,64.6 87.21,64.51 87.21,63.65 87.33,63.53 88.12,63.53 88.3,63.36 88.3,62.4 88.08,62.18 88.08,60.54 88.11,60.5 88.11,57.23 87.47,56.6 86.46,56.6 86.33,56.72 86.33,57.36 85.63,58.06 85.63,62.44 85.89,62.69 85.89,68.03 86.08,68.22 87.98,68.22
+VDDCI on BOTTOM (solid shape): outline of 497 points within 85.38,55.96 87.62,62.98
+VDDCI on IN3 (solid shape): outline of 412 points within 85.32,56.09 87.6,67.52
+VDDCIP on TOP (solid shape): 71.97,51.04 71.97,50.63 72.11,50.49 72.5,50.49 72.55,50.43 72.55,48.41 72.48,48.34 71.6,48.34 71.35,48.59 71.35,49.04 71.23,49.16 69.63,49.16 69.41,49.38 69.41,50.98 69.59,51.15 71.86,51.15
+VDDCIP on BOTTOM (solid shape): 72.04,52.6 72.04,49.93 71.85,49.74 69.69,49.74 69.44,49.99 69.44,52.55 69.68,52.79 71.85,52.79
+VDDCIP on GND2: 70.2,49.85 71.05,49.85 71.16,49.96 71.16,50.79 71.06,50.89 70.17,50.89 70.1,50.83 70.1,49.94
+VDDCIP on GND3: 71.11,50.9 70.18,50.9 70.07,50.79 70.07,50 70.2,49.87 71.15,49.87 71.24,49.96 71.24,50.78
+VDDD_SUPPLY_3.3V on TOP (solid shape): 32.61,68.41 32.61,67.77 32.48,67.65 31.34,67.65 31.21,67.52 31.21,66.88 31.09,66.76 30.58,66.76 30.45,66.88 30.45,67.52 30.2,67.77 29.95,67.77 29.9,67.82 29.9,68.44 30,68.54 32.48,68.54
+VDDD_SUPPLY_3.3V on TOP (solid shape): 36.58,70.23 36.58,69.71 36.46,69.59 36.46,69.59 36.41,69.54 36.41,67.89 36.11,67.58 36.11,66.95 36.27,66.78 36.5,66.78 36.51,66.78 36.78,66.78 36.86,66.69 36.86,66 36.72,65.85 35,65.85 34.83,66.03 34.83,67.7 34.86,67.74 35.24,67.74 35.69,68.19 35.69,70.07 35.93,70.3 36.51,70.3
+VDDD_SUPPLY_3.3V on BOTTOM (solid shape): 31.34,71.33 31.34,70.86 31.24,70.76 30.13,70.76 30.08,70.81 27.83,70.81 27.76,70.88 27.76,71.39 27.89,71.53 31.14,71.53
+VDDD_SUPPLY_3.3V on IN1 (solid shape): outline of 293 points within 29.82,66.12 35.66,71.33
+VDDIO_18 on BOTTOM (solid shape): 107.41,59.9 107.41,56.28 107.54,56.15 107.54,54.91 107.54,53.82 107.58,53.78 107.93,53.78 108.19,53.52 108.19,50.76 108.07,50.63 107.34,50.63 107.16,50.81 107.16,52.91 106.91,53.17 106.91,55.07 106.65,55.33 106.65,59.9 106.84,60.09 107.22,60.09
+VDDIO_18 on IN1: 106.99,53.08 106.91,53.16 106.91,62.01 107.27,62.37 109.31,62.37 109.77,62.83 109.77,64.5 110.37,65.09 110.37,66.52 110.05,66.84 110.05,68.38 110.22,68.55 111.23,68.55 111.37,68.41 111.37,63.87 111.16,63.66 111.16,60.89 110.86,60.6 108.85,60.6 108.35,60.1 108.35,53.28 108.15,53.08
GND on TOP (solid shape): 38.13,66.76 38.13,65.8 38.07,65.74 37.25,65.74 37.12,65.87 37.12,66.69 37.31,66.88 38.01,66.88
GND on TOP (solid shape): 56.79,79.66 56.79,78.31 55.37,76.89 53.88,76.89 53.08,77.69 53.08,79.92 53.2,80.04 56.41,80.04
GND on TOP (solid shape): 69.19,66.25 69.19,65.87 69.06,65.74 67.66,65.74 67.54,65.87 67.54,66.25 67.66,66.38 69.06,66.38
GND on TOP (solid shape): 98.13,62.29 98.13,60.68 98.07,60.62 96.51,60.62 96.43,60.7 96.43,62.33 96.48,62.38 98.03,62.38
GND on TOP (solid shape): 109.7,63.99 109.7,60.76 109.65,60.71 109.14,60.71 109.11,60.74 109.11,64.01 109.17,64.06 109.62,64.06
GND on TOP (solid shape): 114.07,49.09 114.07,46.34 114.06,46.32 111.67,46.32 111.64,46.35 111.64,49.12 111.65,49.13 114.03,49.13
GND on TOP (solid shape): 136.5,18.5 136.5,15 136.22,14.73 132.77,14.73 132.43,15.07 132.43,17.93 133.13,18.62 136.37,18.62
GND on TOP (solid shape): 138.21,3.54 138.21,1.29 138.07,1.15 135.72,1.15 135.57,1.3 135.57,3.56 135.82,3.82 137.93,3.82
GND on TOP (solid shape): 10.39,22.31 10.39,20.66 9.88,20.15 9.88,19.01 9.62,18.75 7.85,18.75 7.59,19.01 7.59,22.18 7.85,22.43 10.26,22.43
GND on TOP (solid shape): 36.68,71.36 36.68,70.54 36.56,70.42 35.93,70.42 35.74,70.62 34.99,70.62 34.91,70.7 34.91,71.37 35.02,71.49 36.56,71.49
GND on TOP (solid shape): 60.17,53.93 60.17,52.81 60.09,52.74 59.04,52.74 58.92,52.85 57.18,52.85 57.18,53.68 58.85,53.68 59.23,54.06 60.04,54.06
GND on TOP (solid shape): 80.3,93.92 80.3,93.11 80.03,92.84 80.03,91.65 79.97,91.59 77.44,91.59 77.25,91.78 77.25,93.74 77.61,94.1 80.12,94.1
GND on TOP (solid shape): 83.09,76.41 83.09,74.63 83.28,74.45 83.28,72.32 83.22,72.26 82.57,72.26 82.52,72.3 82.52,76.35 82.65,76.47 83.03,76.47
GND on TOP (solid shape): 94.61,62.53 94.61,60.42 94.58,60.39 94.28,60.39 94,60.67 93.4,60.67 93.3,60.77 93.3,62.39 93.62,62.71 94.43,62.71
GND on TOP (solid shape): 65.49,48.41 67.37,48.41 67.45,48.34 67.45,48 66.65,47.2 64.02,47.2 63.95,47.26 63.95,48.64 64.02,48.71 65.19,48.71
GND on TOP (solid shape): 103.67,66.06 103.67,64.1 103.48,63.91 103.48,61.87 103.41,61.8 103.03,61.8 102.97,61.87 102.97,66 103.1,66.12 103.6,66.12
GND on TOP (solid shape): 105.42,76.71 105.42,73.34 105.21,73.13 104.23,73.13 104.02,73.35 104.02,74.41 103.92,74.5 103.92,77.31 104,77.39 104.74,77.39
GND on TOP (solid shape): 15.52,30.1 18.26,30.1 18.44,29.93 18.44,29.22 18.31,29.09 15.74,29.09 15.54,28.89 13.76,28.89 13.61,29.04 13.61,30.28 13.74,30.41 15.21,30.41
GND on TOP (solid shape): 55.98,69.42 55.98,65.61 55.47,65.11 52.17,65.11 51.97,65.31 51.94,65.36 51.91,65.4 51.91,69.55 52.3,69.93 55.47,69.93
GND on TOP (solid shape): 83,106.91 83.03,106.89 83.03,106.09 83.02,106.08 83.02,106.05 82.65,105.67 81.61,105.67 81.51,105.77 81.51,106.58 81.3,106.79 81.3,109.53 83,109.53
GND on TOP (solid shape): 97.63,51.26 97.63,46.06 97.89,45.8 98.78,45.8 98.84,45.74 98.84,45.17 98.78,45.1 97,45.1 96.81,45.29 96.81,51.2 96.94,51.33 97.57,51.33
GND on TOP (solid shape): 114.55,28.63 114.55,27.33 114.5,27.29 114.09,27.29 114.02,27.22 114.02,26.66 113.93,26.58 113.48,26.58 113.37,26.68 113.37,28.55 113.54,28.72 114.46,28.72
GND on TOP (solid shape): 126.59,39.96 126.59,32.66 126.46,32.53 123.22,32.53 122.97,32.78 122.97,37.48 123.03,37.55 123.8,37.55 124.18,37.93 124.18,40.21 124.3,40.34 126.21,40.34
GND on TOP (solid shape): 64.87,106.89 64.87,105.62 64.42,105.17 64.42,104.22 64.36,104.16 64.04,104.16 63.98,104.22 63.98,106.06 63.99,106.07 63.99,106.08 64.23,106.32 64.23,106.83 64.36,106.95 64.8,106.95
GND on TOP (solid shape): 129.38,24.09 129.38,21.93 128.88,21.42 126.65,21.42 126.04,22.03 126.04,23.45 125.97,23.53 125.97,24.39 126.11,24.53 128.94,24.53
GND on TOP (solid shape): 129.57,51.07 129.57,49.55 129.97,49.15 130.53,49.15 130.53,46.41 130.5,46.39 128.16,46.39 128.14,46.41 128.14,48.77 127.61,49.31 127.61,51.07 127.8,51.26 129.38,51.26
GND on TOP (solid shape): 152.73,70.82 152.73,66.86 152.5,66.63 150.06,66.63 149.81,66.38 143.63,66.38 143.47,66.54 143.47,68.41 144.39,69.33 144.39,70.72 144.89,71.21 145.64,71.21 146.01,71.58 151.96,71.58
GND on TOP (solid shape): 85.63,68.09 85.63,62.69 85.51,62.57 85.51,60.6 85.44,60.53 85,60.53 84.87,60.66 84.87,62.24 84.5,62.61 84.45,62.66 84.45,66.95 84.87,67.36 84.87,68.09 84.93,68.15 85.57,68.15
GND on TOP (solid shape): 150.66,61.23 150.66,60.42 151.1,59.98 151.1,57.89 149.42,56.22 144.37,56.22 144.27,56.31 144.27,61.39 144.43,61.55 150.34,61.55
GND on TOP (solid shape): 134.24,40.9 134.24,39.4 133.77,38.93 133.77,34.12 133.58,33.93 130.27,33.93 130.15,34.05 130.15,38.44 130.34,38.63 130.84,38.63 131.16,38.94 131.16,40.02 130.97,40.21 130.97,41.17 131.04,41.23 133.9,41.23
GND on TOP (solid shape): 94.71,49.93 94.71,47.2 94.59,47.07 92.24,47.07 92.17,47.14 92.17,49.99 92.3,50.12 94.52,50.12
GND on TOP (solid shape): 119.35,39.77 119.35,33.1 119.22,32.98 115.99,32.98 115.8,33.17 115.8,34.37 115.6,34.56 115.35,34.56 115.29,34.63 115.29,37.86 115.41,37.99 116.62,37.99 116.87,38.25 116.87,38.82 116.49,39.2 116.49,39.9 116.56,39.96 119.16,39.96
GND on TOP (solid shape): 128.32,71.63 128.32,70.57 128.29,70.54 127.91,70.54 127.83,70.62 126.92,70.62 126.89,70.64 126.89,71.13 126.92,71.15 127.66,71.15 127.91,71.41 127.91,71.63 127.94,71.66 128.29,71.66
GND on TOP (solid shape): 111.92,40.15 111.92,33.74 111.69,33.51 109.5,33.51 109.32,33.69 109.32,34.75 108.62,35.45 108.62,38.63 109.76,38.63 110.02,38.88 110.02,39.58 109.83,39.77 109.83,40.4 109.89,40.47 111.6,40.47
GND on TOP (solid shape): 58.01,59.77 58.01,57.93 58.14,57.8 58.18,57.8 58.19,57.79 61.2,57.79 61.25,57.74 61.25,56.91 61.17,56.83 61.17,55.54 60.93,55.3 59.18,55.3 58.65,55.84 58.65,56.6 58.39,56.85 55.72,56.85 55.22,57.36 55.22,59.77 55.47,60.03 57.76,60.03
GND on TOP (solid shape): 81.47,77.99 81.47,72.29 82.08,71.67 84.11,71.67 84.27,71.52 84.27,70.95 84.12,70.81 80.75,70.81 80.3,71.25 79.16,71.25 79.09,71.32 79.09,72.02 79.33,72.25 79.89,72.25 80.17,72.54 80.17,78.22 80.33,78.38 81.08,78.38
GND on TOP (solid shape): 112.77,68.74 112.77,60.84 112.62,60.69 110.87,60.69 110.82,60.74 110.82,61.35 110.89,61.42 111.83,61.42 112.06,61.65 112.06,64.32 111.91,64.47 110.89,64.47 110.82,64.55 110.82,65.18 110.92,65.28 111.86,65.28 112.06,65.49 112.06,68.71 112.14,68.79 112.72,68.79
GND on TOP (solid shape): 76.55,108.35 76.55,108.03 76.68,107.91 76.68,106.89 76.43,106.64 74.14,106.64 74.01,106.51 73,106.51 72.74,106.25 72.74,105.62 72.49,105.37 71.73,105.37 71.47,105.62 71.47,107.21 71.73,107.46 75.16,107.46 76.17,108.48 76.43,108.48
GND on TOP (solid shape): 63.26,103.36 63.53,103.08 63.53,102.89 63.66,102.76 64.04,102.76 64.11,102.7 64.11,102.51 63.73,102.13 63.09,102.13 62.84,101.87 62.84,100.79 62.72,100.68 61.17,100.68 60.99,100.86 60.99,101.3 60.93,101.36 58.07,101.36 57.76,101.68 57.76,103.21 57.91,103.36 59.43,103.36
GND on TOP (solid shape): 57.81,93.96 57.81,92.74 57.54,92.47 56.71,92.47 56.59,92.35 56.59,91.67 56.13,91.22 53.23,91.22 53.08,91.37 53.08,91.82 53.73,92.47 53.73,92.63 54.17,93.06 54.17,93.07 54.25,93.12 54.31,93.2 54.31,93.21 54.76,93.66 56.59,93.66 57.01,94.07 57.69,94.07
GND on TOP (solid shape): 107.45,65.13 107.45,64.18 107.57,64.06 107.84,64.06 108.01,63.89 108.01,63.26 107.86,63.11 105.49,63.11 105.4,63.01 105.4,62.35 105.54,62.21 105.54,60.68 105.49,60.63 104.89,60.63 104.81,60.71 104.81,63.95 104.9,64.05 106.24,64.05 106.43,64.23 106.43,65.07 106.63,65.27 107.32,65.27
GND on TOP (solid shape): 103.73,29.93 103.73,29.77 103.34,29.38 103.34,28.26 103.65,27.95 103.65,26.68 103.3,26.32 103.3,25.2 103.17,25.08 103.17,24.61 102.73,24.16 95.98,24.16 95.98,24.77 95.12,24.77 95.12,25.51 95.27,25.66 101.01,25.66 101.27,25.41 101.27,25.39 101.43,25.23 102.32,25.23 102.51,25.41 102.51,27.83 103.02,28.34 103.02,29.66 103.41,30.05 103.6,30.05
GND on TOP (solid shape): 43.15,22.94 43.15,21.9 43.14,21.86 43.14,21.82 43.14,20.77 42.85,20.48 42.74,20.48 42.74,20.12 42.52,19.89 42.14,19.89 41.88,20.15 41.88,20.66 42.01,20.78 42.52,20.78 42.59,20.86 42.71,20.86 42.71,20.98 42.77,21.04 42.77,22.82 42.64,22.94 38.96,22.94 38.83,22.82 38.83,20.91 38.96,20.78 39.6,20.78 39.85,20.53 39.85,20.02 39.72,19.89 39.34,19.89 38.71,20.53 38.71,20.78 38.65,20.84 38.65,20.91 38.58,20.98 38.58,22.94 38.83,23.2 42.9,23.2
GND on TOP (solid shape): 27.86,31.32 27.86,30.44 27.78,30.36 26.24,30.36 26.03,30.44 25.82,30.36 25.61,30.36 25.35,30.43 25.12,30.29 25.11,30.27 25.07,30.1 25.12,29.93 25.12,27.79 24.99,27.67 24.2,27.67 24.13,27.74 24.13,30.99 24.61,31.48 27.71,31.48
GND on TOP (solid shape): 22.13,26.94 22.13,24.72 22.07,24.66 21.43,24.66 21.24,24.47 21.24,23.01 20.99,22.75 20.04,22.75 20.04,22.94 19.85,23.13 19.84,23.14 19.67,23.23 19.48,23.16 18.08,23.16 17.94,23.3 17.94,23.51 18.14,23.72 18.15,23.72 18.58,24.14 18.58,24.15 18.77,24.34 19.78,24.34 19.78,25.8 20.1,26.12 20.1,26.46 20.36,26.72 20.37,26.72 20.5,26.79 20.57,26.92 20.58,26.94 20.64,27.01 22.07,27.01
GND on TOP (solid shape): outline of 203 points within 105.39,4.57 110.39,9.57
GND on TOP (solid shape): outline of 203 points within 105.39,15.57 110.39,20.57
GND on TOP (solid shape): outline of 267 points within 33,74.95 43.85,87.26
GND on TOP (solid shape): outline of 274 points within 0.86,84.95 12.81,96.28
GND on TOP (solid shape): outline of 274 points within 65.64,34.78 98.9,46.14
GND on TOP (solid shape): outline of 370 points within 0.2,53.99 36.84,84.66
GND on TOP (solid shape): outline of 2237 points within 0.86,0.2 172.54,112.9
GND on BOTTOM (solid shape): 11.85,101.21 11.85,100.42 11.78,100.36 10.81,100.36 10.75,100.42 10.75,101.13 10.89,101.28 11.78,101.28
GND on BOTTOM (solid shape): 11.85,97.05 11.85,96.26 11.78,96.19 10.81,96.19 10.75,96.26 10.75,96.97 10.89,97.12 11.78,97.12
GND on BOTTOM (solid shape): 11.85,85.17 11.85,84.39 11.78,84.32 10.82,84.32 10.75,84.38 10.75,85.1 10.9,85.24 11.79,85.24
GND on BOTTOM (solid shape): 27.96,91.62 27.96,88.37 27.94,88.35 27.3,88.35 27.25,88.4 27.25,91.62 27.3,91.67 27.91,91.67
GND on BOTTOM (solid shape): 88.62,104.41 88.62,103.71 88.55,103.65 86.39,103.65 86.33,103.71 86.33,104.41 86.39,104.48 88.55,104.48
GND on BOTTOM (solid shape): 160.25,10.75 160.25,10.12 160.18,10.05 154.21,10.05 154.15,10.12 154.15,10.75 154.21,10.81 160.18,10.81
GND on BOTTOM (solid shape): 162.21,16.21 162.21,12.85 162.08,12.72 161.52,12.72 161.45,12.78 161.45,16.21 161.52,16.27 162.15,16.27
GND on BOTTOM (solid shape): 17.5,32.72 17.5,32.21 17.24,31.96 13.75,31.96 13.74,31.97 13.74,32.89 13.82,32.98 17.24,32.98
GND on BOTTOM (solid shape): 127.48,51.81 127.48,48.91 127.03,48.47 124.86,48.47 124.24,49.08 124.24,51.98 124.28,52.02 127.27,52.02
GND on BOTTOM (solid shape): 11.86,80.62 11.86,79.83 11.79,79.76 10.82,79.76 10.76,79.83 10.76,80.58 10.89,80.72 11.76,80.72
GND on BOTTOM (solid shape): 60.98,60.11 60.98,55.63 60.67,55.32 58.9,55.32 56.23,57.99 56.23,60.03 56.36,60.15 57.38,60.15 57.76,60.53 60.55,60.53
GND on BOTTOM (solid shape): 64.87,69.81 64.87,62.06 64.61,61.8 63.09,61.8 62.84,62.06 62.84,69.81 63.22,70.19 64.49,70.19
GND on BOTTOM (solid shape): 135.86,18.31 135.86,13.35 135.54,13.04 134.27,13.04 133.45,12.21 132.81,12.21 132.43,12.59 132.43,18.12 132.94,18.62 135.54,18.62
GND on BOTTOM (solid shape): 144.56,7.26 144.56,5.16 144.55,5.16 144.55,4.84 144.44,4.73 143.79,4.73 143.63,4.89 143.63,7.16 143.86,7.38 144.43,7.38
GND on BOTTOM (solid shape): 145.39,71.55 145.39,68.93 145.27,68.82 143.54,68.82 143.3,69.06 143.3,71.5 143.45,71.64 145.3,71.64
GND on BOTTOM (solid shape): 130.53,27.07 130.53,25.55 130.34,25.36 127.67,25.36 127.54,25.48 127.54,26.64 127.77,26.86 128.99,26.86 129.45,27.32 130.27,27.32
GND on BOTTOM (solid shape): 59.1,80.55 59.99,80.55 59.99,80.04 58.92,80.04 58.65,80.32 58.65,80.35 58.62,80.37 57.73,80.37 57.68,80.42 57.68,80.6 57.76,80.68 58.98,80.68
GND on BOTTOM (solid shape): 89,98.7 89.64,98.7 89.75,98.6 89.75,98.18 89.57,98 86.12,98 86.02,98.1 86.02,98.44 86.01,98.44 86.01,99.4 86.14,99.52 88.17,99.52
GND on BOTTOM (solid shape): 122.97,19.89 122.97,18.45 122.23,17.7 122.23,15.18 121.92,14.87 118.09,14.87 116.49,16.47 116.49,19.45 117.19,20.15 122.72,20.15
GND on BOTTOM (solid shape): 140.24,27.9 140.24,25.1 138.97,23.83 137.94,23.83 137.51,24.26 137.51,27.96 137.64,28.09 140.05,28.09
GND on BOTTOM (solid shape): 26.45,57.3 26.45,57.07 26.55,56.97 26.55,56.09 26.48,56.02 26.3,56.02 26.18,56.14 26.18,56.52 26.08,56.62 25.86,56.62 25.65,56.83 25.65,57.21 25.88,57.44 26.31,57.44
GND on BOTTOM (solid shape): 115.14,28.42 115.14,27.48 114.98,27.32 114.67,27.32 114.61,27.26 113.77,27.26 113.76,27.26 109.57,27.26 109.38,27.45 109.38,28.53 109.45,28.59 114.97,28.59
GND on BOTTOM (solid shape): 137.7,23.07 137.7,21.86 137.51,21.67 136.69,21.67 135.67,20.66 134.46,20.66 134.34,20.78 134.34,21.55 133.96,21.93 133.07,21.93 133,21.99 133,23.01 133.19,23.2 137.58,23.2
GND on BOTTOM (solid shape): 33.37,86.38 33.37,85.74 33.31,85.68 33.18,85.68 33.12,85.74 33.12,86 32.99,86.12 31.87,86.12 31.33,86.67 29.82,86.67 29.77,86.72 29.77,87.36 29.97,87.56 32.19,87.56
GND on BOTTOM (solid shape): 49.98,71.91 25.77,71.91 25.77,76.24 17.35,76.24 17.35,77.04 26.57,77.04 26.57,72.71 49.18,72.71 49.18,92.29 26.57,92.29 26.57,89.39 17.35,89.39 17.35,90.19 25.77,90.19 25.77,93.09 49.98,93.09
GND on BOTTOM (solid shape): 9.88,23.32 9.88,22.94 10,22.82 10.26,22.82 10.39,22.69 10.39,20.53 9.75,19.89 9.75,19.26 9.44,18.95 7.77,18.95 7.59,19.13 7.59,22.05 7.72,22.18 8.99,22.18 9.24,22.43 9.24,23.45 9.75,23.45
GND on BOTTOM (solid shape): 152.31,70.25 152.31,66.63 152.18,66.5 151.02,66.5 150.03,65.51 148.76,65.51 148.69,65.59 148.69,67.65 148.66,67.67 146.55,67.67 146.07,68.15 146.07,70.26 146.29,70.48 152.07,70.48
GND on BOTTOM (solid shape): 64.03,103.6 64.03,103.07 62.84,101.87 62.84,100.79 62.71,100.67 61.19,100.67 60.99,100.86 60.99,101.3 60.93,101.36 59.22,101.36 59.03,101.56 59.03,103.27 59.15,103.4 62.35,103.4 62.37,103.4 63.08,104.11 63.53,104.11
GND on BOTTOM (solid shape): 148.18,11.96 148.18,9.67 147.94,9.43 147.94,8.16 147.74,7.96 145.58,7.96 145.13,8.4 142.15,8.4 141.96,8.59 141.96,9.54 142.08,9.67 143.35,9.67 143.54,9.86 143.54,11.96 143.93,12.34 147.8,12.34
GND on BOTTOM (solid shape): 12.78,23.45 12.78,23.42 12.81,23.42 13.12,23.12 13.45,23.12 13.47,23.09 13.47,22.64 12.87,22.64 12.8,22.71 12.8,22.89 12.52,23.17 12.08,23.17 12.03,23.18 11.39,23.18 11.29,23.28 11.29,23.55 12.68,23.55
GND on BOTTOM (solid shape): 19.91,33.81 19.91,33.23 20.24,32.9 20.24,31.83 20.39,31.68 21.76,31.68 22.02,31.93 23.39,31.93 23.47,31.86 23.47,30.51 23.42,30.46 22.3,30.46 22.02,30.74 19.76,30.74 19.61,30.89 19.61,31.53 19.17,31.96 19.17,33.86 19.22,33.91 19.81,33.91
GND on BOTTOM (solid shape): 67.64,80.24 67.64,78.59 67.73,78.5 67.73,78.49 68.11,78.11 68.12,78.11 68.42,77.81 68.42,77.3 68.93,76.79 68.93,76.16 68.81,76.03 67.66,76.03 67.41,76.28 67.41,77.81 67.03,78.19 65.25,78.19 65.12,78.31 65.12,79.2 66.27,80.35 67.54,80.35
GND on BOTTOM (solid shape): 56.74,92.67 56.74,91.78 56.36,91.4 54.33,91.4 54.07,91.14 54.07,90.63 53.82,90.38 53.31,90.38 53.18,90.51 53.18,91.01 52.93,91.27 52.17,91.27 52.05,91.15 52.04,91.15 52.04,90.06 52.04,90.06 52.04,88.98 51.79,88.73 50.9,88.73 50.64,88.98 50.64,91.78 51.79,92.92 56.49,92.92
GND on BOTTOM (solid shape): 127.29,24.03 127.29,23.58 127.44,23.43 129.15,23.43 129.32,23.26 129.32,21.55 129,21.23 128.24,21.23 128.03,21.44 126.72,21.44 126.53,21.63 126.53,22.78 126.34,22.97 125.44,22.97 125.24,23.17 125.24,23.53 125.3,23.6 125.85,23.6 125.99,23.74 125.99,24 126.12,24.13 127.19,24.13
GND on BOTTOM (solid shape): 56.21,80.47 56.21,80.12 56.44,79.89 56.79,79.89 56.82,79.86 56.82,78.8 56.23,78.21 56.23,77.7 55.93,77.4 55.9,77.4 55.88,77.37 55.6,77.37 55.6,74.94 55.61,74.92 55.58,74.86 53.51,74.86 53.08,75.29 53.08,78.7 53.62,79.23 55.57,79.23 55.62,79.28 55.62,80.3 55.88,80.55 56.13,80.55
GND on BOTTOM (solid shape): 134.46,40.96 134.46,39.22 133.96,38.71 133.96,34.4 133.47,33.91 131.84,33.91 131.69,33.77 131.69,32.67 131.67,32.65 131.02,32.65 130.91,32.76 130.91,33.64 130.81,33.74 130.32,33.74 130.12,33.94 130.12,34.75 129.99,34.88 129.99,36.68 130.07,36.76 131.5,36.76 131.76,37.02 131.76,39.43 133.43,41.1 134.33,41.1
GND on BOTTOM (solid shape): 126.59,39.33 126.59,35.03 126.72,34.91 126.72,32.72 126.51,32.52 125.1,32.52 124.23,31.65 123.18,31.65 123.06,31.77 123.06,33.27 122.81,33.53 122.81,35.34 122.88,35.41 124.38,35.41 124.39,35.43 124.52,35.43 124.61,35.52 124.61,37.34 124.96,37.7 124.96,38.49 125.51,39.04 125.51,39.34 125.6,39.43 126.49,39.43
GND on BOTTOM (solid shape): 119.47,39.82 119.47,37.75 119.35,37.63 119.35,35.52 119.48,35.39 119.48,33.2 119.27,33 118.17,33 117.08,31.91 115.91,31.91 115.8,32.03 115.8,33.7 115.57,33.93 115.57,35.82 115.69,35.95 117.2,35.95 117.33,36.08 117.33,37.86 117.83,38.36 117.83,39.81 117.95,39.93 119.36,39.93
GND on BOTTOM (solid shape): 151.01,60.09 151.01,58.08 151.51,57.59 151.51,56.93 150.49,56.93 150.09,56.52 150.09,56.27 149.57,55.76 148.38,55.76 148.26,55.89 148.26,57.79 148.13,57.92 145.36,57.92 145.03,58.25 145.03,60.38 145.23,60.58 145.26,60.58 145.72,61.04 147.93,61.04 148.05,60.92 148.69,60.92 148.82,61.04 148.86,61.08 150.02,61.08
GND on BOTTOM (solid shape): 79.09,94.95 79.09,94.19 79.6,93.68 79.6,92.67 79.47,92.54 79.47,92.33 79.27,92.33 79.27,91.32 79.22,91.27 77.61,91.27 77.61,91.32 77.43,91.51 77.31,91.57 77.19,91.56 77.16,91.55 77.06,91.65 77.06,92.65 77.21,92.8 77.21,92.82 77.7,93.3 78.39,93.3 78.52,93.43 78.52,95.08 78.58,95.14 78.9,95.14
GND on BOTTOM (solid shape): 112.01,39.5 112.01,34.32 111.22,33.53 110.49,33.53 110.41,33.45 110.41,32.98 110.32,32.9 109.45,32.9 109.32,33.03 109.32,34.6 108.72,35.2 108.72,36.72 108.86,36.86 110.38,36.86 110.51,36.99 110.51,38.72 110.82,39.02 110.82,39.58 110.97,39.73 110.97,40.07 111.1,40.2 111.31,40.2
GND on BOTTOM (solid shape): 150.43,94.43 150.43,93.45 150.14,93.16 149.96,93.16 149.75,93.16 149.6,93.01 149.44,92.85 149.13,92.85 148.96,92.68 148.96,91.13 149.35,90.74 149.35,89.47 148.99,89.11 148.99,87.74 148.9,87.65 148.74,87.65 148.62,87.77 148.62,89.29 148.21,89.7 148.21,92.5 147.87,92.84 147.87,94.45 148.02,94.6 150.26,94.6
GND on BOTTOM (solid shape): 85.16,41.68 85.16,39.87 85.44,39.59 85.85,39.59 85.99,39.46 85.99,38.28 86.24,38.03 89.92,38.03 89.92,36.88 89.07,36.88 89.07,36.28 89.15,36.19 90.88,36.19 90.97,36.1 90.97,35.95 90.9,35.87 90.15,35.87 89.93,35.65 89.93,34.53 89.93,34.53 88.94,34.53 88.57,34.16 88.57,33.55 88.48,33.47 88.33,33.47 88.26,33.53 88.26,34.34 88.51,34.58 88.51,35.71 88.21,36.01 85.3,36.01 85.16,35.86 83.09,35.86 82.36,36.59 82.36,40.08 83.97,41.69 85.16,41.69
GND on BOTTOM (solid shape): 69.06,42.34 69.06,39.73 68.64,39.31 68.64,38.31 68.91,38.04 72.6,38.04 72.61,38.04 72.61,36.89 71.76,36.89 71.76,36.89 71.76,36.24 71.8,36.2 73.58,36.2 73.66,36.11 73.66,35.98 73.57,35.89 72.85,35.89 72.62,35.66 72.62,34.55 72.62,34.55 71.63,34.55 71.26,34.17 71.26,33.56 71.18,33.48 71.04,33.48 70.95,33.56 70.95,34.23 71.2,34.48 71.2,35.74 70.91,36.02 66.94,36.02 66.83,36.13 66.83,36.41 66.58,36.66 65.78,36.66 65.63,36.81 65.63,40.81 67.34,42.51 68.89,42.51
GND on BOTTOM (solid shape): 77.16,41.08 77.16,38.34 77.45,38.05 81.17,38.05 81.17,36.9 80.32,36.9 80.32,36.28 80.39,36.2 82.16,36.2 82.22,36.14 82.22,35.99 82.14,35.9 81.4,35.9 81.18,35.68 81.18,34.56 80.15,34.56 79.82,34.23 79.82,33.57 79.74,33.49 79.57,33.49 79.51,33.55 79.51,34.34 79.76,34.59 79.76,35.52 79.24,36.03 76.45,36.03 76.35,35.93 74.41,35.93 74.04,36.3 74.04,39.46 74.05,39.47 74.05,39.87 74.06,39.96 74.05,40.05 74.05,40.82 74.47,41.24 77,41.24
GND on BOTTOM (solid shape): 12.04,55.96 12.04,55.71 11.78,55.45 11.78,54.82 11.66,54.69 11.4,54.69 11.21,54.5 11.03,54.5 11.03,53.74 11.15,53.74 11.15,52.89 10.65,52.39 10.59,52.39 10.55,52.38 10.41,52.38 10.32,52.29 10.32,51.45 11.03,50.74 11.03,49.56 10.94,49.47 10.56,49.47 10.32,49.23 10.32,48.23 10.66,47.88 10.66,47.82 10.52,47.68 10.46,47.68 10.03,48.11 10.03,49.15 9.83,49.36 9.57,49.36 9.37,49.56 9.37,50.98 9.6,51.22 9.6,53 9.49,53.11 9.34,53.11 9.29,53.16 9.29,55.51 9.75,55.96 11.15,55.96 11.4,56.22 11.78,56.22
GND on BOTTOM (solid shape): 21.89,41.37 22.02,41.37 22.07,41.37 22.12,41.37 22.7,41.37 22.7,41.1 22.58,40.98 21.75,40.98 21.75,41.07 19.59,41.07 19.59,40.79 19.53,40.72 19.53,37.29 19.59,37.23 19.6,37.23 19.66,37.17 22.58,37.17 22.58,36.66 21.94,36.66 21.69,36.91 20,36.91 19.87,36.98 19.73,37 19.44,37 19.28,37.17 19.28,41.04 19.3,41.05 19.39,41.12 19.43,41.22 19.43,41.23 20.21,41.23 20.47,41.23 20.47,41.2 21.64,41.2 21.64,41.23 21.69,41.23 21.86,41.4
GND on BOTTOM (solid shape): 93.89,41 93.89,39.98 94.14,39.73 94.57,39.73 94.69,39.6 94.69,38.4 95.05,38.04 98.77,38.04 98.77,36.89 97.92,36.89 97.92,36.27 98,36.19 99.74,36.19 99.83,36.11 99.83,35.98 99.74,35.89 99.02,35.89 98.78,35.65 98.78,34.55 97.78,34.55 97.42,34.19 97.42,33.57 97.34,33.48 97.2,33.48 97.12,33.56 97.12,34.31 97.36,34.56 97.36,35.81 97.15,36.02 93.9,36.02 93.75,35.87 93.12,35.87 92.84,36.15 91.55,36.15 91.25,36.44 91.25,38.54 90.96,38.83 90.96,40.45 90.97,40.46 90.97,41.24 91.28,41.55 93.34,41.55
GND on BOTTOM (solid shape): 33.64,56.28 33.64,56.2 33.67,56.09 33.75,56.02 33.78,56.01 33.78,55.9 33.77,55.85 33.77,55.68 33.78,55.64 33.79,55.6 33.22,55.31 33.2,55.32 33.06,55.35 32.91,55.32 32.87,55.3 32.79,55.46 32.72,55.48 32.74,55.55 32.76,55.56 32.83,55.63 32.86,55.73 32.86,55.77 33.03,55.94 33.03,56.04 33.05,56.07 33.05,56.3 33.11,56.36 33.11,56.43 33.18,56.43 33.27,56.43 33.39,56.53
GND on BOTTOM (solid shape): 27.12,36.06 27.12,35.9 27.32,35.7 27.9,35.7 27.97,35.63 27.97,35.34 27.69,35.07 27.18,35.07 27.11,34.99 26.7,34.99 26.33,34.63 25.63,34.63 25.51,34.74 25.5,34.78 25.5,35.01 25.73,35.24 26.3,35.24 26.37,35.31 26.44,35.36 26.5,35.44 26.52,35.55 26.5,35.65 26.44,35.73 26.35,35.8 26.24,35.81 26.18,35.83 26.16,35.89 26.15,36.02 26.34,36.21 26.98,36.21
GND on BOTTOM (solid shape): 27.5,45.71 27.53,45.67 27.53,45.64 27.57,45.56 27.63,45.5 27.75,45.32 27.73,45.26 27.72,45.21 27.72,45.17 27.59,45.17 27.25,44.82 27.12,44.94 27.04,44.94 27,44.98 26.67,44.98 26.62,45.03 26.63,45.06 26.64,45.18 26.58,45.28 26.55,45.33 26.58,45.39 26.75,45.56 26.87,45.56 26.98,45.59 27.05,45.67 27.06,45.71 27.17,45.71 27.22,45.69 27.36,45.69 27.41,45.69 27.45,45.71
GND on BOTTOM (solid shape): outline of 174 points within 45.03,26.84 49.82,38.32
GND on BOTTOM (solid shape): outline of 251 points within 0.2,53.76 16.96,80.02
GND on BOTTOM (solid shape): outline of 291 points within 0.86,84.98 12.55,96.23
GND on BOTTOM (solid shape): outline of 1761 points within 0.86,0.2 172.54,112.9
GND on BOTTOM (solid shape): outline of 3006 points within 27.03,73.12 43.09,86.52
GND on IN1 (solid shape): 12.1,87.01 12.1,84.35 11.97,84.22 10.7,84.22 10.51,84.41 10.51,87.01 10.89,87.39 11.72,87.39
GND on IN1 (solid shape): 12.1,80.03 12.1,78 11.72,77.62 11.02,77.62 10.51,78.12 10.51,80.03 10.64,80.16 11.97,80.16
GND on IN1 (solid shape): 12.54,102.38 12.54,100.48 12.42,100.35 10.7,100.35 10.45,100.6 10.45,102.89 10.96,103.4 11.53,103.4
GND on IN1 (solid shape): 12,97.21 11.98,96.94 12.16,96.74 12.16,94.51 11.85,94.19 10.83,94.19 10.45,94.57 10.45,96.98 10.7,97.24 11.97,97.24
GND on IN1 (solid shape): 7.95,94.47 8.17,94.4 8.4,94.41 8.58,94.34 9.04,93.88 9.04,87.33 8.45,86.75 8.41,86.75 8.25,86.77 8.09,86.75 6.45,86.75 6.45,86.99 5.85,87.69 5.08,87.19 1.16,87.19 0.95,87.28 0.86,87.49 0.86,88.16 0.93,88.34 1.76,88.87 2.01,89.62 2.01,91.62 1.76,92.37 0.93,92.9 0.86,93.08 0.86,93.74 0.95,93.95 1.16,94.04 5.08,94.04 5.85,93.54 6.45,94.24 6.45,94.47
GND on IN1 (solid shape): 7.94,78.27 8.25,78.2 8.56,78.27 8.9,78.27 9.81,77.36 9.81,73.74 8.42,72.35 7.46,72.35 4.43,69.31 2.71,69.31 2,68.6 2,55.63 2.62,55.01 2.62,54.07 2.31,53.76 1.97,53.76 0.95,54.78 0.89,54.87 0.86,56.59 0.74,56.99 0.26,57.36 0.2,57.53 0.2,71.25 0.26,71.42 0.74,71.79 0.86,72.19 0.86,72.61 0.9,72.75 0.99,72.85 1.07,72.89 1.16,72.91 3.56,72.91 4.34,73.23 4.66,74.01 4.66,74.51 4.34,75.29 3.56,75.61 1.85,75.61 1.64,75.7 1.55,75.91 1.55,77.54 1.64,77.75 1.85,77.84 5.08,77.84 5.38,77.44 5.88,77.35 6.29,77.59 6.45,78.04 6.45,78.27
GND on IN1 (solid shape): outline of 247 points within 0.86,0.2 172.54,112.9
GND on IN2 (solid shape): 106.29,30.74 106.99,30.74 109.21,28.51 109.71,28.02 113.55,28.02 114.04,28.51 114.11,28.51 114.12,28.51 115.08,28.51 115.21,28.38 115.21,26.99 114.89,26.67 110.41,26.67 108.75,28.33 108.7,28.33 107.24,29.78 105.73,29.78 105.69,29.8 105.63,29.82 105.55,29.84 105.48,29.85 105.44,29.85 100.41,29.85 100.27,29.99 100.27,30.52 104.38,30.52 104.38,30.47 104.39,30.43 104.41,30.38 104.43,30.34 104.46,30.3 104.5,30.27 104.54,30.24 104.59,30.22 104.63,30.21 104.68,30.21 104.73,30.21 104.78,30.22 104.82,30.24 104.87,30.27 104.9,30.3 104.93,30.34 104.96,30.38 104.98,30.43 104.99,30.47 104.99,30.52 104.98,30.57 104.97,30.62 104.95,30.66 104.92,30.7 104.89,30.74 104.85,30.77 104.8,30.79 104.76,30.81 104.71,30.82 104.66,30.82 104.61,30.81 104.56,30.79 104.52,30.77 104.48,30.74 104.45,30.7 104.42,30.66 104.4,30.62 104.38,30.57 104.38,30.52 100.27,30.52 100.27,30.87 100.63,31.23 105.8,31.23
GND on IN2 (solid shape): 7.95,94.47 8.18,94.4 8.41,94.42 8.59,94.33 9.04,93.88 9.04,87.33 8.45,86.75 8.41,86.75 8.25,86.77 8.09,86.75 6.45,86.75 6.45,86.99 5.85,87.69 5.08,87.19 1.16,87.19 0.95,87.28 0.86,87.49 0.86,88.16 0.93,88.34 1.76,88.87 2.01,89.62 2.01,91.62 1.76,92.37 0.93,92.9 0.86,93.08 0.86,93.74 0.95,93.95 1.16,94.04 5.08,94.04 5.85,93.54 6.45,94.24 6.45,94.47
GND on IN2 (solid shape): 7.94,78.27 8.22,78.2 8.51,78.25 8.95,78.25 9.37,77.83 9.37,75.01 9.59,74.79 9.59,73.52 8.42,72.35 7.46,72.35 1.32,66.2 1.32,55.05 2.62,53.76 1.97,53.76 0.95,54.78 0.89,54.87 0.86,56.59 0.74,56.99 0.26,57.36 0.2,57.53 0.2,71.25 0.26,71.42 0.74,71.79 0.86,72.19 0.86,72.61 0.9,72.75 0.99,72.85 1.07,72.89 1.16,72.91 3.56,72.91 4.34,73.23 4.66,74.01 4.66,74.51 4.34,75.29 3.56,75.61 1.85,75.61 1.64,75.7 1.55,75.91 1.55,77.54 1.64,77.75 1.85,77.84 5.08,77.84 5.31,77.49 5.69,77.34 6.23,77.52 6.45,78.04 6.45,78.27
GND on IN2 (solid shape): outline of 250 points within 0.86,0.2 172.54,112.9
GND on VCC (solid shape): 0.66,57.64 1.14,57.21 1.32,56.59 1.32,55.05 2.63,53.74 2.68,53.69 2.73,53.63 2.87,53.38 2.96,53.11 2.81,53 2.7,52.87 2.59,52.82 2.51,52.92 2.51,52.92 2.46,53.19 2.31,53.42 0.95,54.78 0.89,54.87 0.86,54.99 0.86,56.59 0.74,56.99 0.26,57.36 0.2,57.53 0.2,70.6 0.66,70.6
GND on VCC (solid shape): outline of 272 points within 0.86,0.2 172.54,112.9
GND on IN3 (solid shape): 12.1,87.08 12.1,84.47 11.97,84.35 10.77,84.35 10.45,84.66 10.45,87.01 10.83,87.39 11.78,87.39
GND on IN3 (solid shape): 12.16,96.54 12.16,94.7 11.66,94.19 11.02,94.19 10.58,94.63 10.58,96.41 10.64,96.48 11.15,96.48 11.27,96.59 12.03,96.59 12.03,96.6 12.1,96.6
GND on IN3 (solid shape): 11.65,102.83 12.04,102.83 12.16,102.7 12.16,100.98 11.97,100.79 11.59,100.79 11.46,100.92 10.64,100.92 10.51,101.05 10.51,102.57 10.45,102.63 10.45,102.89 10.58,103.02 11.46,103.02
GND on IN3 (solid shape): 12.16,80.6 12.16,80.55 12.15,80.53 12.05,80.28 12.16,80.04 12.16,78.19 11.59,77.62 11.15,77.62 10.51,78.25 10.51,80.73 10.64,80.85 11.91,80.85
GND on IN3 (solid shape): 7.95,94.47 8.17,94.4 8.4,94.41 8.6,94.32 9.04,93.88 9.04,87.33 8.45,86.75 8.41,86.75 8.25,86.77 8.09,86.75 6.45,86.75 6.45,86.99 5.85,87.69 5.08,87.19 1.16,87.19 0.95,87.28 0.86,87.49 0.86,88.16 0.93,88.34 1.76,88.87 2.01,89.62 2.01,91.62 1.76,92.37 0.93,92.9 0.86,93.08 0.86,93.74 0.95,93.95 1.16,94.04 5.08,94.04 5.85,93.54 6.45,94.24 6.45,94.47
GND on IN3 (solid shape): 7.93,78.28 8.17,78.2 8.43,78.22 8.86,77.79 8.86,76.41 9.37,75.9 9.37,75.04 9.59,74.82 9.59,73.52 8.42,72.35 7.46,72.35 1.32,66.2 1.32,55.05 2.62,53.76 1.97,53.76 0.95,54.78 0.89,54.87 0.86,56.59 0.74,56.99 0.26,57.36 0.2,57.53 0.2,71.25 0.26,71.42 0.74,71.79 0.86,72.19 0.86,72.61 0.9,72.75 0.99,72.85 1.07,72.89 1.16,72.91 3.56,72.91 4.34,73.23 4.66,74.01 4.66,74.51 4.34,75.29 3.56,75.61 1.85,75.61 1.64,75.7 1.55,75.91 1.55,77.54 1.64,77.75 1.85,77.84 5.08,77.84 5.25,77.54 5.54,77.37 6.17,77.47 6.45,78.04 6.45,78.25 6.48,78.28
GND on IN3 (solid shape): outline of 245 points within 0.86,0.2 172.54,112.9
GND on GND1: outline of 204 points within 0.2,0.2 172.54,112.9
GND on GND2: outline of 208 points within 0.2,0.2 172.54,112.9
GND on VCC: 121.76,79.46 121.76,88.09 137.03,88.09 140.94,84.18 140.94,79.94 140.45,79.46
GND on VCC: 70.18,49.99 69.69,50.48 69.69,54.59 70.18,55.07 71.62,55.07 72.11,54.59 72.11,50.23 71.87,49.99
GND on VCC: outline of 99 points within 0.2,70.31 22.7,110.83
