# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PD_USB20_N1: length 3.9
  BOTTOM w0.145: UPD1.A7 33.59,65.43 33.59,64.94 33.25,64.61 31.66,64.61 31.37,64.32 31.37,64.22 RP133.1 RP131.1
PD_USB20_N1_B: length 35.6
  TOP w0.145: LT4.1 14.07,81.75 v9(13.84,81.52)
  IN3 w0.086: v3(30.68,66.53) 30.68,66.52 30.91,66.29 30.91,65.69 30.55,65.33 30,65.33 28.5,66.83 26.89,66.83 26.38,67.34 17.8,67.34 17.11,68.03 17.11,68.43 17.44,68.77 17.44,68.91 17.34,69.01 17.2,69.01 16.86,68.68 16.46,68.68 16.17,68.97 16.17,70.08 15.8,70.45 15.66,70.45 15.37,70.17 14.97,70.17 14.4,70.75 14.4,75.01 14.67,75.28 14.93,75.28 15.03,75.38 15.03,75.9 14.93,76 14.7,76 14.4,76.31 14.4,78.87 14.68,79.15 14.98,79.15 15.08,79.26 15.08,79.4 14.98,79.5 14.68,79.5 14.4,79.78 14.4,80.35 13.87,80.87 13.87,81.49 v9(13.84,81.52)
PD_USB20_N1_B_R: length 7
  TOP w0.145: JUSBC1.A7 10.04,82.27 10.31,82.54 10.34,82.58 10.86,82.58 DT16.1 11.77,82.58 v10(12.8,82.58) 13.17,82.58 13.55,82.96 13.55,83.31 13.8,83.56 14.05,83.56 14.2,83.41 14.2,83.06 LT4.2
PD_USB20_N1_T: length 37
  IN3 w0.086: v6(15.29,82.84) 15.18,82.72 14.97,82.72 14.7,82.45 14.7,81.95 15.89,80.76 15.89,80.19 16.17,79.9 16.81,79.9 16.91,79.8 16.91,79.66 16.81,79.56 16.17,79.56 15.89,79.28 15.89,78.88 16.17,78.59 17.45,78.59 17.55,78.49 17.55,78.35 17.45,78.25 16.17,78.25 15.82,77.89 15.82,73.75 16.72,72.85 16.72,70.65 19.32,68.05 26.69,68.05 27.09,67.65 27.65,67.65 27.69,67.61 v3(27.79,67.61)
  BOTTOM w0.145: UPD1.A2 31.14,65.49 31.14,65.16 30.78,64.8 30.15,64.8 29.69,65.27 29.69,66.2 v10(28.81,67.08) 28.25,67.64 27.82,67.64 v3(27.79,67.61) ; LT11.1 14.28,82.72 15.18,82.72 v6(15.29,82.84)
PD_USB20_N1_T_R: length 6.2
  BOTTOM w0.145: LT11.2 13.49,82.72 12.83,82.72 12.77,82.66 11.54,82.66 DT19.1 11.09,82.67 7.95,82.67 JUSBC1.B7
PD_USB20_N2: length 6.2
  IN3 w0.086: v3(36.89,64.13) 36.76,64.26 36.76,64.92 36.79,64.95 36.79,65.56 36.38,65.97 36.38,66.92 36.67,67.21 36.67,68.25 36.39,68.53 v3(35.68,68.53)
  BOTTOM w0.145: v3(36.89,64.13) RP127.2
PD_USB20_N2_B: length 40.5
  TOP w0.145: v9(14.37,95.71) 14.2,95.89 13.91,95.89 13.42,96.38 13.42,97.28 LT8.1
  IN3 w0.086: v9(14.37,95.71) 14.63,95.71 14.7,95.79 14.7,95.97 14.52,96.14 14.15,96.14 14,96 14,92.52 15.6,90.93 15.6,87.51 19.07,84.04 19.07,81.19 20.62,79.63 20.62,73.94 21.17,73.39 25.12,73.39 25.95,72.56 25.95,72.23 26.26,71.91 29.3,71.91 30.12,71.09 30.12,70.65 30.43,70.34 30.6,70.34 30.68,70.42 v3(30.68,70.53)
PD_USB20_N2_B_R: length 5.9
  TOP w0.145: JUSBC2.A7 9.79,98.47 9.88,98.56 11.16,98.56 DT54.1 11.66,98.76 v10(13.04,98.76) 13.3,98.76 13.47,98.59 13.47,98.37 13.39,98.29 13.27,98.29 13.14,98.16 13.14,98.03 13.25,97.92 LT8.2
PD_USB20_N2_T: length 40.8
  IN3 w0.086: v6(13.87,97.25) 13.77,97.25 13.68,97.16 13.68,96.78 13.3,96.39 13.3,91.98 14.77,90.51 14.77,87.09 18.08,83.78 18.08,81.11 19.58,79.61 19.58,73.81 20.7,72.68 24.77,72.68 25.21,72.24 25.21,71.96 25.96,71.21 28.96,71.21 29.41,70.76 29.41,70.31 29.9,69.82 29.9,69.02 30.14,68.78 30.34,68.78 30.38,68.82 30.38,68.9 30.3,68.98 30.3,69.02 30.39,69.11 30.6,69.11 v3(30.68,69.03)
PD_USB20_N2_T_R: length 7.3
  BOTTOM w0.145: JUSBC2.B7 7.91,98.91 11.15,98.91 DT57.1 13.37,99.07 13.83,98.62 13.83,97.89 LT10.2
PD_USB20_P1: length 3.9
  BOTTOM w0.145: UPD1.A6 33.28,65.43 33.28,65.07 33.12,64.92 31.53,64.92 31.06,64.45 31.06,64.29 RP132.1 RP130.1
PD_USB20_P1_B: length 35.5
  TOP w0.145: LT4.4 14.57,82.25 14.38,82.06 14.38,81.62 v9(14.48,81.52)
  IN3 w0.086: v3(30.3,66.57) 30.3,66.46 30.6,66.16 30.6,65.82 30.42,65.64 30.13,65.64 28.63,67.14 27.02,67.14 26.51,67.65 17.93,67.65 17.42,68.16 17.42,68.31 17.75,68.64 17.75,69.04 17.47,69.32 17.07,69.32 16.74,68.99 16.59,68.99 16.48,69.1 16.48,70.21 15.93,70.76 15.53,70.76 15.25,70.48 15.1,70.48 14.71,70.88 14.71,74.88 14.8,74.97 15.06,74.97 15.34,75.26 15.34,76.03 15.06,76.31 14.83,76.31 14.71,76.44 14.71,78.74 14.81,78.84 15.11,78.84 15.39,79.13 15.39,79.53 15.11,79.81 14.81,79.81 14.71,79.91 14.71,80.48 14.18,81 14.18,81.3 14.4,81.52 v9(14.48,81.52)
  BOTTOM w0.076: v3(30.3,66.57) 30.3,66.5 30.68,66.12 UPD1.B1
PD_USB20_P1_B_R: length 7
  TOP w0.145: JUSBC1.A6 10.08,82.77 10.2,82.89 DT20.1 13.04,82.89 13.24,83.09 13.24,83.44 13.67,83.87 v10(13.94,83.87) 14.18,83.87 14.51,83.54 14.51,82.99 LT4.3
PD_USB20_P1_T: length 37
  IN3 w0.086: v6(15.29,82.31) 15.19,82.41 15.1,82.41 15.01,82.32 15.01,82.08 16.2,80.89 16.2,80.32 16.3,80.21 16.94,80.21 17.22,79.93 17.22,79.53 16.94,79.25 16.3,79.25 16.2,79.15 16.2,79 16.3,78.9 17.58,78.9 17.86,78.62 17.86,78.22 17.58,77.94 16.3,77.94 16.13,77.76 16.13,73.88 17.03,72.97 17.03,70.78 19.45,68.36 26.82,68.36 27.22,67.96 27.34,67.96 27.45,68.08 27.45,68.74 27.53,68.81 27.68,68.81 27.79,68.71 v3(27.79,67.99)
  BOTTOM w0.145: UPD1.A1 30.83,65.37 30.83,65.29 30.65,65.11 30.28,65.11 30,65.4 30,66.33 28.37,67.95 27.82,67.95 v3(27.79,67.99) ; LT11.4 14.28,82.41 15.18,82.41 v6(15.29,82.31)
PD_USB20_P1_T_R: length 6.2
  BOTTOM w0.145: JUSBC1.B6 7.94,82.36 11.08,82.36 DT15.1 11.54,82.35 12.9,82.35 12.96,82.41 13.49,82.41 LT11.3
PD_USB20_P2: length 6.1
  IN3 w0.086: v3(36.32,64.13) 36.45,64.26 36.45,65.04 36.48,65.08 36.48,65.43 36.07,65.84 36.07,67.05 36.36,67.34 36.36,68.12 36.27,68.22 36.06,68.22 35.99,68.15 35.99,67.91 35.88,67.81 35.76,67.81 35.68,67.89 v3(35.68,68.03)
  BOTTOM w0.145: v3(36.32,64.13) RP126.2
PD_USB20_P2_B: length 40.6
  TOP w0.145: LT8.4 13.9,97.32 14.04,97.17 14.04,97.03 13.94,96.93 13.84,96.93 13.73,96.82 13.73,96.51 14.04,96.2 14.29,96.2 14.37,96.28 v9(14.37,96.61)
  IN3 w0.086: v9(14.37,96.61) 14.23,96.47 14.04,96.47 13.69,96.12 13.69,92.39 15.29,90.8 15.29,87.38 18.76,83.91 18.76,81.06 20.31,79.51 20.31,73.81 21.04,73.08 24.99,73.08 25.64,72.43 25.64,72.1 26.14,71.6 29.17,71.6 29.81,70.96 29.81,70.52 30.3,70.03 v3(30.68,70.03)
PD_USB20_P2_B_R: length 6
  TOP w0.145: LT8.3 13.78,98.01 13.78,98.72 13.43,99.07 DT58.1 11.11,98.87 v10(10.4,98.87) 9.92,98.87 9.82,98.97 JUSBC2.A6
PD_USB20_P2_T: length 40.8
  IN3 w0.086: v6(13.37,97.25) 13.37,96.91 12.99,96.52 12.99,91.85 14.46,90.38 14.46,86.96 17.77,83.65 17.77,80.98 19.27,79.48 19.27,73.68 20.57,72.37 24.64,72.37 24.9,72.11 24.9,71.83 25.83,70.9 28.83,70.9 29.1,70.63 29.1,70.18 29.59,69.69 29.59,68.89 30.02,68.47 30.46,68.47 30.51,68.53 v3(30.68,68.53)
PD_USB20_P2_T_R: length 7.3
  BOTTOM w0.145: JUSBC2.B6 7.98,98.6 11.13,98.6 DT53.1 11.66,98.76 13.25,98.76 13.52,98.49 13.52,98.34 13.41,98.24 13.26,98.24 13.14,98.12 13.14,97.97 13.26,97.85 LT10.3
PECI_EC: length 234.4
  TOP w0.127: v2(54.77,5.26) 55.03,5.52 55.03,5.97 54.18,6.81 RE153.2 ; v2(73,3.7) 73,11.77 v1(73.12,11.89) 73.13,11.89 73.96,11.89 74.59,12.52 75.4,12.52 78.44,15.57 78.44,18.04 80.02,19.61 80.02,22.36 v2(80.22,22.57) ; RH95.2 31.09,36.15 31.28,35.96 v2(31.76,35.96)
  IN1 w0.064: v2(54.77,5.26) 55.01,5.03 57.37,5.03 57.85,4.55 60.21,4.55 60.88,3.88 70.52,3.88 70.7,3.7 v2(73,3.7) ; v2(31.76,35.96) 31.82,36.02 32.48,36.02 32.95,35.55 40.03,35.55 40.7,34.89 40.7,33.73 42.88,31.55 46.25,31.55 46.6,31.89 47.54,31.89 48.22,32.57 53.09,32.57 54.69,30.97 54.93,30.97 55.65,30.24 58.02,30.24 58.2,30.06 61.34,30.06 62.77,28.64 64.94,28.64 65.12,28.46 66.15,28.46 69.61,25 75.07,25 76.2,23.87 76.69,23.87 77.99,22.57 v2(80.22,22.57) 80.88,22.57 81.21,22.23 85.26,22.23 85.72,21.77 87.65,21.77 90.24,19.18 93.04,19.18 93.46,18.76 96.54,18.76 96.8,18.51 96.85,18.51 97.08,18.28 97.08,18.22 97.49,17.81 103.35,17.81 104.82,19.28 104.82,19.68 106.1,20.95 108.54,20.95 110.66,18.83 111.42,18.83 113.77,18.83 114.01,18.6 115.14,18.6 115.7,18.03 123.83,18.03 124.95,16.91 128.93,16.91 133.78,21.76 133.78,22.21 134.88,23.3 135.49,23.3 136.22,24.04 136.22,25.76 140.49,30.02 145.01,30.02 148.05,33.07 148.05,33.46 149.39,34.79 149.39,38.15 149.01,38.53 149.01,43.57 144.85,47.73 144.12,47.73 143.22,48.64 142.25,48.64 141.67,49.22 141.23,49.22 141.05,49.04 137.01,49.04 133.73,52.32 133.73,68.5 134.16,68.94 134.16,69.8 134.46,70.1 134.46,70.22 135.1,70.85 136.36,70.85 v4(136.61,70.61)
  GND2 w0.102: v5(136.22,71.02) 136.22,71 v4(136.61,70.61)
  GND3 w0.102: v6(135.9,71.32) 135.92,71.32 v5(136.22,71.02)
  BOTTOM w0.127: RH55.1 135.77,71.46 v6(135.9,71.32)
PECI_EC_R: length 6.6
  TOP w0.127: UE3.K13 51.43,9.12 51.43,8.37 RE153.1 52.99,6.81 53.5,6.31 54.07,6.31 v1(54.64,5.73)
PEG_RCOMP: length 4.3
  TOP w0.127: v7(89.06,84.78) 89.06,84.69 87.73,83.35 RH35.2
  GND2 w0.127: v7(89.06,84.78) 89.32,84.78 v5(89.53,84.56)
  GND3 w0.127: v5(89.53,84.56) 89.79,84.56 89.88,84.47 v6(89.89,84.47)
PLTRST_CPU#: length 195.8
  TOP w0.127: v7(53.39,60.71) 53.37,60.72 46.89,60.72 45.21,62.4 45.21,67.92 45.69,68.4 45.69,68.72 45.69,70.87 48.33,73.51 50.38,73.51 51.2,74.34 53.96,74.34 v1(54.33,74.71) 54.33,74.71 56.43,76.81 56.43,77.43 57.16,78.16 57.16,78.39 58.21,79.44 60.05,79.44 61.31,80.7 69,80.7 69.33,81.03 73.62,81.03 79.13,86.54 129.3,86.54 134.67,81.17 134.67,79.08 135.59,78.15 v2(135.59,77.82)
  IN1 w0.064: v4(131.5,72.76) 131.66,72.91 131.66,73.33 134.58,76.25 134.58,76.8 v2(135.59,77.82)
  GND2 w0.102: v5(131.38,72.36) 131.5,72.48 v4(131.5,72.76) ; v5(53.72,60.38) v7(53.39,60.71)
  GND3 w0.102: v6(131.1,72.1) 131.12,72.1 v5(131.38,72.36) ; v5(53.72,60.38) 53.74,60.41 v6(53.74,60.71)
  BOTTOM w0.076: 35.1,33.56 34.74,33.91 34.44,33.91 33.64,34.71 33.64,35.77 33.39,36.02
  BOTTOM w0.089: 33.39,36.02 UH4.AK2
  BOTTOM w0.127: 35.1,33.56 35.1,31.27 38.14,28.23 41.75,28.23 45.01,24.96 50.4,24.96 52.15,26.72 52.15,32.11 53.38,33.34 56.27,33.34 58.09,35.17 58.09,38.02 59.6,39.53 59.6,42.17 60.35,42.91 60.35,51.96 58.8,53.51 58.8,54.23 53.74,59.29 v6(53.74,60.71)
PLTRST_GPU_N: length 104.6
  TOP w0.127: v7(53.21,25.52) 53.5,25.24 v1(53.5,24.91) 54.3,24.1 54.3,22.57 54.46,22.42 UV14.4 56.24,22.42 RZ60.2 56.25,22.43 RZ61.2 56.26,23.19 RZ62.1 ; PR2340.1 42.08,47.07 v2(41.76,46.75)
  IN1 w0.064: v2(41.76,46.75) 42.56,45.95 49.11,45.95 v4(50.43,47.27) ; v4(61.14,67.6) 62.37,66.36 72.31,66.36 79.03,59.65 v4(80.36,59.65)
  GND2 w0.102: v7(53.21,25.52) 53.19,25.52 53.11,25.61 v5(52.78,25.61) ; v5(61.03,67.95) 61.03,67.7 v4(61.14,67.6) ; v5(80.74,59.65) v4(80.36,59.65) ; v5(50.76,47.27) v4(50.43,47.27)
  IN2 w0.074: v5(54.63,73.95) 54.43,73.74 54.43,69.52 52.96,68.05 52.96,66.56 50.28,63.89 49.37,63.89 48.13,62.65 48.13,57.22 47.8,56.88 47.8,54.13 51.15,50.78 51.15,47.86 50.76,47.46 v5(50.76,47.27) 50.76,45.51 50.69,45.44 50.69,33.47 50.87,33.29 50.87,27.52 v5(52.78,25.61)
  GND3 w0.102: v8(54.99,74.02) 54.91,73.95 v5(54.63,73.95) ; v8(60.75,68.2) 61.01,67.95 v5(61.03,67.95) ; v6(80.99,59.89) 80.99,59.89 v5(80.74,59.65)
  IN3 w0.064: v8(60.75,68.2) 54.99,73.97 v8(54.99,74.02)
POWER_SW_IN#: length 10.6
  TOP w0.122: v7(43.54,15.46) 43.95,15.04 UE3.D5
  TOP w0.127: v7(35.82,17.1) RE187.1 35.82,18.33 CE101.1
  IN1 w0.064: v7(43.54,15.46) 42.36,16.63 36.29,16.63 v7(35.82,17.1)
PROC_DETECT#: length 149.8
  TOP w0.127: v2(136.34,85.4) 132.64,89.11 84.64,89.11 83.83,89.91 72.01,89.91 v1(71.22,90.7) 71.22,91.62 70.18,92.67 70.18,93.5 v2(69.8,93.88)
  IN1 w0.064: v2(136.34,85.4) 137.1,84.64 137.1,82.61 137.56,82.14 137.56,78.31 136.09,76.84 136.09,76.19 v4(133.31,73.42) ; v4(39.04,56.55) 39.09,56.55 43.24,60.7 43.24,61.63 44.8,63.19 44.8,68.27 47.67,71.14 47.67,84.9 48.76,85.99 48.76,88.39 51.63,91.26 51.63,91.79 53.41,93.56 53.41,93.99 53.77,94.36 54.24,94.36 54.59,94.71 57.77,94.71 58.49,95.43 62.68,95.43 63.01,95.1 66.55,95.1 67.76,93.88 v2(69.8,93.88)
  GND2 w0.102: v5(133.45,73.03) 133.45,73.28 v4(133.31,73.42) ; v4(39.04,56.55) 38.85,56.73 v5(38.71,56.73)
  GND3 w0.102: v6(38.37,56.76) 38.69,56.76 v5(38.71,56.73) ; v5(133.45,73.03) 133.8,73.03 v6(133.83,73.01)
  BOTTOM w0.127: RH56.1 135.14,72.26 134.74,72.65 134.18,72.65 v6(133.83,73.01)
PROCHOT_FET_INV: length 2.8
  TOP w0.127: v1(55.35,16.79) 55.99,16.15 DV9.1 56.23,16.66 56.74,17.16 QC7.5
PROCHOT_GPU#: length 39
  TOP w0.127: v2(58.69,8.69) 58.82,8.55 60.75,8.55 v1(65.27,13.08) 65.62,13.42 65.62,16.92 65.22,17.32 60.16,17.32 59.71,16.87 RH606.2 59.71,16.01 59.17,15.46 UC10.1
  IN1 w0.064: v2(44.75,7.79) 44.75,8.32 46.13,9.7 46.13,10.41 46.79,11.07 46.98,11.07 47.76,11.85 48.09,11.85 48.21,11.98 48.8,11.98 48.98,12.15 49.27,12.15 49.73,11.69 52.18,11.69 54.45,9.42 55.59,9.42 55.74,9.27 58.11,9.27 v2(58.69,8.69)
PROCHOT_XOR_OUT: length 9.8
  TOP w0.127: UC10.4 61.01,14.16 61.07,14.23 RH582.2 61.69,13.87 61.54,13.72 57.2,13.72 57.1,13.62 56.66,13.62 56.04,14.25 DV9.2 55.47,14.25 v1(54.45,15.26)
PROCHOT_XOR_OUT_FET: length 3.3
  TOP w0.127: QC6.2 58.58,12.02 v1(58.36,11.8) 58.26,11.7 RH603.2 58.54,10.9 59.01,11.37 QC6.3
PWM1: length 34.5
  TOP w0.203: PR1814.1 62.69,33.55 61.62,34.63 61.33,34.63 v1(61.26,34.7) 60.82,35.13 PU1800.31
  TOP w0.254: v2(64.02,34.04) 63.65,33.67 PR1814.1
  IN1 w0.254: v9(90.41,33.81) 86.08,33.81 84.45,32.19 77.09,32.19 75.43,30.54 69.49,30.54 68.7,31.32 67.32,31.32 66.76,31.88 66.76,31.98 64.71,34.04 v2(64.02,34.04)
PWM2: length 18.9
  TOP w0.203: PU1800.29 60.65,34.33 v2(60.93,34.05) 61,34.05 v1(62.74,32.31) 63.28,31.77 PR1812.1
  IN1 w0.254: v2(60.93,34.05) 60.94,34.05 62.84,35.95 68.35,35.95 70.56,33.74 v9(73.12,33.74)
PWM3: length 27.3
  TOP w0.203: PR1825.1 63.08,32.66 v1(62.07,33.67) 61.99,33.75 61.77,33.75 v2(61.51,34) 61.45,34 60.72,34.73 PU1800.30
  IN1 w0.254: v2(61.51,34) 62.22,34.71 64.58,34.71 67.54,31.76 75.64,31.76 77.72,33.84 v9(81.66,33.84)
PWM4: length 43.8
  TOP w0.203: PU1800.28 60.42,33.93 60.84,33.51 v1(60.84,33.29) 61.16,32.96 61.55,32.96 63.04,31.48 v2(63.07,31.48) 63.65,30.91 PR1832.1
  IN1 w0.254: v9(99.26,33.84) 94.69,33.84 92.58,31.73 77.75,31.73 75.87,29.85 69.31,29.85 68.35,30.82 65.73,30.82 65.23,31.32 63.23,31.32 v2(63.07,31.48)
PWM_CORE1: length 35.1
  TOP w0.127: v9(113.76,34.3) v1(113.76,33.67)
  TOP w0.203: PU1100.43 137.87,39.42 v2(137.81,39.36)
  IN1 w0.254: v9(113.76,34.3) 113.76,33.86 113.13,33.23 113.13,31.63 113.76,30.99 132.67,30.99 135.3,33.62 135.3,35.72 137.81,38.23 v2(137.81,39.36)
  BOTTOM w0.203: v9(113.76,34.3) 113.97,34.5 PU1200.9
PWM_CORE2: length 25.3
  TOP w0.127: v9(121.08,33.84) v1(121.08,34.45)
  TOP w0.203: v2(137.77,39.82) PU1100.42
  IN1 w0.254: v2(137.77,39.82) 137.39,39.44 137.39,38.69 134.74,36.05 134.74,33.76 132.56,31.58 123.44,31.58 122.6,32.42 122.6,33.51 122.27,33.84 v9(121.08,33.84)
  BOTTOM w0.203: v9(121.08,33.84) 121.22,33.98 PU1201.9
PWM_CORE3: length 20.1
  TOP w0.127: v9(128.11,35.16) v1(127.5,35.16)
  TOP w0.203: PU1100.41 v2(137.77,40.22)
  IN1 w0.254: v2(137.77,40.22) 137.58,40.22 136.88,39.52 136.88,38.92 134.13,36.18 134.13,33.84 132.48,32.19 128.27,32.19 127.48,32.98 127.48,34.52 v9(128.11,35.16)
  BOTTOM w0.203: v9(128.11,35.16) 128.37,35.42 PU1202.9
PWM_FAN1: length 143.4
  TOP w0.127: v7(141.51,31.55) 141.51,30.86 139.54,28.89 139.54,27.69 RE1.2 ; v7(83.71,28.35) 83.98,28.09 83.98,17.61 v1(83.79,17.42) 83.05,16.68 83.05,13.85 83.92,12.98 83.92,7.15 82.71,5.94 v2(82.71,4.9)
  IN1 w0.064: v2(47.95,9.39) 47.95,9 48.14,8.81 48.62,8.81 48.75,8.93 49.55,8.93 49.68,8.81 50.8,8.81 52.07,7.54 56.92,7.54 57.3,7.16 60.79,7.16 61.92,6.03 67.63,6.03 67.93,5.73 71.96,5.73 72.15,5.92 76.19,5.92 76.54,5.57 77.77,5.57 78.07,5.27 79.72,5.27 80.09,4.9 v2(82.71,4.9)
  GND2 w0.102: v5(141.83,31.39) 141.68,31.39 v7(141.51,31.55) ; v5(83.71,28.68) v7(83.71,28.35)
  IN2 w0.074: v5(83.71,28.68) 84.06,28.34 84.54,28.34 86.38,30.18 95.92,30.18 96.57,30.83 99.52,30.83 100.44,31.75 105.9,31.75 106.47,31.18 107.17,31.18 109.89,28.46 113.34,28.46 113.85,28.98 114.93,28.98 115.16,29.21 123.38,29.21 123.68,28.91 134.68,28.91 134.99,29.21 136.92,29.21 137.74,30.03 139.78,30.03 141.14,31.39 v5(141.83,31.39)
  GND3 w0.102: v6(142.21,31.07) 141.89,31.39 v5(141.83,31.39)
  BOTTOM w0.127: JFAN1.2 143.72,37.42 144.13,37.01 144.13,35.91 146.26,33.78 146.26,32.23 145.26,31.23 145.26,30.44 145.13,30.31 142.97,30.31 v6(142.21,31.07)
PWM_FAN2: length 137.7
  TOP w0.127: UE3.L11 48.43,9.07 v7(48.37,9.07) ; v2(83.07,4.91) 83.07,6.01 84.24,7.18 v1(84.24,11.7) 84.24,12.95 83.28,13.91 83.28,15.89 84.18,16.79 84.18,28.2 84.26,28.28 84.26,28.34 v7(84.27,28.35) ; v7(142.26,31.83) 142.19,31.9 141.44,31.9 141.06,31.52 141.06,30.69 140.37,30 RE6.2
  IN1 w0.064: v7(48.37,9.07) 50.76,9.07 52.16,7.68 56.98,7.68 57.36,7.3 60.85,7.3 61.97,6.17 67.69,6.17 67.99,5.87 71.91,5.87 72.09,6.06 76.25,6.06 76.59,5.71 77.83,5.71 78.13,5.41 79.78,5.41 80.03,5.16 82.81,5.16 v2(83.07,4.91)
  GND2 w0.102: v5(141.83,31.9) 141.89,31.83 v7(142.26,31.83) ; v5(84.27,28.68) v7(84.27,28.35)
  IN2 w0.074: v5(84.27,28.68) 85.95,30.36 95.88,30.36 96.5,30.98 99.46,30.98 100.38,31.9 105.97,31.9 106.54,31.33 107.23,31.33 109.95,28.61 113.27,28.61 113.79,29.13 114.87,29.13 115.1,29.36 123.44,29.36 123.72,29.08 134.61,29.08 134.89,29.36 136.86,29.36 137.68,30.18 139.72,30.18 141.43,31.9 v5(141.83,31.9)
  GND3 w0.102: v5(141.83,31.9) 142.02,32.08 v6(142.1,32.08)
  BOTTOM w0.127: v6(142.1,32.08) 142.36,32.34 142.36,33.08 142.21,33.23 142.21,39.29 142.34,39.42 JFAN1.4
PWM_GT1: length 24.8
  TOP w0.127: v1(137.39,40.13) 137.26,40.26 v9(137.26,40.6)
  TOP w0.203: PU1100.40 137.28,40.62 v9(137.26,40.6)
  IN3 w0.254: v3(149.83,54.31) 149.96,54.18 149.96,53.1 149.64,52.79 148.93,52.79 148.23,52.09 148.23,49.57 146.4,47.74 v3(146.4,46.75)
  BOTTOM w0.254: v3(146.4,46.75) 141.58,46.75 140.15,45.33 140.15,42.22 138.53,40.6 v9(137.26,40.6)
PWM_GT2: length 35.5
  TOP w0.127: v1(137.32,41.74) 137.26,41.67 v9(137.26,41.23)
  TOP w0.203: v9(137.26,41.23) 137.32,41.23 137.53,41.02 PU1100.39
  IN3 w0.254: v3(146.76,47.11) 146.76,47.63 148.56,49.43 148.56,51.95 149.07,52.46 149.78,52.46 150.29,52.97 150.29,55.21 151.58,56.51 151.58,61.87 150.35,63.11 150.35,64.08 v9(150.34,64.09)
  BOTTOM w0.254: v3(146.76,47.11) 141.36,47.11 139.75,45.5 139.75,42.44 138.53,41.23 v9(137.26,41.23)
PWM_SA: length 44.9
  TOP w0.127: v9(106.93,35.11) v1(106.45,34.63)
  TOP w0.203: PU1100.38 v2(137.77,41.42)
  IN1 w0.254: v2(137.77,41.42) 138.59,40.59 138.59,38.32 135.86,35.59 135.86,33.42 132.83,30.38 113.31,30.38 112.37,31.32 112.37,33.17 111.72,33.81 108,33.81 107.16,34.65 107.16,34.88 v9(106.93,35.11)
  BOTTOM w0.203: v9(106.93,35.11) 106.93,35.29 107.11,35.46 PU1302.9
PWM_VDD12: length 31
  TOP w0.203: v7(63.65,29.99) 62.63,31.01 62.33,31.01 v1(62.2,31.13) 62.07,31.26 62.07,31.83 61.31,32.59 60.93,32.59 60.45,33.08 60.45,33.33 60.24,33.53 PU1800.27
  TOP w0.254: v9(58.15,49.35) 57.84,49.35 57.54,49.65 PU2200.2
  GND2 w0.254: v7(63.65,29.99) v5(63.27,29.99)
  IN2 w0.254: v5(63.27,29.99) 61.36,31.9 61.36,39.73 58.63,42.46 58.63,48.86 v9(58.15,49.35)
REM_DIODE1_N: length 222.1
  TOP w0.089: 46.7,18.45 46.69,18.44 46.66,18.44 46.06,17.84 46.06,17.48 46.15,17.39 UE3.A8
  TOP w0.127: v2(89.57,10.88) 89.61,10.92 89.61,14.39 90.6,15.38 90.6,18.57 90.12,19.05 90.12,21.32 v2(90.05,21.38) 90.16,21.49 90.16,27.64 v2(90.08,27.72) ; 46.7,18.45 47.24,18.99 47.24,19.34 CE58.1 47.34,19.97 47.34,21.25 v2(47.41,21.32) ; v7(106.82,77.55) 106.82,78.15 QE12.3 ; QE20.1 157.97,14.33 QE20.2 156.17,13.79 155.77,13.79 CE93.2 155.44,13.79 153.68,13.79 152.67,12.77 138.15,12.77 137.26,13.67 135.48,13.67 133.38,11.58 132.37,11.58 130.53,13.42 130.53,17.97 v2(129.19,19.3)
  IN1 w0.127: v2(129.19,19.3) 124.93,19.3 124.3,19.93 116.2,19.93 115.92,20.22 114.68,20.22 114.44,20.45 111.33,20.45 109.21,22.57 105.21,22.57 103.92,21.28 93.24,21.28 93.13,21.18 92.02,21.18 91.2,22 90.4,22 90.12,21.71 90.12,21.44 v2(90.05,21.38) ; v4(106.32,52.76) 106.26,52.71 106.26,50.81 107.49,49.58 107.49,42.6 104.55,39.66 104.55,29.83 104,29.28 104,27.16 102.8,25.97 102.8,25.55 102.28,25.02 98.51,25.02 95.81,27.72 v2(90.08,27.72) ; v2(89.57,10.88) 89.63,10.94 89.63,11 89.48,11.16 84.49,11.16 83.53,12.12 82.63,12.12 82.21,12.55 79.29,12.55 78.45,13.38 70.38,13.38 68.8,14.95 65.59,14.95 64.27,16.27 64.27,17.53 62.48,19.32 57.07,19.32 56.31,20.08 56.14,20.08 55.56,20.67 53.25,20.67 52.58,21.34 51.53,21.34 50.86,20.67 49.47,20.67 48.82,21.32 v2(47.41,21.32)
  GND2 w0.102: v5(107.02,77.07) 106.82,77.27 v7(106.82,77.55)
  GND2 w0.127: v4(106.32,52.76) 106.29,52.79 106.29,53.08 v5(106.43,53.22)
  IN2 w0.127: v5(107.02,77.07) 106.87,76.92 106.87,76.28 106.45,75.85 105.61,75.85 105.14,75.38 105.14,64.18 106.91,62.42 106.91,54.62 106.28,53.99 106.28,53.36 v5(106.43,53.22)
REM_DIODE1_P: length 222.3
  TOP w0.089: UE3.A7 45.75,17.39 45.84,17.48 45.84,17.93 46.51,18.59 46.51,18.62 46.52,18.63
  TOP w0.127: QE20.3 156.22,13.53 155.77,13.53 CE93.1 155.44,13.53 153.78,13.53 152.77,12.52 138.05,12.52 137.15,13.42 135.59,13.42 133.49,11.32 132.26,11.32 130.27,13.31 130.27,17.86 129.19,18.94 v2(129.03,18.94) ; v2(89.95,10.88) 89.87,10.96 89.87,14.29 90.85,15.27 90.85,18.67 90.37,19.16 90.37,21.32 v2(90.43,21.38) 90.43,27.92 v2(90.34,28.01) ; v2(47.41,21.74) 47.23,21.56 47.23,21.55 47.09,21.41 47.09,20.1 CE58.2 46.99,19.41 46.99,19.1 46.52,18.63 ; QE12.1 105.94,79.82 QE12.2 105.94,77.85 v7(106.23,77.55)
  IN1 w0.127: v2(129.03,18.94) 128.93,19.05 124.83,19.05 124.2,19.68 116.1,19.68 115.81,19.96 114.58,19.96 114.34,20.2 111.22,20.2 109.1,22.32 105.32,22.32 104.03,21.03 93.35,21.03 93.24,20.92 91.92,20.92 91.09,21.75 90.51,21.75 90.37,21.61 90.37,21.44 v2(90.43,21.38) ; v4(105.94,52.76) 106.01,52.69 106.01,50.7 107.24,49.47 107.24,42.7 104.3,39.76 104.3,29.94 103.74,29.38 103.74,27.27 102.55,26.07 102.55,25.65 102.17,25.28 98.61,25.28 95.88,28.01 v2(90.34,28.01) ; v2(47.41,21.74) 47.57,21.57 48.93,21.57 49.58,20.92 50.75,20.92 51.43,21.6 52.69,21.6 53.36,20.92 55.66,20.92 56.25,20.34 56.41,20.34 57.17,19.58 62.58,19.58 64.53,17.63 64.53,16.38 65.7,15.21 68.91,15.21 70.48,13.64 78.55,13.64 79.39,12.8 82.31,12.8 82.74,12.38 83.63,12.38 84.6,11.41 89.59,11.41 89.89,11.11 89.89,10.94 v2(89.95,10.88)
  GND2 w0.102: v7(106.23,77.55) 106.23,77.31 v5(106.47,77.07)
  GND2 w0.127: v5(105.9,53.22) 106.04,53.08 106.04,52.86 v4(105.94,52.76)
  IN2 w0.127: v5(106.47,77.07) 106.62,76.92 106.62,76.38 106.34,76.1 105.5,76.1 104.89,75.49 104.89,64.08 106.65,62.31 106.65,54.72 106.03,54.1 106.03,53.35 v5(105.9,53.22)
REM_DIODE2_N: length 179.5
  TOP w0.076: UE3.A10 47.71,17.39 47.63,17.47 47.63,17.83 48.27,18.47 48.91,18.47 49.42,18.98 49.49,18.98 49.5,18.99
  TOP w0.127: v7(51.53,24.21) 51.47,24.15 51.47,23.43 51.28,23.24 51.28,21.83 49.69,20.24 49.69,20.03 CE59.1 49.93,19.7 49.67,19.44 49.67,19.16 49.5,18.99 ; v2(49.18,76.41) 49.12,76.47 48.13,76.47 43.37,71.72 43.37,71.54 v7(43.45,71.46) 43.45,70.79 QE21.2 43.1,69.81 42.45,69.16 QE21.1
  IN1 w0.127: v9(90.34,98.21) 90.18,98.05 89.86,98.05 89.61,97.8 88.52,97.8 88.32,98 83.74,98 82.67,96.93 81.33,96.93 80.53,97.73 77.96,97.73 76.32,96.09 73.09,96.09 71.44,94.44 71.19,94.44 70.15,93.4 67.2,93.4 65.99,94.62 61.16,94.62 60.75,94.21 55.41,94.21 53.48,92.28 53.18,92.28 52.24,91.35 52.24,88.96 49.37,86.09 49.37,85.2 48.42,84.24 48.42,76.75 48.7,76.47 49.12,76.47 v2(49.18,76.41)
  GND2 w0.127: v7(51.53,24.21) 51.53,24.53 v5(51.41,24.66) ; v7(43.45,71.46) v5(43.45,71.09)
  IN2 w0.127: v5(51.41,24.66) 50.99,25.08 48.44,25.08 48.28,24.91 45.92,24.91 44.58,26.25 44.58,27.63 44.38,27.83 44.38,30.09 45.67,31.38 47.27,31.38 48.15,32.25 48.15,35.46 47.72,35.89 47.72,39.6 48.49,40.37 48.49,49.96 44.61,53.84 44.61,55.2 44.1,55.71 44.1,56.06 42.96,57.2 42.96,59.95 44.9,61.89 44.9,65.44 43.34,67 43.34,70.98 v5(43.45,71.09)
  BOTTOM w0.127: QE14.3 116.26,105.3 116.56,105.01 116.56,104.1 CE87.2 116.56,101.53 117.09,100.99 117.09,95.99 115.87,94.77 103.88,94.77 103.47,95.19 102.14,95.19 101.44,95.89 95.78,95.89 94.06,97.62 93.85,97.62 93.42,98.05 90.51,98.05 v9(90.34,98.21)
REM_DIODE2_P: length 179.9
  TOP w0.076: 49.32,19.17 49.31,19.16 49.31,19.09 48.84,18.63 48.2,18.63 47.47,17.9 47.47,17.47 47.39,17.39 UE3.A9
  TOP w0.127: 49.32,19.17 49.42,19.26 49.42,19.44 49.16,19.7 CE59.2 49.44,20.03 49.44,20.35 51.03,21.94 51.03,23.35 51.22,23.54 51.22,24.15 v7(51.15,24.21) ; v2(49.18,76.79) 49.12,76.73 48.02,76.73 43.02,71.73 43.02,71.61 v7(42.87,71.46) 41.85,70.44 QE21.3
  IN1 w0.127: v9(90.34,97.63) 90.18,97.8 89.97,97.8 89.71,97.54 88.41,97.54 88.21,97.75 83.85,97.75 82.78,96.68 81.22,96.68 80.42,97.48 78.06,97.48 76.42,95.84 73.2,95.84 71.55,94.19 71.29,94.19 70.25,93.15 67.1,93.15 65.88,94.37 61.27,94.37 60.85,93.96 55.52,93.96 53.59,92.03 53.29,92.03 52.5,91.24 52.5,88.86 49.63,85.98 49.63,85.09 48.68,84.14 48.68,76.85 48.8,76.73 49.12,76.73 v2(49.18,76.79)
  GND2 w0.127: v7(51.15,24.21) 50.89,24.47 v5(50.89,24.51) ; v7(42.87,71.46) v5(42.87,71.1)
  IN2 w0.127: v5(50.89,24.51) 50.58,24.82 48.55,24.82 48.38,24.66 45.82,24.66 44.33,26.15 44.33,27.52 44.13,27.72 44.13,30.19 45.57,31.63 47.17,31.63 47.9,32.36 47.9,35.35 47.47,35.78 47.47,39.7 48.23,40.47 48.23,49.86 44.36,53.73 44.36,55.09 43.85,55.6 43.85,55.96 42.71,57.1 42.71,60.05 44.65,61.99 44.65,65.33 43.09,66.89 43.09,70.88 v5(42.87,71.1)
  BOTTOM w0.127: v9(90.34,97.63) 90.51,97.8 93.32,97.8 93.75,97.36 93.95,97.36 95.68,95.64 101.33,95.64 102.03,94.93 103.36,94.93 103.78,94.52 115.98,94.52 117.34,95.89 117.34,101.1 116.81,101.63 116.81,103.69 117.14,104.02 CE87.1 117.14,104.25 116.84,104.55 116.84,105.03 117.11,105.3 QE14.2 116.68,105.95 QE14.1
REM_DIODE3_N: length 98.9
  TOP w0.076: 47.98,18.88 47.96,18.86 47.9,18.86 47.81,18.77 46.83,17.8 46.83,16.67 46.91,16.59 UE3.B9
  TOP w0.127: v9(81.96,19.46) 82.22,19.72 82.22,21.15 82.8,21.74 82.8,24.87 81.7,25.98 81.7,28.47 v2(81.51,28.66) ; CE105.2 96.87,43.58 v2(97.32,43.14) 96.49,43.14 96.24,42.88 QE28.1 96.87,42.5 97.52,41.85 QE28.2 ; v7(48.88,20.85) 48.88,20.8 48.55,20.47 48.55,19.45 47.98,18.88
  IN1 w0.127: v2(81.51,28.66) 83.68,30.83 92.49,30.83 94.86,33.2 99.47,33.2 99.81,33.54 99.81,33.88 100.62,34.69 100.62,37.24 98.41,39.45 98.41,42.37 97.83,42.94 97.51,42.94 v2(97.32,43.14)
  GND2 w0.102: v5(48.69,20.29) 48.88,20.48 v7(48.88,20.85)
  GND3 w0.102: v5(48.69,20.29) 48.51,20.11 48.51,19.82 v6(48.59,19.74)
  BOTTOM w0.127: v9(81.96,19.46) 82.17,19.26 82.17,18.88 79.24,15.96 78.23,15.96 77.7,16.49 77.7,17.21 QE22.3 77.62,18.08 77.62,18.67 CE95.2 77.58,18.99 77.58,19.38 75.52,21.44 75.52,23.35 72.88,25.99 58.94,25.99 56.09,23.13 54.89,23.13 51.45,19.69 48.64,19.69 v6(48.59,19.74)
REM_DIODE3_P: length 97.8
  TOP w0.076: UE3.B8 46.59,16.59 46.67,16.67 46.67,17.87 47.65,18.84 47.78,18.98 47.78,19.04 47.8,19.06
  TOP w0.127: v9(82.62,19.46) 82.47,19.61 82.47,21.05 83.05,21.63 83.05,24.98 81.95,26.08 81.95,28.53 v2(82.08,28.66) ; v7(47.96,20.85) 48.29,20.52 48.29,19.55 47.8,19.06 ; CE105.1 97.06,44.66 97.24,44.48 97.24,43.78 v2(97.44,43.58) 97.87,43.15 QE28.3
  IN1 w0.127: v2(97.44,43.58) 97.82,43.2 97.94,43.2 98.66,42.47 98.66,39.55 100.87,37.34 100.87,34.59 100.06,33.78 100.06,33.43 99.58,32.95 94.97,32.95 92.59,30.57 83.99,30.57 v2(82.08,28.66)
  GND2 w0.102: v7(47.96,20.85) 47.96,20.48 v5(48.15,20.29)
  GND3 w0.102: v6(48.21,19.74) 48.28,19.82 48.28,20.16 v5(48.15,20.29)
  BOTTOM w0.127: v9(82.62,19.46) 82.42,19.26 82.42,18.78 79.35,15.71 QE22.1 77.44,16.96 QE22.2 77.36,18.18 77.36,18.62 CE95.1 77.33,18.97 77.33,19.27 75.27,21.33 75.27,23.24 72.77,25.74 59.05,25.74 56.19,22.88 55,22.88 51.56,19.44 48.48,19.44 48.21,19.71 v6(48.21,19.74)
REM_DIODE4_N: length 93.8
  TOP w0.127: v1(35.39,20.83) 34.96,21.26 QE23.1 36.21,22.62 QE23.2 37.5,21.97 37.73,22.21 v2(38.07,22.21) ; UE3.A11 48.75,17.59 49.12,17.96 49.64,17.96 50.4,18.73 51.46,18.73 51.79,19.05 51.79,19.31 CE62.1 51.79,19.97 51.79,20.27 51.74,20.33 51.74,20.41 v2(51.86,20.54)
  IN1 w0.127: v2(38.07,22.21) 38.82,22.95 43.14,22.95 44.61,21.48 45.56,21.48 45.69,21.35 45.96,21.35 47.41,19.91 51.48,19.91 51.79,20.21 51.79,20.47 v2(51.86,20.54) 52.3,20.54 52.94,19.91 55.24,19.91 55.83,19.32 55.99,19.32 56.75,18.56 61.88,18.56 63.34,17.1 63.34,16.12 65.27,14.19 68.43,14.19 70.1,12.53 72.17,12.53 73.12,11.58 77.46,11.58 79.25,9.79 83.22,9.79 84.36,8.65 84.99,8.65 85.55,8.08 98.9,8.08 100.2,9.38 103.58,9.38 103.94,9.74 104.67,9.74 106.29,11.37 107.14,11.37 107.39,11.61 110.45,11.61 v4(110.7,11.36)
  GND2 w0.102: v4(110.7,11.36) v5(110.7,11.03)
  GND3 w0.102: v5(110.7,11.03) 110.93,11.03 v6(111.06,10.9)
REM_DIODE4_P: length 93.5
  TOP w0.127: v2(51.46,20.54) 51.48,20.52 51.48,20.22 51.53,20.17 51.53,19.97 CE62.2 51.53,19.31 51.53,19.16 51.36,18.98 50.29,18.98 49.53,18.22 49.02,18.22 48.36,17.56 48.36,17 UE3.B10 ; v2(38.83,23.64) 38.52,23.64 38.07,23.2 CE104.1 37.35,22.79 QE23.3
  IN1 w0.127: v4(111.1,13.56) 111.1,12.75 110.21,11.86 107.28,11.86 107.04,11.62 106.19,11.62 104.56,10 103.84,10 103.47,9.63 100.09,9.63 98.8,8.34 85.66,8.34 85.09,8.9 84.47,8.9 83.33,10.05 79.35,10.05 77.56,11.84 73.22,11.84 72.28,12.78 70.2,12.78 68.54,14.45 65.38,14.45 63.6,16.23 63.6,17.21 61.99,18.81 56.86,18.81 56.1,19.58 55.93,19.58 55.35,20.16 53.04,20.16 52.37,20.83 51.74,20.83 51.46,20.55 v2(51.46,20.54) 51.53,20.47 51.53,20.32 51.38,20.16 47.52,20.16 46.07,21.61 45.8,21.61 45.67,21.74 44.72,21.74 43.24,23.21 39.26,23.21 v2(38.83,23.64)
  GND2 w0.102: v4(111.1,13.56) 111.05,13.61 v5(110.59,13.61)
  GND3 w0.127: v5(110.59,13.61) 110.06,13.08 v6(110.06,12.9)
RESET_IN#: length 3.3
  TOP w0.089: 40.12,15.59 40.32,15.79 UE3.C1
  TOP w0.127: RE247.1 38.34,14.56 v1(38.9,15.12) 39.65,15.12 40.12,15.59
RREF: length 2.6
  TOP w0.203: 24.25,67.53 24,67.53 23.89,67.42 UR1.9
  TOP w0.305: 24.25,67.53 25.94,67.53 RR9.2
RSVD: length 31.7
  GND3 w0.102: v8(117.17,77.04) v8(117.17,76.51)
  IN3 w0.061: v3(120.04,77.96) 120.04,77.35 119.73,77.04 v8(117.17,77.04) 116.66,77.04 116.46,77.25 116.46,77.88 v6(116.38,77.96)
  IN3 w0.064: v6(117.21,65.15) 117.1,65.15 116.91,65.33 116.91,67 114.55,69.36 111.92,69.36 111.22,70.06 111.22,74.06 113.88,76.71 114.93,76.71 115.13,76.51 v8(117.17,76.51)
  BOTTOM w0.127: UC1.CM33 121.94,65.65 121.66,65.92 117.57,65.92 117.22,65.56 117.22,65.15 v6(117.21,65.15)
RTCRST_ON: length 29.6
  TOP w0.127: v7(49.15,12.66) 49.15,12.99 UE3.F11 ; R5851.2 68.14,17.57 Q3.2 67.58,12.53 v1(66.54,11.49) v2(63.89,8.83)
  IN1 w0.064: v2(63.89,8.83) 59.59,8.83 59.01,9.41 55.8,9.41 55.65,9.56 54.51,9.56 52.12,11.95 52.12,12.75 51.81,13.06 50.84,13.06 50.57,12.79 49.29,12.79 v7(49.15,12.66)
RTCRST_ON_R: length 4.6
  TOP w0.127: QRTC1.2 68.57,26.08 D321.2 67.23,26.08 C2.1 66.27,25.01 R3.1 v1(65.29,24.25)
RTD3 SELECT: length 119.9
  TOP w0.127: RE429.1 44.99,2.5 44.55,2.05 v1(44.29,2.05) 42.34,2.05 41.89,2.5 41.89,4.51 v9(41.75,4.65)
  IN1 w0.064: v4(45.68,85.29) 45.14,84.75 45.14,71.65 42.61,69.12 42.61,64.36 40.8,62.55 40.8,62.03 37.54,58.77 37.25,58.77 34.86,56.38 32.53,56.38 31.18,55.03 31.18,53.9 30.58,53.3 30.26,53.3 30.14,53.17 30.14,52.92 29.92,52.7 29.36,52.7 27.12,50.46 27.12,49.1 27.4,48.83 27.4,43.82 26.59,43.01 26.59,41.93 v4(25.64,40.98)
  GND2 w0.102: v4(45.68,85.29) 45.68,85.29 v5(45.68,85.68) ; v5(25.31,40.85) 25.43,40.98 v4(25.64,40.98)
  GND3 w0.102: v5(45.68,85.68) 45.88,85.88 v6(45.88,85.94) ; v8(25.31,40.47) v5(25.31,40.85)
  IN3 w0.064: v8(25.31,40.47) 25.31,40.09 23.29,38.08 23.29,34.65 25.38,32.57 26.14,32.57 26.81,31.9 27.08,31.9 32.29,26.69 32.29,21.78 33.37,20.69 33.37,19.07 37.06,15.39 v3(37.06,14.81) ; v6(45.88,85.94) 46.7,86.76 47.72,86.76 48.1,87.14 48.1,88.65 v3(47.7,89.05)
  BOTTOM w0.127: v3(37.06,14.81) 37.26,14.61 37.26,10.11 38.67,8.7 38.67,6.53 39.21,5.99 40.61,5.99 41.75,4.84 v9(41.75,4.65) ; U4253.6 46.75,89.67 47.37,89.05 v3(47.7,89.05) ; v6(45.88,85.94) 45.89,85.94 46.2,86.25 47.98,86.25 48.1,86.12 48.1,86 RT239.1 48.55,86.11 48.55,86.62 48.42,86.74 U4254.6
RUN_ON_EC: length 124
  TOP w0.127: v2(18.97,27.26) 17.92,27.26 17.73,27.07 17.73,26.55 17.42,26.24 17.07,26.24 16.68,25.86 16.21,25.86 PR900.1 ; v7(30.73,27.31) 27.26,27.31 27.02,27.07 27.02,26.69 26.77,26.43 25.63,26.43 24.75,27.31 v2(22.93,27.31) 22.93,27.92 23.29,28.28 UZ23.3 ; v2(34.64,15.51) 34.64,15.75 33.91,16.49 33.91,17.51 33.5,17.91 33.5,18.83 32.01,20.31 32.01,21.89 v1(33.32,23.19) 33.89,23.77 v7(34.35,23.77) 34.53,23.77 35.32,24.55 RE294.2 35.32,25.16 35.68,25.53 UZ8.1 ; v7(45.74,13.78) 45.74,13.82 46.11,14.19 UE3.E8
  IN1 w0.064: v2(22.93,27.31) 19.02,27.31 v2(18.97,27.26) ; v2(34.64,15.51) 34.64,15.42 36.08,13.99 37.69,13.99 38.24,13.44 40.67,13.44 40.88,13.65 43.58,13.65 43.7,13.78 45.74,13.78 v7(45.74,13.78)
  GND2 w0.102: v7(34.35,23.77) 34.35,23.44 v5(34.34,23.44) ; v7(30.73,27.31) 30.78,27.26 v5(30.78,26.98)
  IN2 w0.074: v5(30.78,26.98) 34.32,23.44 v5(34.34,23.44)
  GND3 w0.102: v5(34.34,23.44) 34.48,23.3 v6(34.86,23.3)
  BOTTOM w0.127: v6(34.86,23.3) 35.27,23.3 36.04,22.53 36.04,21.59 37.72,19.91 43.45,19.91 43.88,20.34 51.38,20.34 54.68,23.64 55.88,23.64 58.77,26.54 73.05,26.54 76.77,22.82 RZ16.1 76.86,22.9 77.24,23.28 77.24,23.37 78.91,25.05 82.41,25.05 82.86,25.51 86.08,25.51 86.25,25.69 89.86,25.69 91.97,23.58 93.77,23.58 94.1,23.91 94.1,25.23 95.02,26.14 96.05,26.14 96.3,26.4 96.3,27.2 96.17,27.33 UZ2.3
RUN_ON_P: length 267.3
  TOP w0.127: v2(137.82,84.93) 137.65,84.93 137.57,85 136.2,85 v7(136.18,84.98) ; v2(99.29,19.31) v1(99.29,20.02) 99.29,20.54 100.96,22.22 101.11,22.22 101.53,22.64 101.53,22.68 PD1000.1 102.05,22.73 103.07,23.74 PR1003.1 ; RZ43.1 116.67,99.64 114.78,97.74 114.78,94.08 114.66,93.96 114.66,93.37 115.26,92.78 v7(116.62,92.78) ; UZ10.4 36.99,29.21 RZ23.2 36.99,28.03 v7(37,28.02) 37.15,27.88 DE2.1
  IN1 w0.064: v17(77.76,23.32) 78.14,22.94 81.56,22.94 81.76,22.74 85.47,22.74 85.93,22.28 87.86,22.28 90.45,19.69 94.21,19.69 94.59,19.31 v2(99.29,19.31) 99.29,19.21 100.01,18.48 102.91,18.48 105.89,21.46 108.75,21.46 110.87,19.34 113.98,19.34 114.22,19.1 115.35,19.1 115.91,18.54 120.35,18.54 120.63,18.82 123.75,18.82 125.16,17.42 128.72,17.42 133.28,21.98 133.28,22.42 134.67,23.81 135.27,23.81 135.71,24.25 135.71,26.33 139.91,30.53 144.8,30.53 147.55,33.28 147.55,33.67 148.88,35 148.88,37.62 147.96,38.54 147.96,41.81 142.57,47.2 142.21,47.2 140.74,48.67 136.86,48.67 132.94,52.59 132.94,68.49 133.75,69.31 133.75,69.91 134.09,70.25 134.09,70.37 135.11,71.39 137.32,71.39 138.11,72.18 142.55,72.18 143.72,73.35 143.72,78.32 142.2,79.85 142.2,82.7 141.76,83.14 141.76,83.88 140.71,84.93 v2(137.82,84.93)
  GND2 w0.102: v7(116.62,92.78) 116.5,92.78 v5(116.2,93.08) ; v5(77.34,22.93) 77.73,23.32 v17(77.76,23.32) ; v7(136.18,84.98) 135.89,84.7 v5(135.89,84.49) ; v7(37,28.02) v5(37,27.69)
  IN2 w0.074: v5(37,27.69) 38.61,26.09 38.61,20.95 38.93,20.63 44.82,20.63 45.42,21.23 49.69,21.23 50.28,20.63 52.58,20.63 52.76,20.45 55.85,20.45 56.73,19.57 61.06,19.57 63.08,21.59 75.26,21.59 76.6,22.93 v5(77.34,22.93)
  GND3 w0.102: v5(135.89,84.49) 135.89,84.49 135.65,84.73 v6(135.37,84.73) ; v5(116.2,93.08) 116.58,93.08 v6(116.7,92.97) ; v5(77.34,22.93) 76.92,23.35 v6(76.83,23.35)
  BOTTOM w0.127: v6(76.83,23.35) 76.2,23.98 76.2,28.11 76.95,28.87 78.68,28.87 79.57,27.98 UZ14.4 ; v6(116.7,92.97) 118,94.27 124.18,94.27 125.75,92.69 133.23,92.69 135.33,90.59 135.33,84.78 v6(135.37,84.73)
RUNPWROK: length 163
  TOP w0.127: DE2.2 35.27,23.48 34.05,23.48 32.22,21.64 32.22,20.4 33.77,18.84 33.77,18.08 v2(33.84,18.01) ; RE180.1 32.09,12.36 32.11,12.39 32.11,13.33 v7(31.71,13.73) 31.45,13.73 30.07,15.12 30.07,16.11 30.83,16.88 v2(30.83,17.38) ; v7(42.16,12.19) 42.16,12.4 UE3.G3 ; v2(97.51,6.79) 97.28,7.02 97.28,16.66 98.75,18.13 98.75,18.55 98.95,18.75 98.95,23.31 99.41,23.77 RE296.1 ; RE297.1 15.36,21.41 15.36,19.51 15.78,19.09 17.31,19.09 17.55,18.85 17.55,18.54 19.42,16.67 v1(24.23,16.67) 29.9,16.67 30.24,17 v2(30.24,17.35)
  IN1 w0.064: v7(42.16,12.19) 41.06,12.19 40.41,11.54 36.93,11.54 36.46,12 35.4,12 34.63,12.77 34.63,14.76 34.19,15.2 33.17,15.2 v7(31.71,13.73) ; v2(30.24,17.35) 30.81,17.35 v2(30.83,17.38) 31.29,16.92 32.75,16.92 v2(33.84,18.01) 34.96,18.01 35.38,18.43 38.01,18.43 38.52,18.94 38.83,18.94 39.67,18.1 43.58,18.1 43.7,18.22 43.89,18.22 44.01,18.34 46.61,18.34 47,18.73 54.16,18.73 54.75,18.15 55.5,18.15 56.65,17 59.16,17 61.09,15.07 61.9,15.07 64.4,12.57 67.42,12.57 70.61,9.38 71.32,9.38 71.91,8.79 76.88,8.79 77.58,8.09 78.85,8.09 79.02,7.91 82.62,7.91 83.26,7.28 84.7,7.28 85.06,6.91 94.06,6.91 94.18,6.79 v2(97.51,6.79)
  GND2 w0.102: v5(31.59,13.42) 31.71,13.54 v7(31.71,13.73)
  GND3 w0.102: v5(31.59,13.42) 31.57,13.42 v8(31.33,13.67)
  IN3 w0.064: v3(26.26,27.13) 26.26,27.07 28.22,25.12 28.22,22.79 27.66,22.23 v3(27.66,19.88) 27.66,19.58 28.12,19.11 28.12,17.84 29.94,16.02 29.94,15.33 31.33,13.95 v8(31.33,13.67)
  BOTTOM w0.127: v3(26.26,27.13) 26.44,27.13 26.54,27.23 26.54,28.36 26.36,28.54 UH7.2 ; v3(27.66,19.88) 27.02,19.25 RE299.1
SATA_PRX_DTX_N0B: length 78.8
  IN3 w0.086: v3(95.17,16.5) 95.17,16.49 94.56,16.49 93.93,15.86 89.97,15.86 89.79,16.03 85.08,16.03 84.9,15.86 79.71,15.86 79.59,15.97 76.96,15.97 76.3,16.62 69.99,16.62 69.5,17.11 67.32,17.11 61.76,22.66 61.76,23.05 61.11,23.7 60.77,23.7 53.96,30.51 53.96,30.75 53.05,31.66 53.05,40.49 46.91,46.64 46.91,49.25 46.5,49.66 46.5,51.41 46.25,51.66 45.37,51.66 44.92,52.11 44.92,52.37 v3(44.87,52.43)
  BOTTOM w0.145: JNGFF2.43 97.12,16.12 96.93,15.93 96.72,15.93 96.62,16.03 96.62,16.41 96.47,16.57 96.24,16.57 96.08,16.41 96.08,16.06 95.96,15.93 95.15,15.93 94.84,16.24 94.84,16.39 94.97,16.52 95.15,16.52 v3(95.17,16.5)
SATA_PRX_DTX_P0B: length 78.8
  IN3 w0.086: v3(45.63,52.43) 45.5,52.55 45.34,52.55 45.23,52.45 45.23,52.23 45.49,51.97 46.38,51.97 46.81,51.54 46.81,49.79 47.22,49.38 47.22,46.77 53.36,40.62 53.36,31.79 54.27,30.88 54.27,30.64 60.9,24.01 61.24,24.01 62.07,23.18 62.07,22.79 67.45,17.42 69.63,17.42 70.12,16.93 76.43,16.93 77.08,16.28 79.72,16.28 79.84,16.17 84.77,16.17 84.95,16.34 89.92,16.34 90.1,16.17 93.8,16.17 94.43,16.8 95.1,16.8 v3(95.17,16.88)
  BOTTOM w0.145: v3(95.17,16.88) 95.12,16.82 94.84,16.82 94.75,16.74 94.75,16.74 94.53,16.52 94.53,16.11 95.02,15.62 JNGFF2.41
SATA_PTX_C_DRX_N0B: length 4
  TOP w0.145: v9(95.35,18.12) 95.47,18.25 95.47,18.81 CD69.2
  BOTTOM w0.145: v9(95.35,18.12) 95.45,18.02 95.45,17.63 95.96,17.12 JNGFF2.47
SATA_PTX_C_DRX_P0B: length 4
  TOP w0.145: v9(96.08,18.12) 95.98,18.12 95.78,18.33 95.78,18.47 CD70.2
  BOTTOM w0.145: JNGFF2.49 97.05,17.62 96.86,17.43 96.08,17.43 95.76,17.75 95.76,17.95 95.94,18.12 v9(96.08,18.12)
SATA_PTX_DRX_N0B: length 74.6
  TOP w0.145: CD69.1 95.42,19.84 95.65,20.08 95.65,20.45 v9(95.53,20.57)
  IN3 w0.086: v3(50.27,53.96) 50.31,53.92 50.31,52.3 51.2,51.41 51.2,47.43 56.56,42.07 56.56,33.74 69.33,20.96 77.08,20.96 78.34,19.7 80.55,19.7 81.52,20.68 90.31,20.68 90.85,20.14 94,20.14 94.84,20.98 95.56,20.98 95.67,20.87 95.67,20.71 v9(95.53,20.57)
  BOTTOM w0.089: v3(50.27,53.96) 50.3,53.93 50.3,53.57 49.93,53.2 48.19,53.2 47.94,52.95 47.36,52.95 47.33,52.98 47.28,53.03 46.97,53.03 UH4.C36
SATA_PTX_DRX_P0B: length 74.6
  TOP w0.145: v9(96.12,20.57) 95.96,20.41 95.96,20.09 96.2,19.84 CD70.1
  IN3 w0.086: v9(96.12,20.57) 95.98,20.7 95.98,20.99 95.69,21.29 94.71,21.29 93.87,20.45 90.98,20.45 90.44,20.99 81.4,20.99 80.42,20.01 78.46,20.01 77.21,21.27 69.46,21.27 56.87,33.87 56.87,42.2 51.51,47.56 51.51,51.54 50.62,52.43 50.62,53.92 v3(50.65,53.96)
  BOTTOM w0.089: UH4.B36 47.1,52.75 47.1,52.65 47.19,52.56 47.3,52.56 47.52,52.78 48.02,52.78 48.26,53.02 50,53.02 50.47,53.49 50.47,53.78 v3(50.65,53.96)
SBIOS_TX: length 121.7
  TOP w0.127: v2(69.99,4.65) 69.99,7.36 70.56,7.93 70.56,11.34 73.21,14 73.21,15.64 73.68,16.11 73.68,18.68 v1(74.65,19.64) v2(75.18,20.17)
  IN1 w0.064: v2(69.99,4.65) 69.87,4.53 61.15,4.53 60,5.68 56.02,5.68 55.79,5.91 53.21,5.91 52.76,6.37 51.88,6.37 51.11,5.61 49.56,5.61 48.87,4.91 48.87,3.66 v2(48.23,3.03) ; v2(75.18,20.17) 75.01,20.17 73.9,21.28 70.02,21.28 65.04,26.26 58.08,26.26 57.38,26.97 55.97,26.97 55,27.94 53.91,27.94 53.39,28.45 52.17,28.45 51.09,29.53 47.55,29.53 47.22,29.21 40.92,29.21 37.96,32.17 31.73,32.17 28.49,35.42 27.42,35.42 25.75,37.09 25.75,37.31 24.93,38.12 24.93,41.63 25.31,42.01 25.31,44.15 25.56,44.4 25.56,46.81 26.28,47.53 26.28,48.2 26.07,48.41 26.07,50.63 28.35,52.9 28.35,53.51 28.73,53.9 28.73,54.9 29.38,55.55 v4(29.38,56.29)
  GND2 w0.102: v5(29.45,56.65) 29.38,56.58 v4(29.38,56.29)
  GND3 w0.102: v5(29.45,56.65) 29.49,56.69 v6(29.49,57.03)
  BOTTOM w0.076: UH4.AV44 29.32,56.86 v6(29.49,57.03)
SD_CD#: length 22.8
  TOP w0.127: v2(14.4,69.87) 14.53,69.75 JCR1.9 ; UR1.30 23.09,62.5 v2(23.34,62.25)
  IN1 w0.064: v2(14.4,69.87) 12.62,69.87 11.58,68.83 11.58,65.3 13.17,63.71 14.53,63.71 15.19,64.37 17.88,64.37 18.56,65.06 20.72,65.06 23.34,62.44 v2(23.34,62.25)
SD_CLK: length 3.5
  TOP w0.127: JCR1.5 15.85,65.45 CR10.1 RR3.2
SD_CLK_R: length 3
  TOP w0.127: RR3.1 18.26,67.77 19.02,67.01 19.02,66.71 v1(19.34,66.39) 19.38,66.44 UR1.17
SD_CMD: length 3.4
  IN1 w0.064: v7(17.29,63.33) 17.02,63.6 16.68,63.6 16.6,63.68 16.6,63.91 16.53,63.99 16.42,63.99 16.35,63.91 16.35,63.68 16.27,63.6 16.17,63.6 16.09,63.68 16.09,63.91 16.02,63.99 15.91,63.99 15.84,63.91 15.84,63.68 15.76,63.6 15.47,63.6 15.42,63.65 v7(15.25,63.65)
SD_CMD_R: length 3.6
  TOP w0.127: UR1.19 19.74,65.64 v1(19.21,65.11) 18.72,64.62 18.72,63.84 RR4.1
SD_D2: length 2.1
  IN1 w0.064: v7(15.25,61.85) 15.37,61.72 17.21,61.72 v2(17.29,61.8)
SD_D2_R: length 4.5
  TOP w0.127: UR1.21 19.77,64.84 19.66,64.73 19.64,64.73 19.47,64.56 19.47,62.86 v1(19.15,62.54) 18.41,61.8 RR6.1
SD_D3: length 4.5
  TOP w0.127: JCR1.2 14.78,62.75 v7(14.22,62.19) ; RR5.2 17.01,62.57 16.66,62.22 v7(16.51,62.22)
  IN1 w0.064: v7(16.51,62.22) 14.25,62.22 v7(14.22,62.19)
SD_D3_R: length 4.1
  TOP w0.127: RR5.1 18.39,62.57 19.15,63.33 v1(19.15,63.84) 19.15,64.6 19.79,65.24 UR1.20
SD_LN0_M: length 22.9
  TOP w0.109: v2(21.09,62.28) 21.18,62.37 21.18,62.52 21.09,62.61 UR1.25 ; JCR1.17 2.42,66.03 2.51,65.93 2.51,65.75 2.61,65.66 2.78,65.66 v2(2.88,65.76)
  IN1 w0.061: v2(2.88,65.76) 2.96,65.68 8.81,65.68 13.35,61.14 18.31,61.14 19.19,62.02 21.11,62.02 21.18,62.09 21.18,62.19 v2(21.09,62.28)
SD_LN0_P: length 23
  TOP w0.109: v2(21.49,62.28) UR1.26 ; v2(2.88,65.38) 2.85,65.36 2.4,65.36 2.16,65.12 JCR1.16
  IN1 w0.061: v2(21.49,62.28) 21.41,62.2 21.41,61.99 21.21,61.79 19.28,61.79 18.4,60.91 13.26,60.91 8.71,65.46 2.96,65.46 v2(2.88,65.38)
SD_LN1_M: length 21.6
  TOP w0.109: JCR1.19 2.42,67.85 2.72,68.15 3.05,68.15 v2(3.09,68.11) ; UR1.23 v2(19.76,64.04)
  IN1 w0.061: v2(3.09,68.11) 3.17,68.19 7.57,68.19 12.95,62.8 16.68,62.8 16.73,62.74 18,62.74 19.38,64.12 19.67,64.12 v2(19.76,64.04)
SD_LN1_P: length 21.6
  TOP w0.109: v2(3.09,68.49) 3.05,68.45 2.72,68.45 2.42,68.76 JCR1.20 ; UR1.22 v2(19.76,64.44)
  IN1 w0.061: v2(19.76,64.44) 19.67,64.35 19.28,64.35 17.9,62.97 16.83,62.97 16.77,63.03 13.04,63.03 7.66,68.41 3.17,68.41 v2(3.09,68.49)
SD_RCLK_M: length 3.4
  TOP w0.109: RR1.2 17.07,69.2 16.52,69.2 v2(16.48,69.24)
  IN1 w0.061: v2(15.25,68.15) 15.22,68.12 15.22,67.91 15.27,67.87 15.39,67.87 15.69,68.17 15.69,68.88 16.01,69.2 16.45,69.2 v2(16.48,69.24)
SD_RCLK_M_R: length 4.7
  TOP w0.109: UR1.15 21.49,67.85 21.23,68.1 20.45,68.1 19.26,69.29 18.34,69.29 RR1.1
SD_RCLK_P: length 3.4
  TOP w0.109: v2(16.48,68.86) 16.52,68.9 17.06,68.9 RR2.2
  IN1 w0.061: v2(16.48,68.86) 16.37,68.97 16.1,68.97 15.92,68.79 15.92,68.08 15.25,67.41 v2(15.25,67.25)
SD_RCLK_P_R: length 4.7
  TOP w0.109: RR2.1 18.44,68.43 18.56,68.43 18.67,68.54 18.67,68.87 18.79,68.99 19.13,68.99 20.32,67.8 21.11,67.8 21.19,67.72 21.19,67.6 21.09,67.5 UR1.16
SD_REG2: length 4
  TOP w0.203: UR1.24 20.07,63.64 19.88,63.46 19.88,63.23
  TOP w0.508: 19.88,63.23 19.88,62.4 18.4,60.92 CR13.1
SER_IRQ: length 9.5
  IN3 w0.064: v3(21.78,41.67) 21.9,41.8 23.79,41.8 24.36,42.37 24.86,42.37 25.23,42 25.28,42 25.98,41.31 27.4,41.31 28.22,42.12 28.22,42.98 v3(28.06,43.14)
  BOTTOM w0.076: UH4.BA17 27.79,43.41 v3(28.06,43.14)
  BOTTOM w0.127: v3(21.78,41.67) 21.59,41.48 RH625.1
SHD_CS#: length 4.4
  TOP w0.127: RE177.1 43.56,5.2 v1(44,5.64) 43.98,5.64 43.53,6.09 43.53,8.17 UE3.M5
SIO_EXT_SCI#: length 8.6
  TOP w0.127: v7(22.77,50.25) 23.53,50.25 v1(23.75,50.47)
  GND2 w0.102: v7(22.77,50.25) v5(22.77,49.92)
  GND3 w0.102: v5(22.77,49.92) v8(23.11,49.92)
  IN3 w0.064: v8(23.11,49.92) 25.75,49.92 26.72,48.95 29.05,48.95 29.4,49.29 v3(29.4,49.31)
SIO_EXT_SMI#: length 6.1
  IN3 w0.064: v3(34.99,55.25) 33.94,56.29 v3(33.94,60.92)
SIO_EXT_WAKE#: length 149.7
  TOP w0.127: UE3.M12 49.93,8.21 49.93,7.55 50.92,6.57 50.92,5.3 51.06,5.16 51.06,4.27 51.63,3.7 51.79,3.7 v1(51.98,3.51) v7(51.98,2.37)
  GND2 w0.102: v5(51.47,2.24) 51.85,2.24 v7(51.98,2.37)
  GND3 w0.102: v8(51.47,1.91) v5(51.47,2.24)
  IN3 w0.064: v3(28.84,61.55) 25.4,61.55 24.36,62.59 17.13,62.59 15.62,61.09 3.13,61.09 2.58,60.54 2.58,56.14 5.47,53.25 5.47,47.9 5.14,47.57 5.14,37.81 5.77,37.18 5.77,33.71 5.13,33.08 5.13,27.64 4.1,26.61 4.1,21.67 5.12,20.65 5.12,18.37 3.27,16.52 3.27,10.23 6.72,6.79 10.99,6.79 13.35,9.15 14.27,9.15 18.22,5.2 24.25,5.2 25.6,3.85 30.86,3.85 32.33,2.38 36.49,2.38 37.09,1.78 50.5,1.78 50.62,1.91 v8(51.47,1.91)
  BOTTOM w0.076: UH4.AN44 31.53,56.78 31.53,58.19 31.13,58.59 31.13,58.76
  BOTTOM w0.127: v3(28.84,61.55) 29.09,61.3 29.59,61.3 29.98,60.9 29.98,60.81 30.37,60.42 30.88,60.42 30.91,60.39 30.91,60.39 31.12,60.18 31.13,60.17 31.13,58.76
SIO_PWRBTN#: length 84.8
  TOP w0.127: v9(49.15,9.79) UE3.K11
  IN3 w0.064: v6(29.93,40.99) 29.97,41.03 29.97,41.15 29.58,41.54 29.34,41.54 29.11,41.31 29.11,41.07 28.87,40.83 27.73,40.83 27.69,40.87 26.81,40.87 26.62,40.68 26.62,40.42 23.71,37.52 23.71,35.86 24.03,35.55 24.03,34.51 25.55,32.99 26.31,32.99 26.99,32.31 29.23,32.31 31.42,30.12 31.42,28.64 33.37,26.69 33.37,21.48 33.93,20.93 33.93,19.3 38.04,15.19 40.48,15.19 41.43,14.24 45.69,14.24 46.13,13.79 46.13,13.1 49.15,10.07 v9(49.15,9.79) 49.15,8.57 50.2,7.52 53.43,7.52 54.42,6.53 55.76,6.53 56.72,5.57 59.62,5.57 61.19,4 74.99,4 v9(75.42,3.56)
  BOTTOM w0.076: v6(29.93,40.99) 29.93,40.99 UH4.AT13
  BOTTOM w0.127: v1(75.05,4.14) 75.42,3.77 v9(75.42,3.56) 75.59,3.4 R5862.1
SIO_RCIN#: length 12.4
  TOP w0.127: v7(22.48,43.39) 22.21,43.39 22.13,43.31 20.41,43.31 20.1,43.01 RH167.1 19.88,42.81 v1(20.48,42.22)
  GND2 w0.102: v7(22.48,43.39) 22.45,43.41 v5(22.45,43.72)
  GND3 w0.102: v8(22.78,43.74) 22.48,43.74 v5(22.45,43.72)
  IN3 w0.064: v8(22.78,43.74) 23.69,43.74 24.21,44.27 25.69,44.27 26.19,43.77 29.28,43.77 v3(29.33,43.82)
  BOTTOM w0.076: v3(29.33,43.82) 29.64,43.82 UH4.AT17
SIO_SLP_A#: length 105.1
  TOP w0.127: v7(48.89,6.84) 48.33,7.4 48.33,7.93 48.75,8.35 UE3.M11 ; v1(75.47,9.67) 76.33,8.82 JAPS1.6 76.33,4.94 v2(76.36,4.9)
  IN1 w0.064: v7(48.89,6.84) 48.89,6.47 49.5,5.86 50.07,5.86 50.91,6.7 52.86,6.7 53.51,6.05 56.04,6.05 56.14,5.96 60.2,5.96 61.34,4.81 69.58,4.81 69.83,5.05 72.08,5.05 72.38,5.36 75,5.36 75.58,4.78 76.24,4.78 v2(76.36,4.9)
  GND2 w0.102: v7(48.89,6.84) v5(48.61,7.12)
  GND3 w0.102: v5(48.61,7.12) 48.4,7.12 v8(48.3,7.02)
  IN3 w0.064: v8(48.3,7.02) 48.22,6.94 46.93,6.94 46.06,7.81 46.06,9.14 46.54,9.62 46.54,10.64 44.66,12.52 43.25,12.52 42.92,12.18 42.27,12.18 42.22,12.23 40.05,12.23 39.8,12.48 36.81,12.48 36.01,11.68 35.77,11.68 35.47,11.98 33.67,11.98 32.15,13.5 32.15,14.61 28.68,18.08 28.68,19.34 28.38,19.64 28.38,22.17 29.45,23.23 29.45,25.02 27.58,26.88 27.24,26.88 26.96,27.16 26.96,27.54 24.89,29.61 24.89,29.81 20.04,34.66 20.04,35.16 19.3,35.9 19.3,39.39 18.28,40.41 18.28,41.3 18.58,41.6 18.58,42.41 19.57,43.4 21.49,43.4 22.37,42.53 23.26,42.53 v3(23.44,42.7)
  BOTTOM w0.076: UH4.BC15 26.57,42.3 26.42,42.45 25.27,42.45 24.99,42.73 23.47,42.73 v3(23.44,42.7)
SIO_SLP_S0#: length 225.6
  TOP w0.127: RZ26.1 32.62,29.09 v2(32.06,29.65) ; v2(81.57,24.78) 81.64,24.71 81.64,22.13 81.49,21.98 81.49,20.19 81.12,19.82 v2(81.12,17.71) 81.12,17.04 81.43,16.73 81.43,12.52 80.83,11.91 v1(80.83,11.51) JAPS1.15 ; v2(38.15,28.63) 38.58,28.63 40.72,26.49 DZ1.2 41.93,27.53 v2(41.93,28.17)
  TOP w0.254: v9(137.19,46.82) PR1110.1
  IN1 w0.064: v2(81.12,17.71) 80.83,17.42 76.24,17.42 73.31,20.35 69.58,20.35 64.77,25.16 60.48,25.16 60.25,25.38 57.96,25.38 57.58,25.01 56.21,25.01 54.45,26.76 45.26,26.76 43.85,28.17 v2(41.93,28.17) ; v2(32.06,29.65) 33.38,30.98 37.13,30.98 37.29,30.82 37.29,30.32 37.16,30.19 35.69,30.19 35.38,29.88 35.38,29.06 35.81,28.63 v2(38.15,28.63) ; v2(32.06,29.65) 32.13,29.58 32.13,21.38 30.29,19.54 30.19,19.54 27.62,16.97 26.69,16.97 26.21,16.49 v4(26.21,15.75) ; v2(32.06,29.65) 31.47,30.24 31.47,30.78 29,33.25 27.4,33.25 25.02,35.62 25.02,36.65 24.65,37.02 24.65,43.88 25.28,44.51 25.28,47.45 v4(25.86,48.02) ; v9(137.19,46.82) 137.77,46.25 139.76,46.25 141.06,44.95 142.75,44.95 146.5,41.21 146.5,35.84 144.07,33.41 142.53,33.41 142.34,33.23 142.34,32.68 142.06,32.4 139.15,32.4 136.23,29.47 135.85,29.47 134.69,28.31 130.84,28.31 129.53,27 129.53,21.9 128.29,20.67 125.5,20.67 124.87,21.3 123.38,21.3 123.1,21.58 115.25,21.58 113.62,23.21 113.62,23.77 112.43,24.96 109.24,24.96 108.63,24.34 105.64,24.34 105.27,23.97 104.65,23.97 103.59,22.91 96.52,22.91 95.64,23.78 89.12,23.78 87.23,25.67 85.45,25.67 84.83,25.05 82.1,25.05 81.83,24.78 v2(81.57,24.78)
  GND2 w0.102: v4(26.21,15.75) 26.16,15.8 v5(25.83,15.8) ; v5(26.54,48.22) 26.35,48.02 v4(25.86,48.02)
  GND3 w0.102: v5(25.83,15.8) 26.04,16.02 v6(26.04,16.12) ; v6(26.82,48.02) 26.63,48.22 v5(26.54,48.22)
  IN3 w0.064: v3(26.62,15) 26.04,15.58 v6(26.04,16.12)
  BOTTOM w0.127: v6(26.04,16.12) 25.68,16.12 24.72,17.07 RE17.1 ; RE271.1 29,15.25 28.67,15.58 27.36,15.58 26.79,15 v3(26.62,15)
SIO_SLP_S3#: length 174.6
  TOP w0.127: JAPS1.2 74.33,5.13 v9(74.71,4.74) ; UZ11.2 37.6,29.86 37.51,29.77 37.51,27.97 38.07,27.41 38.07,26.5 37.75,26.18 v7(35.97,26.18) 35.39,26.18 33.8,24.59 33.8,24.59 31.24,22.03 v1(31.24,20.4) 31.24,20.28 31.96,19.56 QE13.2 ; UE3.K9 47.16,10.19 47.43,9.92 47.6,9.92 47.6,9.93 v2(47.59,9.93)
  IN1 w0.064: v7(35.47,87.93) 35.9,88.36 38.16,88.36 39.18,87.34 39.18,83.69 40.06,82.8 40.06,81.54 39.95,81.42 39.95,74.76 39.65,74.46 39.65,71.97 38.73,71.06 38.73,68.47 38.57,68.3 38.57,63.92 36.84,62.19 33.84,62.19 33.66,62.01 26.58,62.01 21.79,57.22 21.79,55.36 20.26,53.83 20.26,51.46 19.56,50.76 19.56,49.03 20.01,48.58 20.01,47.64 19.76,47.38 19.76,42.96 v4(19.78,42.93) ; v4(51.48,10.32) 50.85,10.32 50.21,10.95 49.06,10.95 48.9,10.79 48.41,10.79 48.28,10.65 48.28,10.44 47.76,9.93 v2(47.59,9.93)
  GND2 w0.102: v4(51.48,10.32) v5(51.84,10.32) ; v7(35.97,26.18) 35.86,26.18 v5(35.66,26.38) ; v4(19.78,42.93) 19.71,42.86 v5(19.71,42.58)
  GND3 w0.102: v5(19.71,42.58) 19.71,42.27 v8(19.73,42.25) ; v5(51.84,10.32) 51.59,10.32 v8(51.48,10.43) ; v8(35.32,26.63) 35.56,26.38 v5(35.66,26.38)
  IN3 w0.064: v9(74.71,4.74) 74.49,4.52 61.43,4.52 59.86,6.09 56.94,6.09 55.53,7.49 54.42,7.49 v8(51.48,10.43) 50.12,11.79 50.12,14.88 49.24,15.77 48.64,15.77 48.22,16.19 48.1,16.19 46.63,17.66 38.13,17.66 35.91,19.88 35.91,21.81 35.4,22.33 35.4,26.54 v8(35.32,26.63) 35.32,28.8 33.31,30.8 33.31,32.65 30.08,35.88 30.08,39.66 30.32,39.9 30.32,41.02 29.56,41.79 29.03,41.79 v6(28.56,42.26) 27.46,41.17 25.71,41.17 25.11,41.77 24.73,41.77 24.58,41.92 24.1,41.92 23.85,41.66 22.21,41.66 21.95,41.41 20.85,41.41 20.39,41.87 19.96,41.87 19.73,42.09 v8(19.73,42.25)
