# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMI_CRX_PTX_N1: length 82.8
  IN1 w0.061: v6(94.31,81.86) 94.31,82.05 94.25,82.11 93.95,82.11 93.78,81.94 93.63,81.94 93.55,81.86 93.54,81.86
  IN1 w0.086: 93.54,81.86 92.94,81.86 91.24,83.56 91.24,86.36 90.71,86.89 90.15,86.89 88.9,88.14 74.44,88.14 71.88,85.58 71.88,83.15 66.8,78.06 63.5,78.06 62.96,77.52 62.96,76.73 50.45,64.22 50.45,52.91 52,51.36 52,49.5 50.97,48.46 50.48,48.46 v4(50.36,48.35)
  GND2 w0.102: v5(93.98,81.92) 94.04,81.86 v6(94.31,81.86) ; v5(50.69,48.35) v4(50.36,48.35)
  GND3 w0.102: v6(50.36,48.32) 50.66,48.32 v5(50.69,48.35) ; v6(94.31,81.86) 94.04,81.86 v5(93.98,81.92)
  BOTTOM w0.076: UH4.B28 47.14,48.6 47.53,48.31 47.56,48.28 50.08,48.28 50.23,48.43 50.29,48.43 50.36,48.36 v6(50.36,48.32)
DMI_CRX_PTX_N2: length 85.9
  IN1 w0.061: v6(95.2,79.91) 95.2,79.72 95.13,79.66 93.63,79.66 93.55,79.74 93.54,79.74
  IN1 w0.086: v4(53.49,50.46) 53.6,50.35 53.81,50.35 53.92,50.45 53.92,51.09 51.81,53.2 51.81,63.94 61.98,74.11 68.07,74.11 68.61,73.57 69.68,73.57 70.79,74.68 70.79,79.47 74.65,83.33 74.65,84.98 76.69,87.02 87.94,87.02 89.65,85.31 89.65,84.35 89.56,84.26 89.56,82.8 91.18,81.18 91.46,81.18 92.91,79.74 93.54,79.74
  GND2 w0.102: v5(53.14,50.44) 53.16,50.46 v4(53.49,50.46) ; v6(95.2,79.91) v5(94.84,79.91)
  GND3 w0.102: v5(94.84,79.91) v6(95.2,79.91) ; v5(53.14,50.44) 53.21,50.37 v6(53.54,50.37)
  BOTTOM w0.076: UH4.B29 46.99,49.36 46.99,49.49 47.06,49.56 47.16,49.56 47.48,49.24 48.72,49.24 48.99,49.51 51.34,49.51 51.42,49.59
  BOTTOM w0.145: v6(53.54,50.37) 53.49,50.32 52.96,50.32 52.22,49.59 v10(51.85,49.59) 51.42,49.59
DMI_CRX_PTX_N3: length 83.6
  IN1 w0.061: v6(95.2,81.21) 95.2,81.46 95.13,81.52 94.93,81.52 94.7,81.75 94.7,82.52 94.28,82.93 93.8,82.93 93.66,83.08 93.55,83.08 93.54,83.09
  IN1 w0.086: 93.54,83.09 92.12,84.51 92.12,86.52 91.05,87.59 90.44,87.59 89.19,88.84 89.15,88.84 89.14,88.84 84.22,88.84 83.43,89.64 81.18,89.64 80.38,88.84 74.15,88.84 71.05,85.73 71.05,83.37 66.47,78.8 63.21,78.8 62.07,77.66 62.07,76.85 49.75,64.54 49.75,52.56 51.15,51.16 51.15,50.65 50.76,50.27 50.48,50.27 v4(50.44,50.22)
  GND2 w0.102: v5(95.53,81.21) v6(95.2,81.21) ; v4(50.44,50.22) 50.69,50.22 v5(50.77,50.15)
  GND3 w0.102: v5(50.77,50.15) 50.72,50.09 v6(50.44,50.09) ; v6(95.2,81.21) v5(95.53,81.21)
  BOTTOM w0.076: UH4.B30 47.31,49.72 47.52,49.51 48.41,49.51 49.11,50.21 50.33,50.21 v6(50.44,50.09)
DMI_CRX_PTX_P0: length 86.6
  IN1 w0.076: v6(94.28,79.91) 94.51,79.91 94.62,80.03 94.62,80.2 94.53,80.29 93.99,80.29 93.65,80.63 93.55,80.63 93.54,80.65
  IN1 w0.086: v4(53.46,48.81) 53.51,48.71 53.51,48.64 53.45,48.59 53.2,48.59 52.76,49.03 52.76,51.64 51.41,52.99 51.41,64.11 61.81,74.52 67.83,74.52 70.17,76.86 70.17,79.52 74.17,83.52 74.17,85.65 75.94,87.42 88.63,87.42 90.35,85.7 90.35,82.59 91.05,81.89 91.6,81.89 92.57,80.92 93.26,80.92 93.54,80.65
  GND2 w0.102: v5(93.95,79.94) 94.25,79.94 v6(94.28,79.91) ; v4(53.46,48.81) 53.43,48.77 v5(53.13,48.77)
  GND3 w0.102: v5(93.95,79.94) 94.25,79.94 v6(94.28,79.91) ; v6(53.46,48.67) 53.23,48.67 v5(53.13,48.77)
  BOTTOM w0.076: UH4.B27 47.02,48.25 46.95,48.17 46.95,48.07 47.02,48 49.51,48 49.73,47.78 50.86,47.78 50.94,47.86
  BOTTOM w0.145: 50.94,47.86 v10(51.85,47.86) 52.2,47.86 52.96,48.61 53.4,48.61 v6(53.46,48.67)
DMI_CRX_PTX_P1: length 82.7
  IN1 w0.061: 93.54,82.17 93.55,82.17 93.63,82.09 93.72,82.09 93.89,82.26 94.25,82.26 94.31,82.32 v6(94.31,82.51)
  IN1 w0.086: v4(50.36,48.88) 50.47,48.77 50.84,48.77 51.69,49.63 51.69,51.23 50.14,52.78 50.14,64.35 62.65,76.86 62.65,77.65 63.37,78.37 66.67,78.37 71.57,83.27 71.57,85.71 74.31,88.45 89.03,88.45 90.28,87.2 90.84,87.2 91.55,86.49 91.55,83.69 93.07,82.17 93.54,82.17
  GND2 w0.102: v5(50.69,48.88) v4(50.36,48.88) ; v6(94.31,82.51) v5(93.95,82.51)
  GND3 w0.102: v6(50.36,48.88) 50.69,48.88 v5(50.69,48.88) ; v6(94.31,82.51) v5(93.95,82.51)
  BOTTOM w0.076: UH4.A28 47.56,48.5 47.63,48.45 50.01,48.45 50.16,48.6 50.47,48.6 50.56,48.69 50.56,48.8 50.49,48.88 v6(50.36,48.88)
DMI_CRX_PTX_P2: length 85.9
  IN1 w0.061: 93.54,79.43 93.55,79.43 93.63,79.51 95.13,79.51 95.2,79.45 v6(95.2,79.26)
  IN1 w0.086: v4(53.49,49.93) 53.6,50.04 53.95,50.04 54.23,50.32 54.23,51.22 52.12,53.33 52.12,63.82 62.11,73.8 67.94,73.8 68.48,73.26 69.81,73.26 71.1,74.55 71.1,79.34 74.96,83.2 74.96,84.86 76.81,86.71 87.81,86.71 89.34,85.19 89.34,84.47 89.25,84.38 89.25,82.68 89.34,82.59 89.34,82.59 91.05,80.87 91.33,80.87 92.78,79.43 93.54,79.43
  GND2 w0.102: v6(95.2,79.26) v5(94.84,79.26) ; v4(53.49,49.93) 53.16,49.93 v5(53.14,49.91)
  GND3 w0.102: v6(53.54,49.99) 53.22,49.99 v5(53.14,49.91) ; v6(95.2,79.26) v5(94.84,79.26)
  BOTTOM w0.076: UH4.C29 46.88,49.07 47.03,48.99 47.34,48.99 47.43,49.08 48.79,49.08 49.06,49.35 51.34,49.35 51.41,49.28 51.47,49.28
  BOTTOM w0.145: v6(53.54,49.99) 53.52,50.01 53.09,50.01 52.35,49.28 51.47,49.28
DMI_CRX_PTX_P3: length 83.7
  IN1 w0.061: v6(95.22,81.86) 95.22,81.74 95.15,81.67 95,81.67 94.85,81.82 94.85,82.58 94.34,83.08 93.87,83.08 93.77,83.18 93.77,83.3 93.76,83.31
  IN1 w0.086: v4(50.42,50.63) 50.44,50.6 50.45,50.6 50.47,50.58 50.64,50.58 50.84,50.78 50.84,51.03 49.44,52.44 49.44,64.66 61.76,76.98 61.76,77.79 63.08,79.11 66.34,79.11 70.74,83.5 70.74,85.86 74.02,89.15 80.25,89.15 81.05,89.95 83.56,89.95 84.35,89.15 89.27,89.15 89.27,89.15 89.32,89.15 90.57,87.9 91.17,87.9 92.43,86.65 92.43,84.64 93.76,83.31
  GND2 w0.102: v5(95.58,81.82) 95.54,81.86 v6(95.22,81.86) ; v5(50.77,50.68) 50.69,50.6 50.44,50.6 v4(50.42,50.63)
  GND3 w0.102: v6(95.22,81.86) 95.54,81.86 v5(95.58,81.82) ; v5(50.77,50.68) 50.75,50.7 v6(50.44,50.7)
  BOTTOM w0.076: UH4.A30 47.52,49.74 47.59,49.68 48.35,49.68 49.04,50.37 50.47,50.37 50.57,50.48 50.57,50.62 50.49,50.7 v6(50.44,50.7)
DMI_CTX_PRX_N0: length 89.2
  IN1 w0.061: v6(96.57,84.47) 96.57,84.28 96.51,84.22 95.41,84.22 95.16,84.47 95.16,85.21 94.31,86.05 94.31,86.65 94.23,86.73 93.77,87.2 93.77,87.31 93.76,87.32
  IN1 w0.086: 93.76,87.32 90.51,90.57 85.44,90.57 84.51,91.5 80.11,91.5 79.18,90.57 73.45,90.57 68.8,85.92 68.8,83.63 66.27,81.09 63,81.09 60.05,78.14 60.05,77.28 48.04,65.27 48.04,50.49 46.76,49.21 46.76,48.48 46.12,47.83 43.94,47.83 43.38,47.27 42.85,47.27 42.72,47.41 42.72,47.58 42.8,47.66 v4(43.07,47.66)
  GND2 w0.102: v6(96.57,84.47) v5(96.92,84.47) ; v4(43.07,47.66) v5(42.83,47.9)
  GND3 w0.102: v6(42.6,48.13) v5(42.83,47.9) ; v6(96.57,84.47) v5(96.92,84.47)
DMI_CTX_PRX_N1: length 85.4
  IN1 w0.061: v6(95.68,83.17) 95.68,83.36 95.54,83.5 94.98,83.5 94.06,84.42 94.06,84.7 93.66,85.11 93.55,85.11 93.54,85.12
  IN1 w0.086: 93.54,85.12 93.13,85.52 93.13,86.51 91.16,88.47 90.59,88.47 89.51,89.55 84.82,89.55 83.97,90.4 80.51,90.4 79.65,89.55 73.86,89.55 70.33,86.02 70.33,83.68 66.73,80.07 63.43,80.07 61.1,77.74 61.1,76.9 49.05,64.85 49.05,49.99 47.8,48.75 47.8,48.07 46.56,46.82 45.3,46.82 45.24,46.76 45.24,46.56 45.32,46.48 45.58,46.48 v4(45.65,46.55)
  GND2 w0.102: v6(95.68,83.17) v5(95.35,83.17) ; v4(45.65,46.55) v5(45.41,46.79)
  GND3 w0.102: v6(95.68,83.17) v5(95.35,83.17) ; v6(45.65,47.03) v5(45.41,46.79)
DMI_CTX_PRX_N2: length 85.3
  IN1 w0.061: 93.54,88.35 93.56,88.32 93.68,88.32 94.86,87.14 94.86,85.91 95.48,85.3 95.62,85.3 95.68,85.24 v6(95.68,85.12)
  IN1 w0.086: v4(44.98,48.82) 44.98,48.5 45.25,48.23 45.9,48.23 46.35,48.68 46.35,49.38 47.65,50.68 47.65,65.46 54.49,72.3 54.49,72.56 55.7,73.77 55.95,73.77 59.64,77.45 59.64,78.28 62.84,81.48 66.03,81.48 68.41,83.86 68.41,86.09 73.4,91.09 78.83,91.09 79.7,91.95 85.14,91.95 85.87,91.22 90.67,91.22 93.54,88.35
  GND2 w0.102: v4(44.98,48.82) 44.98,48.52 v5(44.93,48.47) ; v6(95.68,85.12) 96.01,85.12 v5(96.03,85.15)
  GND3 w0.102: v6(95.68,85.12) 95.71,85.15 v5(96.03,85.15) ; v5(44.93,48.47) 44.88,48.42 v6(44.88,48.13)
DMI_CTX_PRX_N3: length 88.9
  IN1 w0.061: 94.49,88.62 94.5,88.61 94.62,88.61 94.8,88.43 94.8,88.06 96.02,86.83 96.02,86.31 96.36,85.97 96.51,85.97 96.57,85.91 v6(96.57,85.77)
  IN1 w0.086: v4(42.6,49.31) 42.69,49.22 42.69,48.89 42.96,48.62 44.26,48.62 46.95,51.3 46.95,65.75 53.79,72.59 53.79,72.85 55.54,74.6 55.78,74.6 58.77,77.59 58.77,78.41 62.55,82.19 65.27,82.19 67.71,84.63 67.71,86.39 73.12,91.8 75.77,91.8 78.03,94.06 82.54,94.06 83.41,93.19 84.99,93.19 86.23,91.95 91.17,91.95 94.49,88.62
  GND2 w0.102: v4(42.6,49.31) v5(42.36,49.55) ; v5(96.92,85.86) 96.66,85.86 v6(96.57,85.77)
  GND3 w0.102: v5(42.36,49.55) v6(42.6,49.31) ; v6(96.57,85.77) 96.84,85.77 v5(96.92,85.86)
DMI_CTX_PRX_P0: length 89.2
  IN1 w0.061: 93.54,87.1 93.55,87.09 93.66,87.09 94.16,86.59 94.16,85.99 95.01,85.15 95.01,84.41 95.34,84.07 96.32,84.07 v6(96.57,83.82)
  IN1 w0.086: 93.54,87.1 90.38,90.26 85.31,90.26 84.38,91.19 80.24,91.19 79.31,90.26 73.57,90.26 69.11,85.8 69.11,83.5 66.4,80.78 63.13,80.78 60.36,78.01 60.36,77.16 48.35,65.15 48.35,50.36 47.07,49.08 47.07,48.35 46.24,47.52 44.07,47.52 43.51,46.96 42.73,46.96 42.41,47.28 42.41,47.56 v4(42.31,47.66)
  GND2 w0.102: v5(96.9,83.88) 96.63,83.88 v6(96.57,83.82) ; v4(42.31,47.66) v5(42.07,47.9)
  GND3 w0.102: v5(96.9,83.88) 96.84,83.82 v6(96.57,83.82) ; v6(41.84,48.13) v5(42.07,47.9)
DMI_CTX_PRX_P1: length 85.4
  IN1 w0.061: 93.76,85.34 93.77,85.33 93.77,85.21 94.21,84.77 94.21,84.48 95.04,83.65 95.51,83.65 v6(95.68,83.82)
  IN1 w0.086: v4(44.89,46.55) 44.93,46.59 44.93,46.89 45.17,47.13 46.43,47.13 47.49,48.2 47.49,48.88 48.74,50.12 48.74,64.98 60.79,77.03 60.79,77.87 63.3,80.38 66.6,80.38 70.02,83.81 70.02,86.15 73.73,89.86 79.52,89.86 80.38,90.71 84.1,90.71 84.95,89.86 89.64,89.86 90.71,88.78 91.29,88.78 93.44,86.64 93.44,85.65 93.76,85.34
  GND2 w0.102: v6(95.68,83.82) v5(95.35,83.82) ; v4(44.89,46.55) v5(44.65,46.79)
  GND3 w0.102: v6(44.88,47.03) v5(44.65,46.79) ; v6(95.68,83.82) v5(95.35,83.82)
DMI_CTX_PRX_P2: length 85.4
  IN1 w0.061: v6(95.68,85.77) 95.68,85.5 95.62,85.45 95.54,85.45 95.01,85.97 95.01,87.2 93.78,88.43 93.78,88.54 93.77,88.55
  IN1 w0.086: 93.77,88.55 90.8,91.53 86,91.53 85.26,92.26 79.57,92.26 78.7,91.4 73.27,91.4 68.1,86.22 68.1,83.99 65.9,81.79 62.71,81.79 59.33,78.41 59.33,77.58 55.82,74.08 55.57,74.08 54.18,72.69 54.18,72.43 47.34,65.59 47.34,50.81 46.04,49.51 46.04,48.81 45.77,48.54 45.38,48.54 45.29,48.63 45.29,48.75 45.37,48.82 v4(45.51,48.82)
  GND2 w0.102: v6(95.68,85.77) v5(96.06,85.77) ; v4(45.51,48.82) 45.51,48.52 v5(45.46,48.47)
  GND3 w0.102: v6(45.6,48.08) 45.6,48.34 v5(45.46,48.47) ; v5(96.06,85.77) v6(95.68,85.77)
DMI_CTX_PRX_P3: length 88.8
  IN1 w0.061: 94.71,88.84 94.72,88.83 94.72,88.72 94.95,88.5 94.95,88.12 96.17,86.9 96.17,86.37 96.42,86.12 96.51,86.12 96.57,86.18 v6(96.57,86.42)
  IN1 w0.086: v4(43.37,49.31) 43.12,49.31 43,49.19 43,49.02 43.09,48.93 44.13,48.93 46.64,51.43 46.64,65.88 53.48,72.72 53.48,72.98 55.41,74.91 55.65,74.91 58.46,77.72 58.46,78.54 62.42,82.49 65.14,82.49 67.4,84.76 67.4,86.52 72.99,92.11 75.64,92.11 77.9,94.37 82.67,94.37 83.54,93.5 85.12,93.5 86.36,92.26 91.3,92.26 94.71,88.84
  GND2 w0.102: v5(96.92,86.42) v6(96.57,86.42) ; v4(43.37,49.31) v5(43.13,49.55)
  GND3 w0.102: v6(43.36,49.31) v5(43.13,49.55) ; v5(96.92,86.42) v6(96.57,86.42)
DPHUB_SMBCLK: length 85.2
  TOP w0.089: UE3.F7 45.18,13.76 45.18,16.66 44.93,16.91 44.69,16.91 44.43,17.16 44.43,18.1 44.1,18.43 43.91,18.43 v2(43.72,18.62)
  TOP w0.127: v2(40.29,18.69) 39.61,19.37 39.13,19.37 38.49,20.01 38.49,20.02 RE228.1
  IN1 w0.064: v4(108.3,10.89) 108.06,11.13 107.58,11.13 107.34,10.89 106.49,10.89 104.36,8.76 101.16,8.76 99.58,7.19 85.18,7.19 84.81,7.56 83.37,7.56 82.06,8.86 77.2,8.86 77,9.07 74.65,9.07 73.87,9.85 70.54,9.85 70.4,9.99 67.53,12.85 64.52,12.85 62.02,15.35 61.21,15.35 59.28,17.28 56.77,17.28 55.62,18.43 55.45,18.43 54.87,19.01 46.88,19.01 46.49,18.62 v2(43.72,18.62) 43.28,18.62 43.09,18.43 40.55,18.43 v2(40.29,18.69)
  GND2 w0.102: v5(108.67,10.77) 108.64,10.73 108.46,10.73 v4(108.3,10.89)
  GND3 w0.102: v6(109.06,10.9) 108.81,10.9 v5(108.67,10.77)
DPHUB_SMBDAT: length 82.2
  TOP w0.089: UE3.B6 44.26,17.09 44.26,17.9 44.04,18.12
  TOP w0.127: RE227.1 38.24,19.89 v1(39.07,19.06) 39.46,18.67 v2(39.79,18.67) ; 44.04,18.12 43.72,18.12 43.47,18.37 v2(43.47,18.36)
  IN1 w0.064: v2(39.79,18.67) 40.2,18.26 43.35,18.26 43.47,18.37 v2(43.47,18.36) 43.83,18.36 43.95,18.48 46.55,18.48 46.94,18.87 54.22,18.87 54.8,18.29 55.56,18.29 56.71,17.14 59.22,17.14 61.15,15.21 61.96,15.21 64.46,12.71 67.48,12.71 70.67,9.52 71.37,9.52 71.97,8.93 76.94,8.93 77.14,8.72 82.01,8.72 83.31,7.42 84.75,7.42 85.12,7.05 99.64,7.05 101.21,8.62 104.42,8.62 106.55,10.75 107.4,10.75 107.64,10.99 107.83,10.99 108.2,10.62 108.41,10.62 108.65,10.86 v4(108.65,11.2)
  GND2 w0.102: v4(108.65,11.2) 108.79,11.2 v5(109,11.41)
  GND3 w0.102: v5(109,11.41) 109.06,11.47 v6(109.06,11.9)
DPMST_LANE: length 65
  IN1 w0.064: v2(47.95,7.79) 47.95,7.85 48.89,8.79 49.49,8.79 49.62,8.67 50.74,8.67 52.02,7.38 55.7,7.38 56.39,6.7 61.05,6.7 62.52,5.23 68.68,5.23 69.04,5.59 72.02,5.59 72.21,5.78 76.13,5.78 76.49,5.42 77.72,5.42 78.01,5.13 79.66,5.13 80.15,4.64 83.21,4.64 83.53,4.97 v4(84.81,4.97)
  GND2 w0.102: v5(84.96,5.4) 84.82,5.27 84.82,4.98 v4(84.81,4.97)
  GND3 w0.102: v5(84.96,5.4) 85.26,5.7 v8(85.32,5.7)
  IN3 w0.064: v3(107.58,9.12) 107.24,9.12 105.54,7.42 104.65,7.42 103.67,6.44 103.02,6.44 102.28,5.7 93.49,5.7 93.27,5.92 90.41,5.92 90.2,5.7 v8(85.32,5.7)
  BOTTOM w0.127: v3(107.58,9.12) 107.8,8.9 JIO1.N7
DPSNK_RBIAS: length 0.8
  GND2 w0.102: v7(41.75,78.61) 41.72,78.61 v5(41.45,78.34)
  GND3 w0.102: v6(41.75,78.62) 41.73,78.62 v5(41.45,78.34)
DPSRC_RBIAS: length 2.1
  TOP w0.152: RT9.2 38.71,85.48 38.25,85.01 38.25,84.88 v7(38.23,84.87)
  GND2 w0.152: v7(38.23,84.87) 38.29,84.81 38.29,84.53 v5(38.29,84.52)
  GND3 w0.152: v6(38.24,84.18) 38.29,84.23 v5(38.29,84.52)
  BOTTOM w0.152: UT2.N6 38.5,83.92 v6(38.24,84.18)
DRVON: length 81.8
  TOP w0.203: v7(62.95,34.05) 62.58,34.05 61.1,35.53 PU1800.32
  TOP w0.254: v7(62.56,49.35) 62.29,49.08 v1(62.2,49.08) 61.26,49.08 60.74,49.6 58.59,49.6 PR2250.1
  GND2 w0.254: v5(62.58,48.98) 62.56,49 v7(62.56,49.35) ; v5(63.28,34.05) v7(62.95,34.05)
  IN2 w0.254: v5(62.58,48.98) 62.56,48.95 62.56,43.44 63.28,42.72 v5(63.28,34.05) 63.28,33.9 66.68,30.5 75.4,30.5 75.59,30.69 ; 92.57,31.79 91.94,31.16 84.16,31.16 ; 92.57,31.79 94.37,31.79 94.89,32.31 98.98,32.31 100.16,33.5 v9(100.16,34.99) ; 92.57,31.79 92.57,32.9 91.3,34.17 v9(91.3,34.87) ; 84.16,31.16 84.16,32.48 82.56,34.08 v9(82.56,34.92) ; 84.16,31.16 83.5,30.5 75.78,30.5 75.59,30.69 ; v9(73.95,34.82) 73.95,34.07 75.59,32.43 75.59,30.69
  BOTTOM w0.254: v9(91.3,34.87) 91.14,35.03 PU1900.16 ; PU1901.16 73.73,35.04 v9(73.95,34.82) ; PU2000.16 82.43,35.05 v9(82.56,34.92) ; v9(100.16,34.99) 100.12,35.04 PU2201.16
EDP_1: length 4
  TOP w0.127: v7(53.59,95.13) 53.65,95.19 53.65,95.85 RR17.2 53.5,95.97 52.85,96.62 51.68,96.62 v1(51.66,96.6)
  GND2 w0.102: v7(53.59,95.13) 53.59,95.12 53.59,94.75 v5(53.48,94.65)
  GND3 w0.102: v5(53.48,94.65) 53.48,94.64 53.48,94.31 v6(53.41,94.24)
EDP_2: length 2.2
  TOP w0.127: v1(54.07,94.79) 54.07,95.03 v7(53.95,95.15) 53.95,95.41 54.11,95.57 RR16.2
  GND2 w0.102: v7(53.95,95.15) 53.94,95.15 53.94,94.72 v5(53.99,94.67)
  GND3 w0.102: v6(53.91,94.24) 53.98,94.31 53.98,94.66 v5(53.99,94.67)
EDP_3: length 3.4
  TOP w0.127: v1(55.15,94) 55.09,93.93 v7(54.53,93.93) 54.52,93.94 54.52,95.71 RR15.2
  GND2 w0.102: v7(54.53,93.93) 54.21,93.93 v5(54.2,93.92)
  GND3 w0.102: v5(54.2,93.92) 54.2,94.03 v6(54.41,94.24)
EDP_AUXN: length 51.9
  GND2 w0.102: v5(51.56,95.87) 51.56,95.7 v7(51.72,95.54)
  GND3 w0.102: v8(51.46,96.22) 51.46,95.97 v5(51.56,95.87)
  IN3 w0.061: v3(75.27,64.78) 75.27,64.56 75.38,64.45 75.53,64.45 75.66,64.58 75.66,65.15 75.52,65.29 75.52,65.7 75.26,65.96 75.26,67 75.34,67.07 75.34,67.94 74.77,68.5 74.66,68.5 74.65,68.51
  IN3 w0.086: 74.65,68.51 73.09,70.07 73.09,82.89 71.8,84.18 71.8,89.21 67.78,93.23 67.78,93.73 66.25,95.26 64.22,95.26 63.41,96.07 56.82,96.07 56.26,96.63 51.63,96.63 51.41,96.4 51.41,96.27 v8(51.46,96.22)
EDP_AUXN_C: length 0.9
  TOP w0.145: RV797.1 CV243.2
EDP_AUXN_R: length 2.6
  GND2 w0.102: v7(51.72,92.84) 51.72,92.65 v5(51.53,92.46)
  GND3 w0.102: v5(51.53,92.46) 51.46,92.54 v8(51.46,92.82)
  IN3 w0.086: v3(50.91,94.24) 50.81,94.14 50.81,93.92 51.43,93.3 51.43,92.84 v8(51.46,92.82)
EDP_AUXP: length 51.9
  GND2 w0.102: v7(50.83,95.54) 51.03,95.73 v5(51.03,95.87)
  GND3 w0.102: v5(51.03,95.87) 51.08,95.92 v8(51.08,96.22)
  IN3 w0.061: v3(75.92,64.78) 75.81,64.89 75.81,65.21 75.67,65.35 75.67,65.76 75.41,66.02 75.41,66.93 75.49,67.01 75.49,68 74.87,68.62 74.87,68.73
  IN3 w0.086: 74.87,68.73 73.4,70.2 73.4,83.02 72.11,84.31 72.11,89.34 68.09,93.36 68.09,93.86 66.38,95.57 64.35,95.57 63.54,96.38 56.94,96.38 56.39,96.94 51.51,96.94 51.1,96.53 51.1,96.24 v8(51.08,96.22)
EDP_AUXP_C: length 0.9
  TOP w0.145: RV800.1 CV244.2
EDP_AUXP_R: length 2.6
  GND2 w0.102: v5(51,92.46) 50.83,92.63 v7(50.83,92.84)
  GND3 w0.102: v8(51.08,92.82) 51.08,92.54 v5(51,92.46)
  IN3 w0.086: v3(50.41,94.24) 50.5,94.15 50.5,93.79 51.12,93.17 51.12,92.86 v8(51.08,92.82)
EDP_COMP: length 9.5
  TOP w0.127: RH37.1 82.29,62.49 83.03,61.75 83.03,59.72 v1(81.21,57.91) 80.92,57.61 v7(78.46,57.61)
  GND2 w0.127: v5(78.09,57.7) 78.34,57.7 78.43,57.61 v7(78.46,57.61)
  GND3 w0.127: v6(77.84,57.94) 77.85,57.94 v5(78.09,57.7)
EDP_DISP_UTIL: length 5.5
  BOTTOM w0.127: UC1.C43 77.45,58.2 77.45,57.16 77.76,56.85 77.76,56.29 77.35,55.88 RH36.1
EDP_HPD: length 80
  TOP w0.127: v2(57.45,97.31) 57.45,97.39 58.07,98.01 RV798.1 ; v7(25.74,38.47) 25.59,38.32 RH620.1
  IN1 w0.064: v2(57.45,97.31) 55.97,97.31 55.39,96.73 53.3,96.73 50.4,93.83 49.26,93.83 48.43,93 48.43,92.08 45.94,89.59 45.94,84.88 45.8,84.74 45.8,84.74 45.66,84.6 45.66,71.97 42.75,69.06 42.75,64.3 40.94,62.5 40.94,61.98 37.6,58.63 37.31,58.63 33.63,54.95 32.71,54.95 31.12,53.35 31.12,52.83 30.94,52.65 30.21,52.65 29.08,51.52 28.52,51.52 28.44,51.44 28.44,49.49 27.54,48.59 27.54,43.76 26.73,42.95 26.73,41.68 25.61,40.56 25.61,38.6 v7(25.74,38.47)
  GND2 w0.102: v5(26.06,38.16) v7(25.74,38.47)
  GND3 w0.102: v5(26.06,38.16) 26.05,38.15 25.66,38.15 v6(25.63,38.18)
  BOTTOM w0.089: v6(25.63,38.18) 25.68,38.18 25.7,38.21 26.19,38.21 UH4.BD7
EDP_HPD_S: length 4
  TOP w0.127: RV798.2 58.15,96.14 v1(58.45,95.84) 58.45,95.65 59.01,95.09 v7(59.01,94.51)
  GND2 w0.102: v5(59.51,94.24) 59.24,94.51 v7(59.01,94.51)
  GND3 w0.102: v6(59.91,94.24) v5(59.51,94.24)
EDP_TXN0: length 56.3
  GND2 w0.102: v5(49.02,95.94) 49.06,95.9 v7(49.06,95.54)
  GND3 w0.102: v8(49.32,96.07) 49.15,96.07 v5(49.02,95.94)
  IN3 w0.086: v8(49.32,96.07) 49.28,96.07 49.17,95.96 49.17,95.87 49.25,95.79 49.35,95.79 49.4,95.74 49.4,95.6 49.68,95.33 63.13,95.33 63.89,94.56 65.91,94.56 67.07,93.4 67.07,92.89 71.06,88.9 71.06,83.93 72.36,82.63 72.36,69.2 74.19,67.37 74.19,67.04 74.6,66.63 74.6,65.33 74.09,64.83 v3(74.01,64.83)
  BOTTOM w0.076: UC1.B37 76.05,62.55 76.05,62.62 75.94,62.73 74.79,62.73 74.64,62.88 74.53,62.88 74.52,62.9
  BOTTOM w0.145: v3(74.01,64.83) 74.01,64.76 73.72,64.47 73.72,63.7 74.52,62.9
EDP_TXN0_C: length 0.9
  TOP w0.145: RV790.1 CV234.2
EDP_TXN0_R: length 2.4
  GND2 w0.102: v7(49.06,92.84) 49.06,92.65 v5(49.22,92.49)
  GND3 w0.102: v8(49.3,92.82) 49.3,92.56 v5(49.22,92.49)
  IN3 w0.086: v3(48.91,94.24) 49,94.15 49,93.67 49.34,93.32 49.34,92.9 49.31,92.87 49.31,92.83 v8(49.3,92.82)
EDP_TXN1: length 60.1
  GND2 w0.102: v7(47.28,95.54) 47.32,95.57 v5(47.32,95.87)
  GND3 w0.102: v8(47.55,96.2) 47.32,95.97 v5(47.32,95.87)
  IN3 w0.061: v3(77.22,63.21) 77.47,63.46 77.47,64.15 76.61,65.02 76.61,65.61 76.3,65.92 76.3,68.84 75.63,69.51 75.52,69.51 75.5,69.52
  IN3 w0.086: v8(47.55,96.2) 47.58,96.16 47.58,95.65 47.9,95.33 48.41,95.33 48.76,95.69 48.76,96.58 49.55,97.36 65.32,97.36 68.5,94.19 68.5,93.56 73.91,88.15 73.91,70.75 74.95,69.7 75.32,69.7 75.5,69.52
EDP_TXN1_C: length 0.9
  TOP w0.145: RV792.1 CV238.2
EDP_TXN1_R: length 2.3
  GND2 w0.102: v5(47.44,92.49) 47.28,92.65 v7(47.28,92.84)
  GND3 w0.102: v8(47.52,92.82) 47.52,92.56 v5(47.44,92.49)
  IN3 w0.086: v8(47.52,92.82) 47.53,92.83 47.53,92.99 47.57,93.03 47.57,93.5 47.5,93.56 47.5,94.15 v3(47.41,94.24)
EDP_TXN2: length 57.9
  GND2 w0.102: v7(45.5,95.54) 45.69,95.73 v5(45.69,95.84)
  GND3 w0.102: v5(45.69,95.84) v8(45.69,95.51)
  IN3 w0.086: v3(73.81,65.64) 73.53,65.64 73.43,65.74 73.43,65.87 73.53,65.97 73.81,65.97 73.88,66.04 73.88,66.27 73.43,66.73 73.43,67.13 71.62,68.93 71.62,82.07 70.35,83.34 70.35,87.66 67.91,90.1 67.91,91.04 66.36,92.59 66.36,93.04 65.54,93.86 63.6,93.86 62.84,94.62 46.27,94.62 45.69,95.2 v8(45.69,95.51)
  BOTTOM w0.076: 74.91,64.85 74.91,64.78 74.83,64.71 74.83,63.83 74.97,63.7 75.6,63.7 75.79,63.51 75.79,63.31 75.9,63.21 UC1.B36
  BOTTOM w0.145: v3(73.81,65.64) 73.83,65.62 74.42,65.62 74.91,65.13 74.91,64.85
EDP_TXN2_C: length 0.9
  TOP w0.145: CV240.2 RV794.1
EDP_TXN2_R: length 2.4
  GND2 w0.102: v7(45.5,92.84) 45.5,92.65 v5(45.67,92.49)
  GND3 w0.102: v8(45.75,92.82) 45.75,92.57 v5(45.67,92.49)
  IN3 w0.086: v8(45.75,92.82) 45.75,92.99 45.79,93.03 45.79,93.63 46,93.85 46,94.15 v3(45.91,94.24)
EDP_TXN3: length 70.5
  GND2 w0.102: v5(43.87,95.44) 44.04,95.27 44.04,95.19 43.95,95.1 v7(43.71,95.1)
  GND3 w0.102: v5(43.87,95.44) 43.87,95.04 v8(43.93,94.99)
  IN3 w0.061: v3(77.87,62.42) 77.99,62.3 77.99,62.21 78.28,61.93 78.71,61.93 78.93,62.15 78.93,64.2 78.69,64.45 77.9,64.45 77.26,65.08 77.26,65.41 77.75,65.89 77.75,69.12 76.89,69.97 76.66,69.97 76.38,70.26 76.38,70.37
  IN3 w0.086: 76.38,70.37 74.93,71.82 74.93,88.58 69.55,93.95 69.55,95 66.13,98.41 57.03,98.41 55.92,99.52 46.99,99.52 44.48,97.02 44.48,96.06 43.96,95.54 43.96,95.02 v8(43.93,94.99)
EDP_TXN3_C: length 0.9
  TOP w0.145: RV796.1 CV242.2
EDP_TXN3_R: length 2.9
  GND2 w0.102: v5(43.87,92.06) 43.71,92.22 v7(43.71,92.41)
  GND3 w0.102: v5(43.87,92.06) 43.97,92.15 v8(43.97,92.82)
  IN3 w0.086: v3(44.41,94.24) 44.5,94.15 44.5,93.87 44.01,93.38 44.01,92.85 v8(43.97,92.82)
EDP_TXP0: length 56.3
  GND2 w0.102: v7(49.95,95.54) 50.03,95.62 v5(50.03,95.94)
  GND3 w0.102: v5(50.03,95.94) 49.91,96.07 v8(49.7,96.07)
  IN3 w0.086: v3(74.27,64.56) 74.27,64.57 74.31,64.61 74.91,65.21 74.91,66.76 74.5,67.16 74.5,67.49 72.67,69.33 72.67,82.76 71.37,84.05 71.37,89.03 67.38,93.02 67.38,93.53 66.04,94.87 64.02,94.87 63.26,95.64 49.81,95.64 49.71,95.73 49.71,96.06 v8(49.7,96.07)
  BOTTOM w0.076: UC1.C37 76.52,62.36 76.31,62.36 76.22,62.45 76.22,62.69 76.01,62.9 74.86,62.9 74.75,63 74.75,63.1 74.74,63.12
  BOTTOM w0.145: 74.74,63.12 74.03,63.83 74.03,64.35 74.24,64.56 v3(74.27,64.56)
EDP_TXP0_C: length 0.9
  TOP w0.145: RV789.1 CV233.2
EDP_TXP0_R: length 2.4
  GND2 w0.102: v5(49.76,92.49) 49.95,92.68 v7(49.95,92.84)
  GND3 w0.102: v5(49.76,92.49) 49.68,92.56 v8(49.68,92.82)
  IN3 w0.086: v3(49.41,94.24) 49.31,94.14 49.31,93.79 49.65,93.45 49.65,92.9 49.69,92.87 49.69,92.83 v8(49.68,92.82)
EDP_TXP1: length 60.1
  GND2 w0.102: v7(48.17,95.54) 48.18,95.55 v5(48.18,95.89)
  GND3 w0.102: v5(48.18,95.89) 48.15,95.92 48.15,95.97 v8(47.93,96.2)
  IN3 w0.061: v3(77.87,63.21) 77.74,63.21 77.62,63.32 77.62,64.21 76.76,65.08 76.76,65.67 76.45,65.98 76.45,68.9 75.73,69.62 75.73,69.73 75.72,69.74
  IN3 w0.086: v8(47.93,96.2) 47.89,96.16 47.89,95.78 48.03,95.64 48.28,95.64 48.45,95.82 48.45,96.71 49.42,97.67 65.45,97.67 68.81,94.32 68.81,93.69 74.22,88.28 74.22,70.88 75.08,70.01 75.45,70.01 75.72,69.74
EDP_TXP1_C: length 0.9
  TOP w0.145: RV791.1 CV237.2
EDP_TXP1_R: length 2.3
  GND2 w0.102: v7(48.17,92.84) 48.17,92.68 v5(47.98,92.49)
  GND3 w0.102: v8(47.9,92.82) 47.9,92.56 v5(47.98,92.49)
  IN3 w0.086: v8(47.9,92.82) 47.91,92.83 47.91,92.99 47.88,93.03 47.88,93.63 47.81,93.69 47.81,94.14 v3(47.91,94.24)
EDP_TXP2: length 57.8
  GND2 w0.102: v5(46.22,95.84) 46.22,95.7 v7(46.39,95.54)
  GND3 w0.102: v8(46.07,95.51) 46.22,95.66 v5(46.22,95.84)
  IN3 w0.086: v8(46.07,95.51) 46,95.44 46,95.33 46.4,94.93 62.97,94.93 63.73,94.17 65.67,94.17 66.67,93.17 66.67,92.72 68.22,91.17 68.22,90.23 70.66,87.79 70.66,83.47 71.93,82.2 71.93,69.06 73.74,67.26 73.74,66.85 74.19,66.4 74.19,65.5 74.04,65.35 73.95,65.25 v3(73.81,65.25)
  BOTTOM w0.076: 74.6,64.85 74.6,64.78 74.67,64.71 74.67,63.76 74.9,63.53 75.53,63.53 75.62,63.44 75.62,63.14 75.56,63.07 75.4,63.07 UC1.A36
  BOTTOM w0.145: 74.6,64.85 74.6,65 74.29,65.31 73.87,65.31 v3(73.81,65.25)
EDP_TXP2_C: length 0.9
  TOP w0.145: CV239.2 RV793.1
EDP_TXP2_R: length 2.4
  GND2 w0.102: v5(46.2,92.49) 46.39,92.68 v7(46.39,92.84)
  GND3 w0.102: v5(46.2,92.49) 46.13,92.55 v8(46.13,92.82)
  IN3 w0.086: v3(46.41,94.24) 46.31,94.14 46.31,93.72 46.1,93.5 46.1,93.03 46.13,92.99 v8(46.13,92.82)
EDP_TXP3: length 70.5
  GND2 w0.102: v5(44.41,95.46) 44.26,95.31 44.26,95.21 44.36,95.1 v7(44.6,95.1)
  GND3 w0.102: v8(44.31,94.98) 44.41,95.08 v5(44.41,95.46)
  IN3 w0.061: 76.16,70.15 76.27,70.15 76.6,69.82 76.83,69.82 77.6,69.06 77.6,65.96 77.11,65.47 77.11,65.02 77.84,64.3 78.62,64.3 78.78,64.14 78.78,62.22 78.65,62.08 78.34,62.08 78.14,62.27 78.14,62.69 78.39,62.94 78.51,62.94 78.6,62.84 78.6,62.5 v3(78.52,62.42)
  IN3 w0.086: 76.16,70.15 74.62,71.69 74.62,88.45 69.24,93.83 69.24,94.87 66,98.1 56.9,98.1 55.79,99.21 47.12,99.21 44.79,96.89 44.79,95.94 44.27,95.41 44.27,95.01 v8(44.31,94.98)
EDP_TXP3_C: length 0.9
  TOP w0.145: RV795.1 CV241.2
EDP_TXP3_R: length 2.9
  GND2 w0.102: v5(44.41,92.06) 44.6,92.25 v7(44.6,92.41)
  GND3 w0.102: v8(44.36,92.82) 44.36,92.11 v5(44.41,92.06)
  IN3 w0.086: v3(44.91,94.24) 44.81,94.14 44.81,93.74 44.32,93.25 44.32,92.85 v8(44.36,92.82)
EGND: length 8.9
  TOP w0.127: R5849.2 v7(157.77,7.74)
  IN1 w0.064: v7(157.77,7.74) 157.77,7.52 157.5,7.26 157.5,6.41 155.56,4.46 v2(153.45,4.46)
  GND2 w0.102: v7(157.77,7.74) 157.77,7.07 v5(157.81,7.03)
  GND3 w0.102: v6(158.15,7.03) v5(157.81,7.03)
  BOTTOM w0.127: JFP1.6 158.41,6.77 v6(158.15,7.03)
EN_0.6V: length 6.7
  TOP w0.203: PR805.2 PR808.1 80.07,94.56 80.43,94.2 81.14,94.2 81.82,93.52 81.82,93.36 v1(81.89,93.3) 82.27,92.92 v7(82.27,92.87)
  GND2 w0.203: v5(82.61,92.67) 82.41,92.87 v7(82.27,92.87)
  GND3 w0.203: v6(82.2,92.58) 82.52,92.58 v5(82.61,92.67)
  BOTTOM w0.203: v6(82.2,92.58) 81.53,92.58 80.94,93.17 PU800.16
EN_1.2V: length 2.5
  GND2 w0.254: v7(79.02,95.59) v5(79.02,95.22)
  GND3 w0.254: v8(79.41,95.21) 79.4,95.22 v5(79.02,95.22)
  IN3 w0.254: v8(79.41,95.21) 80.57,94.04 v3(80.69,94.04)
EN_1VALWP: length 6.3
  BOTTOM w0.203: PR703.2 13.08,55.01 PC712.1 ; PC712.1 12.37,55.81 PR704.1 ; PC712.1 12.37,54.9 12.76,54.5 12.76,53.11 12.38,52.73 12.38,51.4 12.18,51.2 PU700.11
EN_+0.95VSP: length 6.9
  TOP w0.254: PD1000.2 103.49,22.73 PR1003.2 104.96,23.74 105.22,23.49 v1(105.66,23.49) 106.22,24.05 PC1011.1 105.2,25.49 105.2,26.01 105.18,26.03 105.18,26.27 104.96,26.49 PU1000.11
EN_INVPWR: length 132.7
  TOP w0.127: UE3.B2 41.14,17 40.61,17 39.87,17.74 v1(39.09,17.74) 38.96,17.61 RE161.1 37.98,17.72 37.69,18.01 v7(37.13,18.01) ; RV787.1 67.03,95.69 67.15,95.81 67.15,96.67 67.44,96.95 QV9.2 66.79,97.6 v2(66.64,97.75)
  IN1 w0.064: v4(26.11,33.33) 24.32,35.11 24.32,36.36 23.95,36.73 23.95,44.2 24.51,44.76 24.51,50.69 27.56,53.75 27.56,54.9 28.44,55.78 28.44,56.7 30.6,58.85 32.31,58.85 33.17,59.72 36.16,59.72 37.35,60.91 38.29,60.91 39.82,62.45 39.82,62.98 41.63,64.78 41.63,69.52 42.53,70.42 42.53,72.08 44.09,73.64 44.09,85.14 43.05,86.18 43.05,91.02 42.2,91.87 42.2,96.62 43.14,97.56 52.33,97.56 53,98.23 58.83,98.23 59.19,97.87 66.52,97.87 v2(66.64,97.75)
  GND2 w0.102: v5(36.29,17.99) 36.32,17.96 37.08,17.96 v7(37.13,18.01) ; v4(26.11,33.33) 26.11,33.31 26.41,33.31 v5(26.56,33.15)
  GND3 w0.102: v5(36.29,17.99) 36.15,17.99 v8(36,18.14) ; v8(27.33,33.2) 27.3,33.2 27.28,33.22 26.63,33.22 v5(26.56,33.15)
  IN3 w0.064: v8(27.33,33.2) 29.07,33.2 32.93,29.35 32.93,28.13 33.92,27.14 33.92,21.71 34.48,21.15 34.48,19.66 v8(36,18.14)
EN_VDD08: length 3.6
  BOTTOM w0.127: v1(151.74,93.71) 151.57,93.54 PR2329.1
  BOTTOM w0.254: PR2329.1 151.53,92.85 PC3274.1 151.55,92.26 PR2334.2 151.44,91.68 150.88,91.12 PU2304.11
ENVDD: length 4.3
  BOTTOM w0.254: RZ21.1 68.33,91.66 UZ6.4 66.89,91.66 66.63,91.91 v1(66.63,92.97) 67.06,93.4 DV4.1
ENVDD_PCH: length 142.2
  TOP w0.127: UE3.N9 v7(47.51,7.44) ; v1(70.86,94.62) 70.74,94.62 v9(70.46,94.34)
  IN1 w0.064: v9(70.46,94.34) 70.43,94.37 67.56,94.37 66.69,95.24 63.08,95.24 62.29,96.02 56.12,96.02 55.51,95.41 54.86,95.41 54.09,94.64 53.66,94.64 53.13,94.11 53.13,93.68 51.35,91.9 51.35,91.69 49.34,89.68 48.48,89.68 47.67,88.87 47.67,87.5 47.39,87.22 47.39,71.26 44.52,68.39 44.52,63.31 42.96,61.75 42.96,60.82 39.32,57.18 39.1,56.95 38.79,56.95 38.57,56.73 38.57,56.18 v4(37.9,55.52) 36.91,55.52 36.64,55.24 36.64,54.74 35.64,53.74 35.64,53.5 34.48,52.34 34.48,51.38 34.11,51.01 33.4,51.01 32.08,49.69 31.53,49.69 31.02,49.18 31.02,47.62 30.47,47.06 30.47,43.64 29.26,42.44 29.26,41.05 28.16,39.95 28.08,39.95 27.89,39.76 27.24,39.76 v4(27.22,39.79)
  GND2 w0.102: v4(27.22,39.79) 27.2,39.78 27.05,39.78 v5(26.77,40.06) ; v5(38.15,55.76) v4(37.9,55.52) ; v7(47.51,7.44) 47.85,7.44 v5(48.13,7.71)
  GND3 w0.102: v8(26.02,40.24) 26.59,40.24 v5(26.77,40.06) ; v8(48.2,8.29) 48.2,7.78 v5(48.13,7.71) ; v6(38.5,55.76) v5(38.15,55.76)
  IN3 w0.064: v8(48.2,8.29) 48.61,8.71 48.61,10.42 45.99,13.04 45.99,13.74 45.63,14.1 41.38,14.1 40.45,15.03 38.01,15.03 33.79,19.24 33.79,20.87 33.23,21.43 33.23,26.63 31.28,28.58 31.28,30.06 29.17,32.17 26.93,32.17 26.25,32.85 25.49,32.85 23.89,34.45 23.89,35.49 23.57,35.81 23.57,37.79 v8(26.02,40.24)
  BOTTOM w0.127: v9(70.46,94.34) 70.51,94.29 70.51,93.2 70.06,92.75 DV4.3
ESPI_ALERT#: length 66.5
  TOP w0.127: UE3.H7 45.44,11.68 45.27,11.68 44.95,11.37 v7(44.95,11.34) ; RH166.1 22.41,42.94 v7(22.48,43.01) v1(22.86,43.01)
  GND2 w0.102: v5(44.57,10.99) 44.59,10.99 44.94,11.34 v7(44.95,11.34) ; v7(22.48,43.01) v5(22.83,43.01)
  GND3 w0.102: v8(22.91,43.39) 22.83,43.31 v5(22.83,43.01) ; v5(44.57,10.99) 44.05,10.99 v8(43.87,10.82)
  IN3 w0.064: v6(28.53,43.41) 28.37,43.57 26.12,43.57 25.62,44.07 24.29,44.07 23.77,43.55 23.07,43.55 v8(22.91,43.39) 22.75,43.24 22.32,43.24 21.69,43.87 19.37,43.87 18.11,42.6 18.11,41.79 17.81,41.49 17.81,40.21 18.83,39.19 18.83,35.01 24.29,29.55 24.29,29.35 25.96,27.68 25.96,27.07 28.03,25 28.03,22.87 27.4,22.24 27.4,19.57 27.93,19.03 27.93,16.6 29.14,15.39 29.14,14.97 32.1,12.01 32.44,12.01 33.98,10.47 35.56,10.47 35.99,10.04 37.65,10.04 38.17,9.52 40.17,9.52 41.65,11 42.91,11 43.09,10.83 43.86,10.83 v8(43.87,10.82)
ESPI_CLK: length 11.2
  BOTTOM w0.076: 22.07,43.63 22.16,43.63 22.42,43.9 23.97,43.9 24.2,43.67 26.11,43.67 26.16,43.72 26.59,43.72 26.82,43.49 UH4.BC17
  BOTTOM w0.127: 22.07,43.63 21.69,43.63 21.41,43.35 18.02,43.35 RH168.1 18.07,44.21 v1(18.83,44.21)
ESPI_CLK_R: length 67.8
  TOP w0.127: v9(29.73,9.58) v1(29.12,10.18) ; UE3.G7 45.31,12.35 v7(45.31,12.27) ; v7(17.5,43.14) 18.07,43.71 CH84.1 RH169.2
  IN1 w0.064: v9(29.73,9.58) 29.8,9.65 30.86,9.65 31.15,9.35 32.74,9.35 33.16,9.77 35.18,9.77 35.37,9.96 38.5,9.96 38.58,9.89 40.44,9.89 41.59,11.03 42.47,11.03 42.47,11.02 42.89,11.02 43.42,10.5 43.79,10.5 44.22,10.93 44.4,10.93 44.64,11.16 44.64,11.6 v7(45.31,12.27)
  GND2 w0.102: v7(17.5,43.14) 17.5,43.17 v5(17.12,43.56)
  GND3 w0.102: v5(17.12,43.56) 16.92,43.76 v6(16.7,43.76)
  IN3 w0.064: v6(16.7,43.76) 17,43.45 17,42.25 16.7,41.95 16.7,39.56 17.2,39.06 17.2,38.41 17.4,38.21 17.4,36.77 17.14,36.51 17.14,34.46 18.46,33.14 18.46,27.93 21.6,24.79 23.76,24.79 24.72,23.83 25.55,23.83 v3(25.74,23.64) 24.93,22.83 24.93,21.01 25.15,20.79 25.15,19.65 24.89,19.39 24.89,19.39 24.04,18.54 24.04,15.83 26.61,13.25 26.72,13.25 26.84,13.37 26.94,13.37 27.02,13.3 27.02,13.19 26.9,13.07 26.9,12.97 26.97,12.89 27.08,12.89 27.2,13.01 27.3,13.01 27.38,12.94 27.38,12.83 27.26,12.71 27.26,12.61 28.86,11 28.99,11 29.44,10.56 29.44,9.87 29.73,9.58 v9(29.73,9.58)
  BOTTOM w0.127: v3(25.74,23.64) 24.8,23.64 24.76,23.6 JESPI1.10
ESPI_CS#: length 68.5
  TOP w0.127: v7(44.35,11.39) UE3.H6
  IN1 w0.064: v7(44.35,11.39) 43.97,11.39 43.81,11.23 43.58,11.23 43.07,11.74 41.4,11.74 40.18,10.52 39.65,10.52 39.57,10.6 35.01,10.6 34.63,10.22 v4(34.36,10.22)
  GND2 w0.102: v5(34.36,9.78) v4(34.36,10.22)
  GND3 w0.102: v15(34.04,9.73) 34.09,9.78 v5(34.36,9.78)
  IN3 w0.064: v15(34.04,9.73) 33.98,9.73 33.47,10.24 32.37,10.24 31.72,10.89 31.72,11.65 28.62,14.75 28.62,15.17 27.32,16.47 27.32,18.62 27.02,18.92 27.02,20.73 v3(26.93,20.81) 27.02,20.9 27.02,22.4 27.5,22.89 27.5,24.78 25.5,26.79 25.5,27.41 23.9,29 23.9,29.4 18.45,34.85 18.45,38.65 18.25,38.85 18.25,39.5 17.62,40.14 17.62,41.57 17.91,41.87 17.91,42.68 19.14,43.9 19.14,44.35 19.2,44.42 19.44,44.42 19.51,44.34 19.51,44.14 19.59,44.06 19.76,44.06 19.83,44.14 19.83,44.34 19.91,44.42 20.14,44.42 20.21,44.34 20.21,44.14 20.29,44.06 20.46,44.06 20.53,44.14 20.53,44.34 20.6,44.42 22.03,44.42 22.42,44.02 v3(22.42,43.52)
  BOTTOM w0.076: UH4.BE16 25.84,42.8 25.38,42.8 24.95,43.24 23.26,43.24 22.98,43.52 v3(22.42,43.52)
  BOTTOM w0.127: v3(26.93,20.81) v1(26.51,20.4) 26.32,20.4 25.82,20.91 25.18,20.91 24.99,21.1 24.99,21.8 24.68,22.1 JESPI1.7
ESPI_IO0: length 70.3
  TOP w0.127: v7(43.55,9.58) 43.55,9.79 UE3.K5 ; RH621.2 24.72,45.23 v1(23.91,45.23) 23.82,45.14 21.08,45.14 20.34,44.41 19.44,44.41 19.38,44.47 18.16,44.47 v7(17.8,44.83)
  IN1 w0.064: v7(43.55,9.58) 43.55,9.55 43.05,9.05 43.05,8.82 42.07,7.84 38.05,7.84 37.81,8.08 36.19,8.08 v4(36.16,8.1)
  GND2 w0.102: v4(36.16,8.1) 36.17,8.1 36.04,7.97 v5(36.04,7.72) ; v7(17.8,44.83) v5(17.8,45.22)
  GND3 w0.102: v8(35.98,7.38) 35.98,7.66 v5(36.04,7.72) ; v8(17.47,45.22) v5(17.8,45.22)
  IN3 w0.064: v8(35.98,7.38) 33.25,7.38 32.51,8.13 29.69,8.13 22.26,15.55 22.26,18.31 v3(24.06,20.1) 20.85,23.32 20.85,24.1 17.44,27.51 17.44,32.72 16.12,34.04 16.12,37.71 16.39,37.98 16.39,38.98 16.07,39.3 16.07,44.37 16.91,45.22 v8(17.47,45.22)
ESPI_IO0_R: length 5.1
  TOP w0.127: v7(29.33,45.09) 29.23,45.19 27.05,45.19 v1(26.83,44.98) 26.39,45.42 RH621.1
  GND2 w0.102: v7(29.33,45.09) 29.36,45.09 29.41,45.04 v5(29.69,45.04)
  GND3 w0.102: v5(29.69,45.04) 29.61,45.12 v6(29.61,45.4)
  BOTTOM w0.076: UH4.AT22 v6(29.61,45.4)
ESPI_IO1: length 70.5
  TOP w0.127: v7(17.33,45.48) 17.56,45.48 18.32,44.72 19.49,44.72 19.55,44.66 20.24,44.66 21,45.42 22.13,45.42 23.02,46.31 v1(23.09,46.31) RH622.2 ; v7(42.75,8.99) UE3.L4
  IN1 w0.064: v4(35.53,8.11) 35.91,8.49 36.1,8.49 36.32,8.71 36.82,8.71 37.01,8.51 37.31,8.51 37.74,8.51 38.22,8.03 41.79,8.03 v7(42.75,8.99)
  GND2 w0.102: v5(35.53,7.77) v4(35.53,8.11) ; v5(17.52,45.75) 17.33,45.56 v7(17.33,45.48)
  GND3 w0.102: v8(35.2,7.77) v5(35.53,7.77) ; v8(17.94,45.75) v5(17.52,45.75)
  IN3 w0.064: v8(17.94,45.75) 17.94,45.04 17.75,44.85 16.81,44.85 16.26,44.29 16.26,39.37 16.58,39.06 16.58,37.9 16.31,37.64 16.31,34.12 17.63,32.8 17.63,27.59 21.04,24.18 21.04,23.63 v3(24.06,20.6) 24.32,20.34 24.32,20 22.45,18.13 22.45,15.63 29.77,8.32 32.59,8.32 33.14,7.77 v8(35.2,7.77)
ESPI_IO1_R: length 5
  TOP w0.127: v7(29.33,46.36) 29.33,46.82 29.13,47.02 27.51,47.02 v1(26.8,46.31) RH622.1
  GND2 w0.102: v5(29.3,46.03) 29.33,46.07 v7(29.33,46.36)
  GND3 w0.102: v6(29.3,45.69) v5(29.3,46.03)
ESPI_IO2: length 67.6
  TOP w0.127: RH623.2 22.56,42.18 21.43,42.18 21.15,41.9 19.25,41.9 19.05,41.7 18.76,41.7 18.25,42.21 16.85,42.21 16.47,41.83 16.47,39.26 v1(16.53,39.2) v7(16.53,38.44) ; v7(44.35,12.19) UE3.G6
  IN1 w0.064: v4(32.18,9.68) 33.18,10.68 34.83,10.68 34.93,10.79 37.02,10.79 37.58,11.35 40.49,11.35 41.07,11.93 43.66,11.93 43.92,12.19 v7(44.35,12.19)
  GND2 w0.102: v7(16.53,38.44) 16.8,38.17 v5(16.8,38.09) ; v4(32.18,9.68) 32.18,9.24 v5(32.04,9.1)
  GND3 w0.102: v8(16.77,37.68) 16.8,37.7 v5(16.8,38.09) ; v5(32.04,9.1) 31.85,8.91 v15(31.85,8.58)
  IN3 w0.064: v15(31.85,8.58) 29.78,8.58 22.65,15.71 22.65,18.05 24.51,19.92 24.51,20.52 24.06,20.97 v3(24.06,21.1) 21.23,23.94 21.23,24.26 17.82,27.67 17.82,32.88 16.5,34.2 16.5,37.41 v8(16.77,37.68)
ESPI_IO2_R: length 4.8
  TOP w0.127: RH623.1 v7(26.95,44.53)
  GND2 w0.102: v5(27.23,44.28) 26.97,44.53 v7(26.95,44.53)
  GND3 w0.102: v5(27.23,44.28) 27.48,44.28 v8(27.57,44.37)
  IN3 w0.064: v6(29.21,45.03) 28.6,45.03 27.94,44.37 v8(27.57,44.37)
  BOTTOM w0.076: v6(29.21,45.03) 29.62,45.03 UH4.AT19
ESPI_IO3: length 65.3
  TOP w0.127: v7(43.55,8.99) UE3.L5 ; RH624.2 22.92,41.65 v1(21.75,41.65) 19.35,41.65 19.15,41.45 18.66,41.45 18.14,41.96 16.96,41.96 16.72,41.72 16.72,39.46 16.85,39.33 16.85,37.62 v7(16.86,37.61)
  IN1 w0.064: v7(43.55,8.99) 42.2,7.64 37.97,7.64 37.73,7.89 36.31,7.89 36.26,7.84 35.01,7.84 34.82,8.02 v4(34.71,8.02)
  GND2 w0.102: v4(34.71,8.02) v5(34.71,8.35) ; v7(16.86,37.61) 16.85,37.6 v5(16.85,37.25)
  GND3 w0.102: v5(34.71,8.35) 34.65,8.35 v8(34.39,8.08) ; v5(16.85,37.25) v8(16.85,36.85)
  IN3 w0.064: v8(16.85,36.85) 16.84,36.85 16.69,36.7 16.69,34.28 18.01,32.95 18.01,27.75 21.42,24.34 21.42,24.09 23.91,21.6 v3(24.06,21.6) 24.06,21.58 24.36,21.29 24.36,20.95 24.7,20.6 24.7,19.84 22.84,17.97 22.84,16.4 28.6,10.63 28.6,10.08 29.84,8.84 32.34,8.84 33.09,8.08 v8(34.39,8.08)
ESPI_IO3_R: length 2.8
  TOP w0.127: v7(25.83,43.64) v1(26.83,43.64)
  GND2 w0.102: v5(25.47,43.47) 25.5,43.44 25.63,43.44 v7(25.83,43.64)
  GND3 w0.102: v6(25.5,43.1) 25.5,43.44 v5(25.47,43.47)
  BOTTOM w0.076: v6(25.5,43.1) 26.06,43.1 26.29,42.86 UH4.BD16
ESPI_RESET#: length 71.4
  TOP w0.127: v9(44.35,9.79) UE3.K6
  IN3 w0.064: v9(44.35,9.79) 44.03,9.79 43.72,9.48 42.36,9.48 41.52,8.64 36.69,8.64 35.77,9.56 34.32,9.56 33.75,8.99 33.45,8.99 32.99,9.45 31.45,9.45 30.55,10.36 30.55,12.35 30.41,12.49 28.24,14.66 28.24,15.08 26.95,16.38 26.95,17.32 25.97,18.3 25.97,18.6 26.15,18.77 26.15,21.12 v3(26.32,21.29) 26.32,22.37 27.03,23.09 27.03,23.61 26.65,23.99 26.65,24.77 25.54,25.89 23.59,25.89 23.26,26.22 23.26,29.16 17.84,34.58 17.84,35.51 17.58,35.77 17.58,36.32 17.84,36.58 17.84,38.4 17.64,38.59 17.64,39.25 17.15,39.74 17.15,41.77 17.44,42.07 17.44,43.08 17.82,43.45 17.82,44.05 19.79,46.02 20.72,46.02 21.36,46.67 23.23,46.67 23.48,46.42 23.48,45.05 v3(23.11,44.68)
  BOTTOM w0.076: UH4.BC18 26.85,43.99 26.62,44.22 26.15,44.22 26.04,44.33 24.66,44.33 24.36,44.63 23.16,44.63 v3(23.11,44.68)
  BOTTOM w0.127: v3(26.32,21.29) 26.65,21.62 RE428.2
FB_1VALWP: length 3.8
  BOTTOM w0.203: PU700.14 12.4,49.85 12.85,50.3 13.34,50.3 PR702.2 PC706.2 13.48,51.38 PR705.1
FB_+0.95VSP: length 3.5
  TOP w0.127: PC1012.2 PR1007.2 PR1009.1 106.14,28.34 105.64,27.84 PU1000.14
FB_VDD08: length 4.7
  TOP w0.127: v7(151.26,89.94) v1(150.26,89.94)
  TOP w0.254: PR2336.2 151.99,88.67 PC3285.2 151.5,89.7 v7(151.26,89.94)
  GND2 w0.254: v5(150.69,89.78) 150.85,89.94 v7(151.26,89.94)
  GND3 w0.254: v5(150.69,89.78) 150.71,89.77 v6(151.11,89.77)
  BOTTOM w0.254: PU2304.14 v6(151.11,89.77)
FGND: length 5.2
  IN1 w0.064: v2(153.45,5.8) 153.9,5.35 156.08,5.35 v7(157.18,6.46)
  GND2 w0.254: v7(157.18,6.46) 157.4,6.24 157.41,6.24 v5(157.51,6.14)
  GND3 w0.254: v5(157.51,6.14) v6(157.91,6.14)
FPR__GPIO_DET#: length 34.4
  TOP w0.127: R5824.2 129.54,3.5 131.42,3.5 131.92,3.99 MD3.3 136.01,4.02 v1(136.7,4.71) v7(137.18,5.19)
  GND2 w0.102: v5(137.18,5.61) v7(137.18,5.19)
  GND3 w0.102: v5(137.18,5.61) v8(137.44,5.87)
  IN3 w0.064: v8(137.44,5.87) 137.52,5.87 138.85,7.19 141.77,7.19 142.42,6.55 147.16,6.55 148.53,7.92 153.2,7.92 154.8,6.32 155.96,6.32 156.21,6.57 159.05,6.57 159.41,6.21 v3(159.41,5.99)
FPR_DET#: length 127.9
  TOP w0.076: 42.11,13.92 41.96,14.07 41.96,16.16 42.35,16.55 UE3.B3
  TOP w0.127: v2(115.29,6.38) 118.6,6.38 120.45,4.53 128.34,4.53 128.75,4.93 R5824.1 ; v2(86.76,17.91) 86.94,17.74 v1(86.94,15.13) 86.94,12.63 86.69,12.38 86.69,10.12 85.68,9.11 v2(85.68,5.3) ; 42.11,13.92 42.23,13.8 42.57,13.8 42.73,13.63 42.73,13.15 v2(42.76,13.12)
  IN1 w0.064: v2(115.29,6.38) 115.29,6.75 114.36,7.68 114.36,11.19 114.47,11.31 114.47,15.57 114.01,16.03 110.58,16.03 110.11,15.55 106.64,15.55 106.32,15.86 102.07,15.86 100.82,14.61 97.76,14.61 97.23,14.09 92.49,14.09 90.11,16.47 88.44,16.47 87.1,17.81 86.86,17.81 v2(86.76,17.91) ; v2(35.87,13.09) 35.94,13.15 40.78,13.15 40.88,13.25 42.39,13.25 42.52,13.12 v2(42.76,13.12) 43.48,13.12 43.86,13.51 46.26,13.51 46.63,13.88 47.66,13.88 48.11,14.33 49.3,14.33 49.89,14.93 50.57,14.93 50.76,15.12 51.49,15.12 51.77,14.83 51.77,14.42 52.01,14.19 53.65,14.19 54.27,13.56 54.27,12.86 54.8,12.32 55.76,12.32 56.46,11.62 59.56,11.62 61.96,9.23 64.69,9.23 65.36,8.56 67.87,8.56 69.86,6.57 70.59,6.57 70.83,6.81 76.29,6.81 76.83,6.27 78.06,6.27 78.36,5.97 80.01,5.97 80.26,5.72 84.04,5.72 84.12,5.64 85.34,5.64 v2(85.68,5.3)
FPR_SCAN#: length 126.7
  TOP w0.127: v2(86.36,17.91) 86.36,17.81 86.74,17.43 86.74,16.11 86.31,15.68 v1(86.31,13.29) 86.31,10.02 85.37,9.08 85.37,4.77 v2(85.63,4.5) ; v2(44.34,12.87) 44.34,13.7 43.95,14.09 UE3.E5 ; v2(55.15,6.45) 55.15,7.38 54.71,7.83 RE278.1 v2(54.71,8.97) ; R5823.1 129.57,5.4 128.63,5.4 128.09,4.86 120.41,4.86 118.59,6.67 114.94,6.67 v2(114.84,6.57) ; v2(56.71,8.99) 57.2,9.48 57.2,10.55 v2(56.99,10.75)
  IN1 w0.064: v2(55.15,6.45) 56.04,6.45 56.26,6.24 60.31,6.24 61.46,5.09 68.73,5.09 69.1,5.45 72.08,5.45 72.26,5.64 76.08,5.64 76.43,5.28 77.67,5.28 77.96,4.99 79.61,4.99 80.1,4.5 83.26,4.5 83.44,4.67 85.35,4.67 85.52,4.5 v2(85.63,4.5) ; v2(56.71,8.99) 56.69,8.97 v2(54.71,8.97) ; v2(86.36,17.91) 86.62,17.65 87.07,17.65 88.39,16.33 90.05,16.33 92.44,13.95 97.29,13.95 97.81,14.47 100.88,14.47 102.12,15.72 106.27,15.72 106.58,15.41 110.16,15.41 110.64,15.89 113.95,15.89 114.33,15.5 114.33,11.36 114.22,11.25 114.22,7.19 v2(114.84,6.57) ; v2(56.99,10.75) 56.83,10.75 56.7,10.62 55.15,10.62 54.96,10.81 54.96,11.77 53.99,12.74 53.99,13.45 53.53,13.91 51.89,13.91 51.42,14.38 50.38,14.38 49.69,13.69 46.65,13.69 46.38,13.42 46.37,13.42 46.32,13.37 44.84,13.37 v2(44.34,12.87)
FPR_SCAN#_CONN: length 31.8
  TOP w0.127: R5823.2 130.03,4.02 MD3.2 131.81,4.91 v1(134.4,4.91) 135.68,4.91 v7(135.99,5.21)
  GND2 w0.102: v7(135.99,5.21) v5(136.32,5.21)
  GND3 w0.102: v5(136.32,5.21) v8(136.65,5.21)
  IN3 w0.064: v3(158.91,6.14) 158.62,6.43 156.27,6.43 156.02,6.18 154.74,6.18 153.16,7.75 148.56,7.75 147.21,6.41 142.36,6.41 141.72,7.05 139.09,7.05 137.25,5.21 v8(136.65,5.21)
FRS_ON_P1: length 30.3
  IN2 w0.074: v5(23.92,71.67) 23.92,72.61 24.2,72.89 24.2,75.22 23.76,75.66 23.76,79.71 25.02,80.96 v5(25.02,83.18)
  GND3 w0.102: v5(23.92,71.67) 24.03,71.57 v6(24.44,71.57) ; v8(24.77,82.72) 25.02,82.96 v5(25.02,83.18)
  IN3 w0.064: v8(24.77,82.72) 27.68,79.81 27.68,75.94 30.83,72.79 30.83,72.08 v3(31.57,71.34)
  BOTTOM w0.127: v3(31.57,71.34) 33.3,71.34 33.68,70.96 UPD1.L7
FRS_ON_P2: length 58.2
  IN1 w0.064: v7(27.21,100.61) 27.48,100.34 27.48,99.99 26.7,99.22 26.7,94.29 v4(27.08,93.92)
  GND2 w0.102: v4(27.08,93.92) 27.24,93.92 v5(27.47,94.14)
  IN2 w0.074: v5(38.13,71.28) 37.88,71.53 37.88,72.83 38.14,73.09 39.99,73.09 41.72,74.82 45.03,74.82 47.59,77.38 47.59,86.33 45.18,88.73 44.42,88.73 43.21,89.94 43.21,90.39 41.08,92.52 39.87,92.52 38.33,94.07 35.52,94.07 34.98,94.61 31.74,94.61 31.48,94.35 27.68,94.35 v5(27.47,94.14)
  GND3 w0.102: v6(37.75,70.88) 37.75,70.88 37.75,70.88 38.13,71.27 v5(38.13,71.28)
  BOTTOM w0.127: UPD1.L8 34.45,70.79 37.66,70.79 v6(37.75,70.88)
GPIO_6_REG_HOTB: length 33
  TOP w0.127: RH634.2 63.42,87.33 QC3.1 63.42,86.25 64.59,85.08 64.59,83.09 65.25,82.43 68.28,82.43 68.61,82.76 v1(69.44,82.76) 72.47,82.76 78.44,88.73 v7(82.51,88.73)
  GND2 w0.102: v5(82.91,88.36) 82.55,88.73 v7(82.51,88.73)
  GND3 w0.102: v6(83.28,88.37) 82.93,88.37 v5(82.91,88.36)
  BOTTOM w0.127: UC1.V4 86.39,84.49 86.09,84.79 84.65,84.79 84.37,85.07 84.37,87.28 v6(83.28,88.37)
GPP_C2_SMBALERT#: length 5.9
  IN3 w0.064: v3(27.11,55.48) 28.09,56.46 28.09,57.63 26.51,59.2 v3(26.51,60.28)
GPP_C5_SML0ALERT#: length 6
  IN3 w0.064: v3(27.95,54.94) 28.55,55.55 28.55,58.31 27.66,59.2 v3(27.66,60.28)
GPPB_23_SML1ALERT#: length 2.4
  TOP w0.127: RH154.2 30.07,47.66 30.06,47.67 v1(30.06,48.16) 29.85,48.37 v7(29.74,48.37)
  GND2 w0.102: v5(29.66,48.7) 29.71,48.65 29.71,48.39 v7(29.74,48.37)
  GND3 w0.102: v5(29.66,48.7) 29.69,48.67 v6(29.69,48.37)
  BOTTOM w0.076: UH4.AT27 v6(29.69,48.37)
GPU_ANALOGIO_1: length 2.5
  TOP w0.127: RH541.1 79.18,82 78.87,82.31 v7(78.85,82.31) 78.79,82.31 v1(78.29,81.81)
  GND2 w0.102: v5(79.42,82.13) 79.01,82.13 78.85,82.29 v7(78.85,82.31)
  GND3 w0.102: v6(79.22,81.86) 79.22,81.93 v5(79.42,82.13)
GPU_ANALOGIO_2: length 0.8
  GND2 w0.102: v5(80.03,62.85) 80.13,62.74 v7(80.36,62.74)
  GND3 w0.102: v5(80.03,62.85) 80.08,62.85 80.2,62.72 v6(80.2,62.55)
GPU_AUX_ZVSS: length 5.4
  BOTTOM w0.127: RH482.1 70.98,85.03 72.48,83.52 74.01,83.52 74.62,82.91 UC1.A6
GPU_B+: length 17.2
  TOP w0.254: PR1803.1 53.81,26.31 54.04,26.08 v7(54.37,26.08)
  IN1 w0.254: v4(59.57,33.36) 59.92,33 64.65,33 v7(65.13,32.52)
  GND2 w0.254: v4(59.57,33.36) 59.21,33.36 v5(59.11,33.46) ; v5(54.45,26.4) 54.45,26.15 v7(54.37,26.08)
  GND3 w0.254: v5(54.45,26.4) 54.48,26.4 v6(54.71,26.17) ; v5(59.11,33.46) v6(59.11,33.02)
  BOTTOM w0.254: v6(59.11,33.02) 59.11,30.45 54.83,26.17 v6(54.71,26.17)
  vias: v1(94.97,32.66) v3(100.17,27.69) v3(100.17,26.98) v3(100.17,26.36) v3(100.53,27.69) v3(100.53,26.98) v3(100.53,26.33) v3(100.53,25.81) v3(100.86,27.69) v3(100.86,26.98) v3(100.86,26.33) v3(100.86,25.81) v3(101.04,25.2) v3(101.22,27.69) v3(101.22,26.98) v3(101.22,26.33) v3(101.22,25.81) v3(101.39,25.2) v3(101.66,33.52) v3(101.57,27.69) v3(101.57,26.98) v3(101.57,26.33) v3(101.57,25.81) v3(101.69,33.01) v3(101.69,32.56) v3(101.69,31.84) v3(101.69,31.13) v3(101.75,25.2) v3(101.93,27.69) v3(101.93,26.98) v3(101.93,26.33) v3(101.89,25.8) v3(101.99,33.52) v3(102.02,33.01) v3(102.02,32.56) v3(102.02,31.84) v3(102.02,31.13) v3(102.1,25.2) v3(102.35,33.52) v3(102.37,33.01) v3(102.37,32.56) v3(102.37,31.84) v3(102.37,31.13) v3(102.78,33.53) v3(102.8,33.03) v3(102.79,32.53) v3(102.79,31.92) v3(102.79,31.21) v3(103.13,33.53) v3(103.16,33.03) v3(103.15,32.53) v3(103.15,31.92) v3(103.15,31.21) v9(66.33,34.97) v9(66.33,34.38) v9(66.91,34.97) v9(66.91,34.38) v9(67.5,34.97) v9(67.5,34.38) v9(75.12,34.7) v9(75.12,34.12) v9(75.7,34.65) v9(75.7,34.07) v9(76.29,34.65) v9(76.29,34.07) v9(83.87,34.61) v9(83.87,34.03) v9(84.45,34.61) v9(84.45,34.03) v9(85.04,34.61) v9(85.04,34.03) v9(92.71,34.63) v9(92.71,34.04) v9(93.29,34.63) v9(93.29,34.04) v9(93.87,34.63) v9(93.87,34.04)
GPU_BP_0: length 13.6
  IN3 w0.064: v3(82.45,86.42) 82.45,88.23 84.9,90.68 84.9,91.94 v3(85.1,92.15)
  BOTTOM w0.127: RH534.1 91.04,92.77 89.7,92.77 89.42,92.49 88.79,92.49 88.6,92.3 v1(88.34,92.3) 87.79,92.3 87.66,92.42 85.38,92.42 v3(85.1,92.15)
GPU_BP_0_R: length 2.2
  BOTTOM w0.127: v1(89.46,93.06) 90.12,93.72 RH536.2 RH534.2
GPU_BP_1: length 14.8
  IN3 w0.064: v3(82.45,85.77) 82.54,85.77 82.71,85.94 82.71,88.29 85.04,90.62 85.04,91.66 v3(85.5,92.12)
  BOTTOM w0.127: v3(85.5,92.12) 85.59,92.03 v1(86.04,92.03) 87.75,92.03 87.81,91.97 88.56,91.97 88.87,92.28 89.51,92.28 89.79,92.56 91.13,92.56 91.3,92.73 91.77,92.73 RH535.1
GPU_BP_1_R: length 0.6
  BOTTOM w0.127: RH537.2 RH535.2
GPU_DBG_DFTIO_0: length 2.5
  GND2 w0.102: v7(105.38,65.87) 105.58,65.66 v5(105.76,65.66)
  GND3 w0.102: v5(105.76,65.66) 105.79,65.64 105.79,65.44 v6(105.89,65.33)
  BOTTOM w0.127: UC1.BG35 105.37,64.13 105.74,64.5 105.74,65.18 v6(105.89,65.33)
GPU_DBG_DFTIO_1: length 0.8
  GND2 w0.107: v5(106.91,66.18) 107.16,65.94 v7(107.16,65.87)
  GND3 w0.127: v6(107.2,65.9) v5(106.91,66.18)
GPU_DP_ZVSS: length 7
  BOTTOM w0.127: RH481.1 71.31,86.19 71.63,85.86 71.63,84.69 72.6,83.72 74.16,83.72 74.61,83.28 75.52,83.28 UC1.B5
GPU_GPIO0: length 5
  IN3 w0.064: v3(87.54,89.64) 85.11,87.22 85.11,86.07 v3(84.81,85.77)
GPU_GPIO2: length 5.3
  TOP w0.127: v1(83.03,80.54) 82.78,80.79 82.78,81.68 83.13,82.04 RH608.2 83.16,83.35 v7(82.91,83.59)
  GND2 w0.102: v7(82.91,83.59) 82.92,83.59 83.16,83.35 v5(83.16,83.27)
  GND3 w0.102: v5(83.16,83.27) v6(82.88,83.54)
  BOTTOM w0.127: UC1.N4 82.91,84.15 82.91,83.57 v6(82.88,83.54)
GPU_GPIO11: length 13
  IN3 w0.064: v3(88.98,91.91) 89.13,91.77 89.13,89.56 88.26,88.7 86.76,87.2 86.76,85.1 85.6,83.93 v3(85.6,83.82)
  BOTTOM w0.127: v3(88.98,91.91) 89.45,91.91 89.82,92.28 90.29,92.28 90.45,92.13 90.45,91.6 90.75,91.29 RH521.2 RH517.2
GPU_GPIO12: length 11.9
  IN3 w0.064: v3(85.6,84.47) 85.44,84.47 85.32,84.6 85.32,87.06 87.83,89.57 87.83,90.51 88.01,90.68 88.01,91.04 87.65,91.4 v3(87.65,91.73)
  BOTTOM w0.127: RH527.2 RH522.2 v1(89.2,91.29) 88.34,91.29 87.91,91.73 v3(87.65,91.73)
GPU_GPIO13: length 5.3
  BOTTOM w0.127: UC1.R3 84.88,85.12 85.16,85.4 85.16,86.62 86.97,88.42 RH528.2 87.05,88.44 87.64,89.02 RH525.2
GPU_GPIO15: length 12.8
  TOP w0.127: v7(90.8,90.68) 90.7,90.58 v1(88.49,90.58) 87.98,90.58 v7(87.7,90.86)
  GND2 w0.102: v7(87.7,90.86) v5(88.13,90.86) ; v5(91.11,90.81) 90.98,90.68 v7(90.8,90.68)
  GND3 w0.102: v5(91.11,90.81) 91.25,90.67 v6(91.47,90.67) ; v5(88.13,90.86) v8(87.73,90.86)
  IN3 w0.064: v3(84.81,84.47) 84.81,84.55 84.46,84.89 84.46,86.84 87.19,89.57 87.19,90.33 v8(87.73,90.86)
GPU_GPIO20: length 7.1
  IN3 w0.064: v3(84.02,83.82) 84.14,83.82 84.32,84 84.32,87.06 v3(86.9,89.64)
GPU_GPIO29: length 8.7
  BOTTOM w0.127: UC1.M4 82.38,84.47 82.01,84.84 82.01,88.02 83.02,89.02 v1(84.73,89.02) 85.32,88.44 RH506.2
GPU_GPIO_8_ROM_SO: length 12.3
  IN3 w0.064: v3(88.93,93.62) 88.16,92.84 88.16,91.41 88.29,91.29 88.29,90.54 88.17,90.43 v3(88.17,89.64) 88.17,89.4 85.6,86.83 v3(85.6,86.42)
  BOTTOM w0.127: RH492.2 88.17,89.21 v3(88.17,89.64) ; RP88.2 90.6,95.21 v1(89.88,94.48) 89.01,93.62 v3(88.93,93.62)
GPU_GPIO_9_ROM_SI: length 13
  IN3 w0.064: v3(88.81,89.64) 88.85,89.68 88.85,91.56 88.72,91.69 88.72,92.96 89.19,93.43 89.19,95.92 v3(89.48,96.21)
  BOTTOM w0.127: RP88.4 v1(89.86,96.21) v3(89.48,96.21) ; v3(88.81,89.64) 88.81,89.46 89.13,89.15 RH503.2 88.93,89.02 88.74,88.83 88.74,87.99 UC1.W1
GPU_GPIO_10_ROM_SCK: length 12.7
  IN3 w0.064: v3(87.17,85.77) 87.17,86.85 89.4,89.08 89.4,93.25 89.47,93.32 89.47,95.73 v3(89.48,95.74)
  BOTTOM w0.127: v3(89.48,95.74) 89.51,95.71 RP88.3
GPU_GPIO_19_CTF: length 57.3
  IN2 w0.074: v5(83.79,86.66) 83.35,86.21 80.67,86.21 79.5,85.05 79.5,82.6 79.77,82.33 79.77,81.71 79.69,81.63 79.69,81.34 79.33,80.98 79.33,79.94 79.12,79.73 76.79,79.73 75.89,78.82 74.76,78.82 72.72,76.78 72.72,60.15 72.91,59.96 72.91,59.45 72.77,59.32 72.23,59.32 72.03,59.52 72.03,62.81 68.29,66.55 59.9,66.55 v5(59.85,66.5)
  GND3 w0.102: v5(59.85,66.5) 59.79,66.44 v6(59.34,66.44)
  GND3 w0.127: v6(84.02,86.42) v5(83.79,86.66)
  BOTTOM w0.127: 57.44,64.98 58.23,64.98 RH627.1 v1(59.13,65.89) 59.34,66.1 v6(59.34,66.44)
