# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP2_CTRL_CLK: length 66.4
  TOP w0.127: v2(46.38,84.03) v1(45.95,84.03) 45.37,84.03 43.72,85.68 RT91.2
  IN1 w0.064: v4(27.58,36.88) 26.9,37.56 26.9,38.54 26.37,39.07 26.37,40.3 26.98,40.91 27.49,40.91 28.3,41.73 28.3,43.1 28.59,43.38 28.59,43.9 29.61,44.93 29.61,47.17 29.35,47.43 29.35,48.39 29.8,48.84 29.8,49.53 30.94,50.66 30.94,50.98 31.28,51.31 31.28,51.41 32.94,53.08 33.09,53.08 35.02,55.01 35.05,55.01 40.36,60.32 40.83,60.32 41.96,61.45 41.96,62.16 43.51,63.71 43.51,68.8 46.38,71.67 v2(46.38,84.03)
  GND2 w0.102: v4(27.58,36.88) 27.58,36.72 27.61,36.7 v5(27.61,36.45)
  GND3 w0.102: v5(27.61,36.45) 27.36,36.21 v6(27.36,36.2)
  IN3 w0.064: v6(27.36,36.2) 27.17,36.01 v3(27.17,34.58)
  BOTTOM w0.076: v3(27.17,34.58) 26.87,34.58 26.67,34.37 26.67,34.09 26.2,33.62 26.2,33.36
  BOTTOM w0.127: RP1.4 25.8,32.25 26.2,32.64 26.2,33.36
CPU_DP2_CTRL_CLK_R: length 3.4
  TOP w0.127: v1(41.88,85.68) RT91.1 v8(42.73,85.11)
  GND2 w0.102: v5(42.39,85.1) 42.4,85.11 v8(42.73,85.11)
  GND3 w0.102: v5(42.39,85.1) 42.4,85.11 v8(42.73,85.11)
  IN3 w0.064: v8(42.73,85.11) 42.39,85.11 v3(41.75,84.47)
CPU_DP2_CTRL_DATA: length 84
  TOP w0.127: RT92.2 38.36,88.51 38.05,88.82 38.05,92.31 v1(37.75,92.6) 37.54,92.82 v7(37.28,92.82)
  GND2 w0.102: v7(37.28,92.82) v5(36.88,92.82)
  IN2 w0.074: v5(36.88,92.82) 36.78,92.92 34.68,92.92 34.05,93.55 32.24,93.55 31.99,93.29 28.23,93.29 27.12,92.18 27.12,91.62 25.49,89.99 25.49,89.19 24.89,88.58 24.89,87.24 26.11,86.02 26.11,79.2 25.28,78.36 25.28,71.52 24.9,71.14 24.9,62.58 29.1,58.38 29.1,55.76 27.17,53.84 27.17,51.17 26.2,50.2 26.2,47.29 26.45,47.04 26.45,44.52 27.33,43.64 27.33,42.54 27.86,42 27.86,40.9 28.17,40.6 28.17,39.77 27.75,39.35 27.67,39.35 27.15,38.83 v5(27.15,38.13)
  GND3 w0.102: v6(26.74,37.67) 26.74,37.8 27.07,38.13 v5(27.15,38.13)
  IN3 w0.064: v6(26.74,37.67) 26.54,37.47 26.54,36.99 26.18,36.63 26.18,36.4 25.57,35.79 25.57,34.47 v3(25.5,34.4)
  BOTTOM w0.076: 24.6,33.36 24.6,33.5 v3(25.5,34.4) ; v6(26.74,37.67) 26.62,37.67 26.6,37.66 UH4.BD6
  BOTTOM w0.127: 24.6,33.36 24.6,32.59 24.3,32.3 RP1.1
CPU_DP2_CTRL_DATA_R: length 3.8
  TOP w0.127: RT92.1 RT81.2 38.96,87.69 v9(38.6,87.33)
  IN3 w0.064: v9(38.6,87.33) 39.15,86.78 v3(39.15,85.12)
CPU_DP2_HPD: length 73.5
  TOP w0.127: v9(46.71,89) v1(46.71,89.93)
  IN1 w0.064: v4(28.34,36.39) 28.34,36.75 27.34,37.75 27.34,38.73 26.82,39.26 26.82,40.01 27.26,40.46 27.67,40.46 28.76,41.55 28.76,42.92 29.03,43.19 29.03,43.71 30.19,44.86 30.19,47.23 29.84,47.58 29.84,47.91 30.28,48.35 30.28,49.38 31.38,50.48 31.38,50.79 31.72,51.13 31.72,51.23 32.19,51.7 33.24,51.7 34.33,52.79 34.33,53.54 34.83,54.04 35.34,54.04 36.22,54.92 36.22,55.55 40.39,59.72 41.07,59.72 42.4,61.05 42.4,61.98 43.95,63.53 43.95,68.61 46.83,71.49 46.83,87.39 46.71,87.52 v9(46.71,89)
  GND2 w0.102: v4(28.34,36.39) v5(28.67,36.06)
  GND3 w0.102: v6(28.26,36.06) v5(28.67,36.06)
  IN3 w0.064: v6(28.26,36.06) 28.08,35.88 28.08,34.71 v6(27.35,33.99)
  BOTTOM w0.076: 27.15,33.36 27.15,33.79 v6(27.35,33.99)
  BOTTOM w0.127: v9(46.71,89) 43.74,89 43.25,88.51 RT415.2 ; RH618.1 27.15,33.36
CPU_DP2_HPD_R: length 2.7
  BOTTOM w0.076: 42.58,87.26 41.76,86.44 41.76,86.05 UT2.AA2
  BOTTOM w0.127: 42.58,87.26 42.83,87.52 RT415.1
CPU_DP2_N0: length 49.1
  IN3 w0.061: 69.82,62.85 69.83,62.85 69.84,62.85 69.91,62.77 70.46,62.77 73.96,59.26 75.43,59.26 75.8,58.9 76.14,58.9 76.32,59.09 76.32,59.51 76.28,59.56 76.15,59.56 76.08,59.49 76.08,59.31 76.04,59.27 v3(75.92,59.27)
  IN3 w0.086: v3(46.87,82.76) 47,82.88 47,82.97 46.93,83.03 46.78,83.03 46.77,83.03 46.76,83.03 46.5,83.03 46.26,82.79 46.26,82.16 45.52,81.43 45.06,81.43 44.21,80.58 44.21,78.34 44.95,77.6 44.95,75.85 48.53,72.27 48.98,72.27 50.45,70.8 50.45,70.68 58.28,62.85 69.82,62.85
CPU_DP2_N0_C: length 4.3
  BOTTOM w0.076: 44.93,83.24 44.92,83.25 44.91,83.25 44.84,83.32 44.02,83.32 43.89,83.45 43.24,83.45 43.08,83.28 42.78,83.28 42.71,83.35 42.71,83.44 42.79,83.52 UT2.AC7
  BOTTOM w0.145: CT14.1 46.16,82.89 45.76,82.89 45.41,83.24 44.93,83.24
CPU_DP2_N1: length 52.3
  IN3 w0.061: 69.82,62.11 69.84,62.11 69.91,62.04 70.58,62.04 74.09,58.53 76.93,58.53 77.41,59.01 78.18,59.01 78.38,59.21 78.38,59.5 78.3,59.58 78.17,59.58 78.05,59.46 77.95,59.46 77.87,59.38 v3(77.87,59.27)
  IN3 w0.086: v3(45.25,82.16) 45.25,82.37 45.19,82.42 44.79,82.42 42.9,80.52 42.9,77.4 43.2,77.09 43.84,77.09 44.24,76.69 44.24,75.55 49.97,69.82 50.31,69.82 52.51,67.63 52.51,66.69 53.25,65.94 54.18,65.94 58.01,62.11 69.82,62.11
CPU_DP2_N1_C: length 2.5
  BOTTOM w0.076: UT2.AC9 42.79,82.6 42.73,82.54 42.73,82.43 42.8,82.36 43.08,82.36 43.24,82.53 44.01,82.53 44.18,82.37 44.46,82.37 CT15.1
CPU_DP2_N2: length 44.8
  IN3 w0.061: 69.82,63.99 69.84,63.99 69.92,64.07 70.24,64.07 73.9,60.4 77.17,60.4 77.33,60.24 77.33,60.16 v3(77.22,60.06)
  IN3 w0.086: 69.82,63.99 58.74,63.99 51.58,71.14 51.58,71.24 48.78,74.05 48.35,74.05 46.09,76.31 46.09,78.26 45.52,78.83 45.52,80.09 46.19,80.75 46.19,81.46 46.55,81.82 v3(46.9,81.82)
CPU_DP2_N2_C: length 4.2
  BOTTOM w0.076: UT2.AC11 42.77,81.68 42.7,81.74 42.7,81.83 42.78,81.91 43.1,81.91 43.25,81.76 44.14,81.76 44.28,81.62 44.84,81.62 44.91,81.7 44.93,81.7
  BOTTOM w0.145: 44.93,81.7 46.19,81.7 CT24.1
CPU_DP2_N3: length 46.7
  IN3 w0.061: 69.82,63.25 69.84,63.25 69.91,63.33 70.43,63.33 74.12,59.64 75.97,59.64 76.18,59.73 76.33,59.73 76.45,59.61 77.99,59.61 78.14,59.76 78.69,59.76 79.11,59.35 79.31,59.35 v3(79.42,59.24)
  IN3 w0.086: v3(45.25,80.94) 45.25,80.82 44.77,80.34 44.77,78.44 45.36,77.86 45.36,76.03 48.22,73.16 48.65,73.16 50.84,70.97 50.84,70.87 58.46,63.25 69.82,63.25
CPU_DP2_N3_C: length 2.5
  BOTTOM w0.076: CT18.1 44.46,80.73 44.23,80.73 44.12,80.84 43.25,80.84 43.1,80.99 42.78,80.99 42.7,80.91 42.7,80.82 42.77,80.76 UT2.AC13
CPU_DP2_P0: length 49.1
  IN3 w0.061: v3(76.57,59.27) 76.47,59.17 76.47,59.03 76.2,58.75 75.73,58.75 75.37,59.11 73.9,59.11 70.4,62.62 69.91,62.62 69.84,62.54 69.82,62.54
  IN3 w0.086: 69.82,62.54 58.16,62.54 50.14,70.56 50.14,70.67 48.85,71.96 48.4,71.96 44.64,75.72 44.64,77.47 43.9,78.22 43.9,80.71 44.93,81.74 45.4,81.74 45.95,82.29 45.95,82.92 46.38,83.34 46.78,83.34 v3(46.87,83.33)
CPU_DP2_P0_C: length 4.3
  BOTTOM w0.076: 44.93,83.55 44.91,83.55 44.84,83.48 44.09,83.48 43.96,83.61 43.23,83.61 43.11,83.73 42.67,83.73 UT2.AB7
  BOTTOM w0.145: CT13.1 46.15,83.2 45.89,83.2 45.53,83.55 v10(45.25,83.55) 44.93,83.55
CPU_DP2_P1: length 52.4
  IN3 w0.061: v3(78.63,59.24) 78.24,58.86 77.48,58.86 77,58.38 74.03,58.38 70.52,61.89 69.91,61.89 69.84,61.81 69.82,61.81
  IN3 w0.086: v3(45.24,82.73) 44.66,82.73 42.59,80.65 42.59,77.27 43.07,76.78 43.71,76.78 43.93,76.56 43.93,75.42 49.84,69.51 50.18,69.51 52.2,67.5 52.2,66.56 53.12,65.63 54.05,65.63 57.88,61.8 69.82,61.8 69.82,61.81
CPU_DP2_P1_C: length 2.5
  BOTTOM w0.076: CT23.1 44.45,82.53 44.24,82.53 44.08,82.69 43.23,82.69 43.11,82.81 42.67,82.81 UT2.AB9
CPU_DP2_P2: length 44.8
  IN3 w0.061: 69.82,64.3 69.84,64.3 69.92,64.22 70.3,64.22 73.97,60.55 77.23,60.55 77.48,60.31 77.48,60.02 77.55,59.95 77.77,59.95 v3(77.87,60.06)
  IN3 w0.086: v3(46.9,81.26) 46.97,81.34 46.97,81.44 46.89,81.51 46.68,81.51 46.5,81.33 46.5,80.62 45.83,79.96 45.83,78.96 46.4,78.39 46.4,76.44 48.47,74.36 48.9,74.36 51.89,71.37 51.89,71.27 58.87,64.3 69.82,64.3
CPU_DP2_P2_C: length 4.2
  BOTTOM w0.076: 44.93,81.39 44.91,81.39 44.84,81.46 44.21,81.46 44.08,81.59 43.26,81.59 43.12,81.45 42.68,81.45 UT2.AB11
  BOTTOM w0.145: 44.93,81.39 46.19,81.39 CT16.1
CPU_DP2_P3: length 46.6
  IN3 w0.061: v3(79.42,59.89) 79.77,59.89 79.87,59.79 79.87,59.57 79.81,59.5 79.17,59.5 78.76,59.91 78.08,59.91 77.93,59.76 76.52,59.76 76.39,59.88 76.15,59.88 75.94,59.79 74.18,59.79 70.49,63.48 69.91,63.48 69.84,63.56 69.83,63.56 69.82,63.56
  IN3 w0.086: 69.82,63.56 58.59,63.56 51.15,71 51.15,71.1 48.78,73.47 48.35,73.47 45.67,76.16 45.67,77.98 45.08,78.57 45.08,80.21 v3(45.25,80.38)
CPU_DP2_P3_C: length 2.5
  BOTTOM w0.076: UT2.AB13 42.68,80.53 43.12,80.53 43.26,80.67 44.05,80.67 44.16,80.57 44.47,80.57 CT17.1
CPU_DP3_AUXN: length 59.1
  IN3 w0.061: 72.18,66.31 72.11,66.24 72.11,65.61 74.57,63.15 75.99,63.15 76.17,63.33 76.17,63.93 76.11,63.99 v3(75.92,63.99)
  IN3 w0.086: 72.18,66.31 72.19,66.32 72.19,66.63 70.43,68.39 70.43,81.24 69.16,82.51 69.16,86.67 66.24,89.59 66.24,90.43 63.98,92.69 63.12,92.69 62.55,93.25 53.97,93.25 51.91,91.2 51.36,91.2 50.11,89.94 50.11,85.4 48.65,83.94 48.38,83.94 v3(48.26,84.07)
CPU_DP3_AUXN_C: length 7.7
  IN3 w0.086: v3(41.1,81.22) 41.59,81.49 42.29,81.49 44.28,83.48 45.39,83.48 45.98,84.07 47.67,84.07 v3(47.67,84.07)
CPU_DP3_AUXP: length 59.1
  IN3 w0.061: v3(76.57,63.99) 76.38,63.99 76.32,63.93 76.32,63.27 76.06,63 74.51,63 71.96,65.55 71.96,66.22 71.88,66.3 71.88,66.31
  IN3 w0.086: 71.88,66.31 71.88,66.5 70.12,68.26 70.12,81.11 68.85,82.38 68.85,86.54 65.93,89.46 65.93,90.3 63.85,92.38 62.99,92.38 62.43,92.94 54.1,92.94 52.04,90.89 51.49,90.89 50.42,89.81 50.42,85.27 48.78,83.63 48.38,83.63 v3(48.26,83.51)
CPU_DP3_AUXP_C: length 7.7
  IN3 w0.086: v3(47.67,83.51) 47.67,83.71 47.61,83.76 46.11,83.76 45.52,83.17 44.41,83.17 42.42,81.18 42.11,81.18 41.84,80.91 41.72,80.91 41.64,80.98 41.64,81.11 v3(41.75,81.22)
CPU_DP3_CTRL_CLK: length 99.4
  TOP w0.127: v7(45.4,83.27) v1(44.42,83.27) RT93.2
  GND2 w0.102: v5(45.38,83.6) 45.38,83.28 v7(45.4,83.27)
  IN2 w0.074: v5(45.38,83.6) 45.38,85.02 43.7,86.7 43.7,88.81 42.74,89.77 42.74,90.21 40.89,92.07 39.68,92.07 38.14,93.61 34.84,93.61 34.3,94.15 31.93,94.15 31.67,93.9 27.98,93.9 26.52,92.43 26.52,91.89 24.89,90.27 24.89,89.44 24.26,88.81 24.26,87.02 25.5,85.78 25.5,80.81 24.21,79.52 24.21,75.85 24.67,75.39 24.67,71.8 23.99,71.11 23.99,70.54 24.29,70.24 24.29,62.32 28.41,58.21 28.41,56.09 25.82,53.5 25.82,51.02 25.6,50.8 25.6,47.04 25.85,46.79 25.85,44.27 26.41,43.7 26.41,40.15 25.52,39.26 25.52,38.16 26.11,37.57 v5(26.23,37.57)
  GND3 w0.102: v5(26.23,37.57) 26.07,37.57 v6(25.89,37.4)
  BOTTOM w0.076: 22.08,35.12 22.17,35.21 22.98,35.21 25.17,37.4 v6(25.89,37.4)
  BOTTOM w0.089: 22.07,35.11 22.08,35.12
  BOTTOM w0.127: RH584.1 19.08,34.55 20.62,34.55 20.63,34.56 21.52,34.56 22.07,35.11
CPU_DP3_CTRL_CLK_R: length 3.4
  TOP w0.127: v7(42.73,83.84) RT93.1 v1(41.88,83.27)
  GND2 w0.102: v5(42.85,84.18) 42.73,84.07 v7(42.73,83.84)
  GND3 w0.102: v5(42.85,84.18) 42.67,84 v8(42.67,83.84)
  IN3 w0.064: v8(42.67,83.84) 42.42,83.84 v3(41.75,83.17)
CPU_DP3_CTRL_DATA: length 84.6
  TOP w0.127: v7(38.3,92.64) 38.3,92.08 38.39,91.99 v1(38.39,91.27) RT94.2
  GND2 w0.102: v5(37.87,92.82) 38.12,92.82 v7(38.3,92.64)
  IN2 w0.074: v5(26.79,38.82) 26.79,39.58 27.15,39.94 27.15,43.61 26.3,44.46 26.3,46.98 26.05,47.23 26.05,50.61 26.29,50.84 26.29,53.31 28.91,55.93 28.91,58.36 24.75,62.52 24.75,71.2 25.13,71.58 25.13,78.42 25.96,79.25 25.96,85.96 24.71,87.21 24.71,88.62 25.34,89.25 25.34,90.05 26.97,91.68 26.97,92.24 28.17,93.44 31.92,93.44 32.18,93.7 34.11,93.7 34.65,93.16 37.53,93.16 v5(37.87,92.82)
  GND3 w0.102: v6(26.79,38.49) v5(26.79,38.82)
  BOTTOM w0.076: 22.08,35.39 22.91,35.39 25.1,37.58 25.57,37.58 UH4.BE6 26.21,37.9 26.36,38.06 26.62,38.06 26.72,38.16 26.72,38.46 26.74,38.49 v6(26.79,38.49)
  BOTTOM w0.089: 22.07,35.39 22.08,35.39
  BOTTOM w0.127: RH586.1 18.5,34.78 21.39,34.78 22,35.39 22.07,35.39
CPU_DP3_CTRL_DATA_R: length 5.3
  TOP w0.127: v7(38.96,89.13) RT94.1
  GND2 w0.102: v5(39.11,88.8) 38.96,88.96 v7(38.96,89.13)
  GND3 w0.102: v8(39.21,88.42) 39.21,88.7 v5(39.11,88.8)
  IN3 w0.064: v8(39.21,88.42) 39.02,88.23 38.82,88.23 38.22,87.63 38.22,85.39 v3(38.5,85.12)
CPU_DP3_HPD: length 72
  IN1 w0.064: v4(29.41,37.85) 29.33,37.93 29.33,39 29.57,39.24 29.57,42.53 30.61,43.56 30.61,47.01 31.16,47.56 31.16,48.4 31.61,48.84 32.86,48.84 33.22,49.21 33.22,49.46 33.52,49.76 33.93,49.76 34.34,50.17 34.34,50.65 34.76,51.07 35.14,51.07 35.86,51.8 36.34,51.8 36.81,52.27 36.81,53.69 37.17,54.04 38.06,54.04 38.64,54.62 38.64,55.28 39.77,56.42 39.77,57.03 43.38,60.64 43.38,61.58 44.94,63.13 44.94,68.22 47.81,71.08 47.81,84.68 48.62,85.5 v4(48.64,85.5)
  GND2 w0.102: v5(48.75,85.89) 48.64,85.78 v4(48.64,85.5) ; v5(29.41,37.5) v4(29.41,37.85)
  GND3 w0.102: v6(29.39,37.13) 29.39,37.47 v5(29.41,37.5) ; v5(48.75,85.89) v8(48.39,85.89)
  IN3 w0.064: v3(41.75,83.82) 42.49,84.56 44.94,84.56 46.17,85.79 47.23,85.79 47.53,86.09 47.84,86.09 48.04,85.89 v8(48.39,85.89)
  BOTTOM w0.076: v6(29.39,37.13) 29.03,36.77 29.03,35.74 29.05,35.72 29.05,34.63 29.36,34.32 29.36,33.36
  BOTTOM w0.127: 29.36,33.36 29.36,32.52 RH619.1
CPU_DP3_N0: length 40.7
  IN3 w0.061: 69.82,64.7 69.84,64.7 69.92,64.78 70.14,64.78 73.99,60.93 75.61,60.93 75.82,61.14 75.96,61.14 76.03,61.07 76.03,60.96 v3(75.92,60.84)
  IN3 w0.086: 69.82,64.7 59.04,64.7 57.73,66.02 57.73,66.63 49.13,75.22 48.22,75.22 46.83,76.61 46.83,78.53 46.25,79.11 46.25,79.73 46.57,80.05 v3(46.9,80.05)
CPU_DP3_N0_C: length 4.1
  BOTTOM w0.076: 44.93,79.93 44.91,79.93 44.84,79.85 44.37,79.85 44.3,79.92 43.25,79.92 43.1,80.07 42.78,80.07 42.7,79.99 42.7,79.9 42.77,79.84 UT2.AC15
  BOTTOM w0.145: CT28.1 46.19,79.93 44.93,79.93
CPU_DP3_N1: length 40.3
  IN3 w0.061: 71.1,66.09 71.11,66.08 71.22,66.08 71.35,65.95 71.35,65.56 74.34,62.57 76.41,62.57 77,61.98 77.52,61.98 77.65,61.86 77.65,61.75 77.54,61.63 v3(77.22,61.63)
  IN3 w0.086: v3(47.88,78.7) 47.91,78.73 48.67,78.73 59.96,67.44 61.74,67.44 62.14,67.04 70.15,67.04 71.1,66.09
  BOTTOM w0.145: v3(47.88,78.7) 47.83,78.75 45.39,78.75 CT30.2
CPU_DP3_N1_C: length 2.4
  BOTTOM w0.076: CT30.1 44.42,78.85 43.24,78.85 43.08,78.68 42.8,78.68 42.73,78.75 42.73,78.86 42.79,78.92 UT2.AC17
CPU_DP3_N2: length 37
  IN3 w0.061: 69.82,65.72 69.84,65.72 69.92,65.64 70.18,65.64 73.96,61.85 75.5,61.85 75.72,61.63 v3(75.92,61.63)
  IN3 w0.086: v3(47.62,78.19) 47.66,78.15 47.94,78.15 48.28,77.81 48.28,76.59 48.56,76.32 49.49,76.32 58.85,66.96 58.85,66.43 59.55,65.72 69.82,65.72
  BOTTOM w0.145: CT32.2 47.02,78.15 47.58,78.15 v3(47.62,78.19)
CPU_DP3_N2_C: length 4.1
  BOTTOM w0.076: 44.93,78.15 44.91,78.15 44.84,78.08 43.25,78.08 43.1,78.23 42.78,78.23 42.7,78.15 42.7,78.06 42.77,78 UT2.AC19
  BOTTOM w0.145: 44.93,78.15 46.18,78.15 CT32.1
CPU_DP3_N3: length 40.4
  IN3 w0.061: v3(77.87,60.84) 78,60.82 78.21,60.82 78.28,60.89 78.28,61.1 78.21,61.17 76.96,61.17 75.97,62.16 74.1,62.16 70.89,65.37 70.18,66.08 70.07,66.08 70.06,66.09
  IN3 w0.086: v3(48.65,76.93) 48.72,77 49.39,77 60.06,66.33 69.83,66.33 70.06,66.09
  BOTTOM w0.145: CT34.2 45.37,76.96 48.61,76.96 v3(48.65,76.93)
CPU_DP3_N3_C: length 2.4
  BOTTOM w0.076: CT34.1 44.47,77.03 44,77.03 43.97,77.01 43.24,77.01 43.08,76.84 42.8,76.84 42.73,76.91 42.73,77.02 42.79,77.08 UT2.AC21
CPU_DP3_P0: length 40.6
  IN3 w0.061: v3(76.57,60.84) 76.48,60.75 76.25,60.75 76.18,60.82 76.18,61.13 76.03,61.29 75.76,61.29 75.54,61.08 74.06,61.08 70.2,64.93 69.92,64.93 69.84,65.01 69.82,65.01
  IN3 w0.086: 69.82,65.01 59.17,65.01 58.04,66.15 58.04,66.76 49.26,75.53 48.35,75.53 47.14,76.74 47.14,78.66 46.56,79.24 46.56,79.6 46.7,79.74 46.89,79.74 46.97,79.67 46.97,79.57 v3(46.9,79.49)
CPU_DP3_P0_C: length 4.1
  BOTTOM w0.076: UT2.AB15 42.68,79.61 43.12,79.61 43.26,79.75 44.24,79.75 44.3,79.69 44.84,79.69 44.91,79.62 44.93,79.62
  BOTTOM w0.145: 44.93,79.62 46.19,79.62 CT27.1
CPU_DP3_P1: length 40.3
  IN3 w0.061: v3(77.87,61.63) 77.8,61.7 77.8,61.92 77.59,62.13 77.06,62.13 76.48,62.72 74.4,62.72 71.5,65.62 71.5,66.02 71.33,66.19 71.33,66.3 71.31,66.31
  IN3 w0.086: v3(47.88,79.08) 47.91,79.04 48.8,79.04 60.09,67.75 61.87,67.75 62.27,67.35 70.28,67.35 71.31,66.31
  BOTTOM w0.145: v3(47.88,79.08) 47.85,79.06 45.36,79.06 CT29.2
CPU_DP3_P1_C: length 2.4
  BOTTOM w0.076: CT29.1 44.51,79.01 43.23,79.01 43.11,79.13 42.67,79.13 UT2.AB17
CPU_DP3_P2: length 37
  IN3 w0.061: 69.82,65.41 69.84,65.41 69.92,65.49 70.11,65.49 73.9,61.7 75.44,61.7 75.58,61.56 75.58,61.51 75.5,61.43 v3(75.27,61.43)
  IN3 w0.086: 69.82,65.41 59.38,65.41 58.54,66.25 58.54,66.83 49.36,76.01 48.43,76.01 47.97,76.46 47.97,77.68 47.81,77.84 47.65,77.84 v3(47.62,77.81)
  BOTTOM w0.145: v3(47.62,77.81) 47.59,77.84 47.02,77.84 CT31.2
CPU_DP3_P2_C: length 4.1
  BOTTOM w0.076: 44.93,77.84 44.91,77.84 44.84,77.91 43.26,77.91 43.12,77.77 42.68,77.77 UT2.AB19
  BOTTOM w0.145: 44.93,77.84 46.19,77.84 CT31.1
CPU_DP3_P3: length 40.4
  IN3 w0.061: 70.28,66.31 70.29,66.3 70.29,66.19 71.04,65.44 74.16,62.31 76.03,62.31 77.02,61.32 78.28,61.32 78.43,61.16 78.43,60.94 v3(78.52,60.84)
  IN3 w0.086: 70.28,66.31 69.95,66.64 60.19,66.64 49.52,77.31 v3(48.65,77.31)
  BOTTOM w0.145: v3(48.65,77.31) 48.62,77.27 45.37,77.27 CT33.2
CPU_DP3_P3_C: length 2.4
  BOTTOM w0.076: UT2.AB21 42.67,77.29 43.11,77.29 43.23,77.17 43.9,77.17 43.93,77.2 44.47,77.2 CT33.1
CPU_TRIGGER: length 65.1
  IN1 w0.064: v4(62.63,44.05) 62.63,43.39 59.93,40.68 59.93,35.95 57.55,33.57 57.55,33.31 v4(56.98,32.73)
  GND2 w0.102: v4(56.98,32.73) 56.82,32.57 v5(56.69,32.57) ; v5(63.04,44.05) v4(62.63,44.05) ; v5(69.58,53.49) v7(69.15,53.49)
  IN2 w0.074: v5(69.58,53.49) 64.68,53.49 63.7,52.51 63.7,51.42 v5(63.65,51.36)
  GND3 w0.102: v5(63.65,51.36) 63.65,51.21 v8(63.84,51.02) ; v5(56.69,32.57) 57.06,32.2 v6(57.06,31.83) ; v8(63.04,44.58) v5(63.04,44.05)
  IN3 w0.064: v8(63.04,44.58) 62.77,44.86 62.77,49.87 63.39,50.5 63.39,50.58 v8(63.84,51.02)
  BOTTOM w0.076: 34.62,33.36 33.39,34.59 UH4.AK1
  BOTTOM w0.127: v6(57.06,31.83) 57.06,30.32 54.64,27.9 v1(53.95,27.9) 50.58,24.53 44.84,24.53 41.72,27.64 38.12,27.64 34.67,31.09 34.67,33.31 34.62,33.36
CPU_TRIGGER_R: length 9.4
  TOP w0.127: v2(75.69,55.66) v1(74.49,54.46) 73.52,53.49 RH63.2
  IN1 w0.064: v2(75.69,55.66) 75.33,56.01 75.33,57.44 v4(75.43,57.54)
  GND2 w0.102: v4(75.43,57.54) v5(75.7,57.8)
  GND3 w0.102: v6(75.97,58.07) 75.97,58.07 v5(75.7,57.8)
CPU_XDP_TCK0: length 210
  IN1 w0.064: v2(141.86,81.49) 140.43,81.49 139.58,80.64 139.58,78.38 137.44,76.24 137.44,74.81 v4(136.72,74.1) 135.51,72.88 134.53,72.88 132.48,70.82 129.8,70.82 128.57,69.59 128.57,63.97 129.04,63.5 129.04,62.63 129.59,62.09 129.59,60.98 130.08,60.48 130.08,55.77 129.59,55.28 129.59,53.88 135.66,47.81 135.66,46.64 137.49,44.81 142.69,44.81 146.36,41.15 146.36,35.9 144.01,33.55 142.47,33.55 142.2,33.29 142.2,32.74 142,32.54 139.1,32.54 136.17,29.61 135.79,29.61 135.12,28.94 114.43,28.94 113.39,27.9 108.74,27.9 105.12,24.28 104.56,24.28 103.48,23.19 97.2,23.19 94.3,26.1 79.82,26.1 79.22,26.69 78.64,26.69 77.84,27.49 75.89,27.49 75.12,26.72 v4(73.66,26.72)
  GND2 w0.102: v4(73.66,26.72) v5(73.66,27.13) ; v4(136.72,74.1) 136.65,74.1 136.52,74.22 v5(136.42,74.22)
  GND3 w0.102: v5(136.42,74.22) 136.25,74.06 v8(136.12,74.06) ; v6(73.55,27.54) 73.55,27.23 v5(73.66,27.13)
  IN3 w0.064: v8(136.12,74.06) 136.05,74 132.75,74 132.59,73.83 131.68,73.83 131.24,73.39 130.88,73.39 130.6,73.67 v3(129.8,73.67)
  BOTTOM w0.076: UH4.AR3 30.56,36.47 30.88,36.15 30.88,34.96 30.93,34.91 30.93,33.36
  BOTTOM w0.127: 30.93,33.36 30.93,29.39 31,29.33 31.02,29.33 31.34,29.01 v1(31.34,27.81) 34.56,24.59 35.45,24.59 36.67,23.37 42.44,23.37 43.89,21.91 51.52,21.91 54.26,24.66 55.45,24.66 58.73,27.93 73.16,27.93 v6(73.55,27.54)
CS_CORE1: length 40
  TOP w0.127: v9(112.77,35.72) v1(112.25,35.72)
  TOP w0.203: PU1100.5 140.93,35.06 140.88,35.01 v7(140.88,34.38)
  GND2 w0.254: v7(140.88,34.38) 140.65,34.16 v5(140.6,34.16)
  VCC w0.254: v5(140.6,34.16) 137,30.56 134.34,30.56 133.58,29.8 113.51,29.8 113,30.31 113,32.98 112.24,33.74 112.24,35.26 112.7,35.72 v9(112.77,35.72)
  BOTTOM w0.203: v9(112.77,35.72) 113.01,35.96 PU1200.12
CS_CORE2: length 29.3
  TOP w0.127: v9(120.15,35.55) v1(119.67,35.55)
  TOP w0.203: PU1100.4 140.53,35.28 139.99,34.74 v7(139.99,34.38)
  GND2 w0.254: v5(139.74,34.12) 139.99,34.37 v7(139.99,34.38)
  VCC w0.254: v5(139.74,34.12) 136.81,31.2 121.38,31.2 119.67,32.91 119.67,35.32 119.9,35.55 v9(120.15,35.55)
  BOTTOM w0.203: PU1201.12 v9(120.15,35.55)
CS_CORE3: length 22.6
  TOP w0.127: v9(127.17,36.89) v1(127.71,36.89)
  TOP w0.203: PR1119.1 139.1,34.25 v9(139.16,34.31) 139.16,34.69 140.13,35.65 PU1100.3
  VCC w0.254: v9(127.17,36.89) 126.87,36.58 126.87,33.33 128.24,31.96 136.83,31.96 139.16,34.3 v9(139.16,34.31)
  BOTTOM w0.203: PU1202.12 127.24,36.95 v9(127.17,36.89)
CS_GT1: length 33.2
  TOP w0.203: PU1100.2 139.73,35.76 v1(139.16,35.2) 138.53,34.56 v9(138.53,34.31) 138.4,34.18 138.4,33.88 PR1121.1
  IN2 w0.254: v9(148.37,53.12) 148.99,52.5 148.99,48.58 147.8,47.39 147.8,41.84 v5(148.2,41.44)
  GND3 w0.254: v5(148.2,41.44) 148.17,41.46 147.91,41.46 v6(147.86,41.51)
  BOTTOM w0.203: PU1300.12 148.23,53.26 v9(148.37,53.12)
  BOTTOM w0.254: v9(138.53,34.31) 138.53,34.37 140.2,36.05 140.2,40.3 141.85,41.95 144.96,41.95 145.4,41.51 v6(147.86,41.51)
CS_GT2: length 46.3
  TOP w0.203: PR1123.1 137.89,34.26 v9(137.89,34.31) v1(137.89,34.82) 137.89,35.2 138.53,35.83 139.12,35.83 139.33,36.04 PU1100.1
  IN2 w0.254: v9(149.28,62.74) 149.28,62.67 149.74,62.21 150.58,62.21 152.02,60.77 152.02,56.62 150.52,55.12 150.52,52.38 149.32,51.19 149.32,48.28 148.23,47.19 v5(148.23,42.13)
  GND3 w0.254: v5(148.23,42.13) 148.03,41.93 148.02,41.93 148,41.91 v6(148,41.89)
  BOTTOM w0.203: PU1301.12 148.69,63.73 148.72,63.7 148.72,63.47 149.28,62.91 v9(149.28,62.74)
  BOTTOM w0.254: v6(148,41.89) 145.67,41.89 145.2,42.37 141.45,42.37 139.67,40.6 139.67,36.1 137.89,34.32 v9(137.89,34.31)
CS_SA: length 58.2
  TOP w0.127: v9(106.3,36.81) v1(105.74,36.81)
  TOP w0.203: PR1126.1 137.05,34.31 v9(137.26,34.31) 137.26,35.32 137.77,35.83 137.77,37.17 138.02,37.42 PU1100.48
  VCC w0.254: v9(137.26,34.31) 137.26,34.75 138.27,35.77 140.88,35.77 141.22,35.43 141.22,34.02 137.19,29.99 136.03,29.99 135.33,29.29 113.26,29.29 112.49,30.05 112.49,32.72 111.22,33.99 105.51,33.99 104.87,34.63 104.87,36.4 105.28,36.81 v9(106.3,36.81)
  BOTTOM w0.203: v9(106.3,36.81) 106.4,36.91 PU1302.12
CSN1: length 38.1
  TOP w0.254: v9(65.2,36.89) 64.87,36.56 v1(64.87,36.51) 64.77,36.4 PR1817.2
  IN3 w0.254: v9(65.2,36.89) 64.42,37.67 64.42,41.43 65.71,42.72 65.71,43.59 68.2,46.08 77.35,46.08 78.23,45.2 78.23,44.41 79.13,43.52 84.45,43.52 84.71,43.26 85.32,43.26 85.52,43.47 85.52,44.1 85.15,44.47 v9(85.06,44.47)
  BOTTOM w0.254: v9(65.2,36.89) 64.87,36.56 PR1854.1 ; v9(85.06,44.47) 86.91,44.47 87.17,44.72 PL1902.3
CSN2: length 12.6
  TOP w0.127: v9(69.31,44.02) v1(69.82,44.02)
  TOP w0.203: v9(65.15,40.09) PR1821.2
  IN3 w0.254: v9(69.31,44.02) 67.98,44.02 66.01,42.06 66.01,40.95 v9(65.15,40.09)
  BOTTOM w0.254: PR1855.1 64.97,39.91 v9(65.15,40.09) ; v9(69.31,44.02) 70.58,44.02 71.08,44.52 PL1904.3
CSN3: length 25.2
  TOP w0.127: v9(65.15,38.3) v1(65.68,38.3)
  TOP w0.203: PR1828.2 64.57,38.31 v9(65.15,38.3)
  IN1 w0.254: v9(76.11,44.66) 75.4,45.37 67.87,45.37 63.88,41.38 63.88,38.98 64.56,38.3 v9(65.15,38.3)
  BOTTOM w0.254: PR1857.1 65.06,38.21 v9(65.15,38.3) ; v9(76.11,44.66) 79.02,44.66 79.18,44.82 PL2001.3
CSN4: length 39.4
  TOP w0.127: v2(63.29,42.82) v1(63.29,43.82)
  TOP w0.203: v2(63.29,42.82) PR1834.2
  IN1 w0.254: v2(63.29,42.82) 64.77,44.29 64.77,45.29 65.3,45.83 75.64,45.83 76.17,45.29 79.09,45.29 79.75,45.95 90.24,45.95 90.93,45.27 94.34,45.27 v9(95.27,44.34)
  BOTTOM w0.254: PL2202.3 95.91,45.1 95.27,44.47 v9(95.27,44.34)
CSN_VDD12: length 56.1
  TOP w0.127: v1(65.5,29.55) 65.06,29.1 v7(64.56,29.1)
  IN1 w0.254: v4(59.74,30.53) 61.53,30.53 62.96,29.1 v7(64.56,29.1)
  GND2 w0.254: v4(59.74,30.53) v5(60.23,30.53)
  IN2 w0.254: v5(60.23,30.53) 60.23,39.93 57.97,42.19 57.97,46.94 56.21,48.7 56.21,51.92 54.48,53.65 54.48,58.17 59.03,62.72 66.14,62.72 67.13,61.73 v9(67.13,58.76)
  BOTTOM w0.254: PL2201.3 v9(67.13,58.76)
CSP1: length 38.4
  TOP w0.127: v9(66.58,45.12) v1(67.2,45.12)
  TOP w0.254: v9(66.58,45.12) 66.32,44.85 PR1841.2 ; PR1819.1 65.21,34.7 v9(65.36,34.85)
  IN3 w0.254: v9(85.06,43.83) 84.85,44.05 79.35,44.05 78.76,44.63 78.76,45.42 77.57,46.61 68.08,46.61 v9(66.58,45.12) 65.07,43.6 65.07,43.01 63.92,41.85 63.92,37.1 65.36,35.65 v9(65.36,34.85)
  BOTTOM w0.254: PL1902.2 87.17,43.58 86.91,43.83 v9(85.06,43.83)
CSP2: length 13
  TOP w0.203: v9(65.16,39.2) PR1824.1
  TOP w0.254: PR1845.2 66.58,43.39 v1(68.42,43.39) v9(69.31,43.39)
  IN3 w0.254: v9(65.16,39.2) 66.52,40.56 66.52,41.87 68.04,43.39 v9(69.31,43.39)
  BOTTOM w0.254: v9(69.31,43.39) 70.58,43.39 71.08,42.9 PL1904.2
CSP3: length 23.5
  TOP w0.127: PR1847.2 v1(66.33,41.23)
  IN1 w0.254: v2(64.56,37.42) 65.44,37.42 66,37.98 66,42.11 v2(66.34,42.45) 66.34,42.93 68.37,44.86 75.14,44.86 75.96,44.05 v9(76.11,44.05)
  BOTTOM w0.254: v9(76.11,44.05) 78.79,44.05 79.18,43.66 PL2001.2
CSP4: length 39.5
  TOP w0.254: v2(62.96,45.29) 62.58,45.29 61.95,45.93 PR1837.1 60.98,46.23 PR1849.2
  IN1 w0.254: v9(95.91,44.34) 95.91,44.35 94.59,45.68 91.03,45.68 90.39,46.31 79.64,46.31 78.96,45.62 76.31,45.62 75.75,46.18 63.85,46.18 v2(62.96,45.29)
  BOTTOM w0.254: PL2202.2 v9(95.91,44.34)
CSP_VDD12: length 54.2
  TOP w0.127: v1(64.8,25.86) 64.55,26.12 PR1867.2
  TOP w0.203: v7(64.56,28.35) PR1866.2 64.56,27.15 PR1867.2
  GND2 w0.254: v5(64.14,28.8) 64.14,28.77 64.55,28.35 v7(64.56,28.35)
  IN2 w0.254: v9(66.52,58.76) 66.52,61.49 65.89,62.12 58.94,62.12 54.96,58.15 54.96,53.89 56.71,52.13 56.71,48.66 58.3,47.07 58.3,42.32 61.03,39.59 61.03,31.17 63.41,28.8 v5(64.14,28.8)
  BOTTOM w0.254: v9(66.52,58.76) PL2201.2
CSSUMA: length 12.8
  TOP w0.127: PR1119.2 139.34,32.53 v1(140.24,32.53)
  TOP w0.203: v2(140.88,33.47) PR1118.2 139.8,33.47 PR1119.2 ; PU1100.18 v2(145.43,39.42)
  IN1 w0.254: v2(145.43,39.42) 145.43,36.68 143.64,34.88 142.27,34.88 v2(140.88,33.47)
CSSUMB: length 14.5
  TOP w0.203: PU1100.19 145.72,39.82 v2(145.77,39.77)
  TOP w0.254: v2(138.21,32.77) PR1123.2
  IN1 w0.254: v2(138.21,32.77) 138.54,33.1 141.12,33.1 142.36,34.35 143.71,34.35 145.79,36.42 145.79,39.75 v2(145.77,39.77)
CSSUMC: length 18.5
  TOP w0.127: 136.43,32.72 v1(135.42,31.71)
  TOP w0.203: PU1100.20 v2(145.45,40.22) ; PR1126.2 136.43,32.66 136.81,32.28 v2(137.89,32.28)
  IN1 w0.254: v2(137.89,32.28) 138.34,32.28 138.83,32.77 141.32,32.77 142.34,33.79 143.79,33.79 146.12,36.12 146.12,39.92 145.82,40.22 v2(145.45,40.22)
DAT_TP_SIO_I2C_CLK: length 38.3
  TOP w0.127: v1(27.59,8.4) 26.88,8.4 v9(26.41,8.87) ; UE3.C12 49.89,16.13 50.52,16.13 v7(50.77,15.88)
  IN1 w0.064: v4(36.28,19.7) 34.92,18.34 33.72,18.34 33.07,17.68 30.11,17.68 28.57,16.15 28.57,14.89 26.41,12.73 v9(26.41,8.87)
  GND2 w0.102: v5(36.61,19.7) v4(36.28,19.7) ; v5(50.9,15.58) 50.9,15.75 v7(50.77,15.88)
  GND3 w0.102: v8(37.01,19.55) 36.85,19.7 v5(36.61,19.7) ; v8(50.79,15.89) 50.9,15.78 v5(50.9,15.58)
  IN3 w0.064: v8(37.01,19.55) 38.48,18.08 49,18.08 50.79,16.29 v8(50.79,15.89)
  BOTTOM w0.127: JKB1.24 26.42,8.86 v9(26.41,8.87)
DB_SEN_I2C_SCK: length 250.1
  TOP w0.127: RR34.2 13.15,21.75 v7(13.59,22.18) ; v2(141.16,27.22) 141.08,27.3 141.08,28.18 142.06,29.17 146.44,29.17 148.82,31.54 148.82,33.22 150.87,35.28 150.87,36.89 150.78,36.98 150.78,44.64 149.96,45.46 149.96,46.93 v2(149.99,46.97)
  IN1 w0.064: v2(141.16,27.22) 141.06,27.13 141.06,26.64 140.43,26.02 140.43,22.94 136.56,19.07 134.04,19.07 125.34,10.37 121.32,10.37 121.18,10.23 121.18,10.1 v9(121.4,9.89) ; v2(149.99,46.97) 149.89,47.06 149.89,47.98 148.42,49.45 148.42,52.48 147.16,53.74 147.16,57.74 145.46,59.44 145.46,60.27 146.88,61.69 147.78,61.69 148.07,61.98 148.07,62.8 147.86,63 147.86,67.61 145.86,69.61 145.86,72.47 147.27,73.88 147.27,77.49 146.96,77.8 146.96,80.74 144.47,83.24 144.47,89.97 145.75,91.26 145.75,95.7 146.45,96.4 146.45,99.43 146.08,99.81 145.71,99.81 v4(145.61,99.9)
  GND2 w0.102: v5(13.92,22.31) 13.71,22.31 v7(13.59,22.18) ; v4(145.61,99.9) 145.54,99.83 145.39,99.83 v5(145.23,99.98)
  IN2 w0.074: v5(104.06,24.85) 103.68,24.47 103.15,24.47 102.99,24.62 94.56,24.62 93.14,26.04 91.94,26.04 91.33,25.43 91.33,24.16 87.75,20.58 87.75,19.72 85.39,17.35 85.39,16.52 85.39,15.9 82.94,13.46 78.3,13.46 77.66,12.82 53.9,12.82 53.24,13.48 52.69,13.48 52.31,13.1 47.99,13.1 47.74,13.36 43.85,13.36 43.04,14.17 40.95,14.17 40.6,14.52 35.03,14.52 34.1,15.45 31.85,15.45 30.68,16.62 28.68,16.62 24.76,20.54 18.22,20.54 16.25,22.51 14.12,22.51 v5(13.92,22.31)
  GND3 w0.102: v5(145.23,99.98) 145.2,99.94 v6(144.84,99.94) ; v8(104.11,24.52) 104.06,24.57 v5(104.06,24.85)
  IN3 w0.064: v9(121.4,9.89) 121.16,10.1 121.16,10.11 121.16,10.19 121.16,11.88 118.22,14.81 117.64,14.81 116.09,16.36 116.09,18.95 114.34,20.7 110.17,20.7 109.92,20.95 105.67,20.95 105.38,21.23 105.38,22.82 103.98,24.21 103.98,24.39 v8(104.11,24.52)
  BOTTOM w0.127: v6(144.84,99.94) 144.78,99.88 144.4,99.88 144.23,100.05 JCAM1.15
DB_SEN_I2C_SDA: length 249.2
  TOP w0.127: v2(149.61,46.97) 149.7,46.87 149.7,45.36 150.53,44.53 150.53,36.87 150.61,36.79 150.61,35.38 148.56,33.33 148.56,31.64 146.34,29.42 141.96,29.42 140.83,28.29 140.83,27.27 v2(140.78,27.22) ; RR35.2 13.41,22.48 13.61,22.69 v7(13.61,22.74)
  IN1 w0.064: v9(120.76,9.86) 120.99,10.09 120.99,10.31 121.24,10.56 125.26,10.56 133.96,19.26 136.48,19.26 140.24,23.02 140.24,26.09 140.87,26.72 140.87,27.13 v2(140.78,27.22) ; v2(149.61,46.97) 149.7,47.06 149.7,47.9 148.23,49.37 148.23,52.41 146.97,53.66 146.97,57.66 145.27,59.36 145.27,60.35 146.81,61.88 147.7,61.88 147.88,62.06 147.88,62.72 147.67,62.92 147.67,67.53 145.67,69.54 145.67,72.55 147.08,73.96 147.08,77.41 146.77,77.72 146.77,80.66 144.27,83.16 144.27,90.05 145.56,91.34 145.56,95.78 146.26,96.48 146.26,99.35 146,99.62 145.71,99.62 v4(145.61,99.52)
  GND2 w0.102: v5(13.92,22.87) 13.79,22.87 13.66,22.74 v7(13.61,22.74) ; v5(145.23,99.45) 145.39,99.6 145.54,99.6 v4(145.61,99.52)
  IN2 w0.074: v5(13.92,22.87) 13.92,22.84 14.05,22.71 16.34,22.71 18.31,20.74 24.84,20.74 28.77,16.82 30.76,16.82 31.93,15.65 34.19,15.65 35.12,14.72 40.68,14.72 41.04,14.37 43.12,14.37 43.93,13.56 47.82,13.56 48.08,13.3 52.23,13.3 52.61,13.68 53.32,13.68 53.98,13.02 77.58,13.02 78.22,13.66 82.86,13.66 85.19,15.99 85.19,16.44 85.19,17.43 87.55,19.8 87.55,20.66 91.13,24.24 91.13,25.51 91.86,26.24 93.22,26.24 94.64,24.82 103.08,24.82 103.23,24.67 103.32,24.67 v5(103.5,24.84)
  GND3 w0.102: v5(103.5,24.84) 103.67,24.68 v8(103.67,24.53) ; v6(144.84,99.56) 145.12,99.56 v5(145.23,99.45)
  IN3 w0.064: v8(103.67,24.53) 103.79,24.4 103.79,24.13 105.19,22.74 105.19,21.15 105.59,20.76 109.84,20.76 110.09,20.51 114.26,20.51 115.9,18.87 115.9,16.28 117.56,14.62 118.14,14.62 120.97,11.8 120.97,10.18 120.97,10.1 120.97,10.09 v9(120.76,9.86)
  BOTTOM w0.127: JCAM1.16 144.3,99.55 144.37,99.62 144.78,99.62 v6(144.84,99.56)
DBC_EN: length 65
  IN1 w0.064: v4(30.27,47.73) 30.61,48.07 30.61,49.24 31.39,50.02 31.86,50.02 32.14,50.3 32.14,50.82 32.44,51.11 32.85,51.11 35.36,53.62 35.36,53.86 36.36,54.86 36.36,55.49 38.84,57.97 40.45,59.58 41.13,59.58 42.54,60.99 42.54,61.92 44.09,63.47 44.09,68.55 46.97,71.43 46.97,87.4 47.23,87.66 47.23,89.32 50.4,92.49 50.4,93.15 53.22,95.97 v4(54.18,95.97)
  GND2 w0.102: v4(54.18,95.97) 54.29,96.07 v5(54.5,96.07) ; v5(29.94,47.73) v4(30.27,47.73)
  IN2 w0.074: v5(55.41,93.87) 55.09,93.87 54.5,94.46 v5(54.5,96.07)
  GND3 w0.102: v6(29.59,47.73) v5(29.94,47.73) ; v5(55.41,93.87) v6(55.41,94.24)
  BOTTOM w0.107: UH4.AW27 28.93,47.73 v6(29.59,47.73)
DBGDATA0: length 6.2
  BOTTOM w0.127: RH495.2 78.52,90.01 78.98,89.55 v1(78.98,89.44) 78.98,84.79 UC1.G4
DBGDATA1: length 5
  BOTTOM w0.127: UC1.H2 79.71,86.15 79.71,86.64 80.11,87.04 v1(80.11,88.72) 80.11,89.86 RH496.2
DBGDATA2: length 11.3
  TOP w0.127: v9(72.84,85.9) v1(72.26,85.9)
  IN2 w0.074: v5(79.15,84.2) 79.15,84.63 77.59,86.2 76.88,86.2 76.44,86.63 73.27,86.63 72.84,86.21 v9(72.84,85.9)
  GND3 w0.102: v5(79.15,84.2) 79.3,84.05 v6(79.3,83.82)
  BOTTOM w0.127: v9(72.84,85.9) 71.79,86.95 RH497.2
DBGDATA3: length 4.2
  BOTTOM w0.127: RH498.2 79.09,89.95 79.61,89.44 79.61,87.05 79.3,86.74 UC1.G1
DBGDATA4: length 5
  BOTTOM w0.127: RH499.2 77.95,87.6 78.75,86.81 78.75,86.01 UC1.F2
DBGDATA5: length 5.9
  BOTTOM w0.127: UC1.F3 78.18,85.46 78.18,85.9 78.52,86.24 78.52,86.71 77.54,87.69 77.54,90.15 RH500.2
DBGDATA6: length 4.9
  BOTTOM w0.127: UC1.E2 77.77,86.49 77.2,87.05 77.2,89.82 76.81,90.21 RH501.2
DBGDATA7: length 9.9
  TOP w0.127: v9(73.37,86.2) v1(73.37,86.81)
  IN2 w0.074: v9(73.37,86.2) 73.62,86.46 76.37,86.46 76.8,86.02 77.51,86.02 78.03,85.51 v5(78.03,85.22)
  GND3 w0.102: v5(78.03,85.22) 78.08,85.17 v6(78.08,84.82)
  BOTTOM w0.127: v9(73.37,86.2) 72.05,87.52 RH502.2 ; UC1.F4 v6(78.08,84.82)
DCI_CLK: length 116.7
  TOP w0.127: v2(78.01,20.97) 78.01,15.74 v1(76.65,14.38) 75.29,13.02 v2(75.29,12.91)
  IN1 w0.064: v2(75.29,12.91) 78.1,12.91 78.94,12.07 82.01,12.07 82.43,11.65 83.33,11.65 84.3,10.68 88.89,10.68 89.11,10.46 92.76,10.46 93.46,11.16 97.99,11.16 98.99,12.16 103.3,12.16 104.01,12.87 v4(104.07,12.87) ; v4(32.27,51.41) 32.27,51.37 31.57,50.66 31.57,50.6 31.55,50.58 31.55,50.41 30.44,49.31 30.44,48.29 30,47.85 30,47.61 30.33,47.29 30.33,43.72 29.12,42.51 29.12,41.14 28.07,40.09 28.02,40.09 27.83,39.9 27.47,39.9 27.3,40.07 27.11,40.07 26.95,39.92 26.95,39.31 27.48,38.78 27.48,37.81 31.94,33.35 38.33,33.35 41.77,29.91 46.93,29.91 47.28,30.25 52.45,30.25 54.13,28.57 55.28,28.57 55.94,27.91 60.98,27.91 62.06,26.82 65.27,26.82 68.93,23.16 74.34,23.16 75.9,21.61 76.9,21.61 77.54,20.97 v2(78.01,20.97)
  GND2 w0.102: v5(32.36,51.82) 32.27,51.74 v4(32.27,51.41) ; v5(104.7,12.87) v4(104.07,12.87)
  GND3 w0.102: v5(32.36,51.82) 32.36,51.97 v6(32.61,52.22) ; v6(105.06,12.9) 105.03,12.87 v5(104.7,12.87)
DCI_DATA: length 118.9
  TOP w0.127: v2(83.01,12.91) 82.32,13.59 82.32,18.17 83.08,18.93 v1(83.08,20.59) v2(83.08,21.25)
  IN1 w0.064: v4(33.05,54.37) 32.87,54.37 31.54,53.04 31.54,52.66 31.11,52.23 30.49,52.23 30.06,51.8 30.06,50.71 29.04,49.69 29.04,48.9 28.52,48.38 28.52,48 28.05,47.54 28.05,47.16 28.49,46.72 28.49,45.33 28.01,44.84 28.01,43.63 27.64,43.27 27.64,42.64 27.44,42.44 27.44,41.74 27.25,41.55 26.79,41.55 25.76,40.52 25.76,38.85 26.01,38.61 26.01,37.84 26.31,37.54 26.31,37.33 27.65,35.99 28.75,35.99 31.93,32.82 38.13,32.82 41.18,29.77 46.99,29.77 47.34,30.11 52.39,30.11 54.07,28.43 55.22,28.43 55.88,27.77 58.04,27.77 59.12,26.68 65.21,26.68 68.87,23.02 74.28,23.02 75.84,21.47 76.84,21.47 78.25,20.07 80.22,20.07 81.29,21.13 82.97,21.13 v2(83.08,21.25) ; v4(104.37,13.9) 103.84,13.9 103.39,13.45 102.82,13.45 102.39,13.02 98.34,13.02 97.86,12.55 94.01,12.55 93.61,12.14 90.68,12.14 89.97,12.85 83.06,12.85 v2(83.01,12.91)
  GND2 w0.102: v5(104.7,13.9) v4(104.37,13.9) ; v4(33.05,54.37) 33.21,54.53 v5(33.39,54.53)
  GND3 w0.102: v5(104.7,13.9) v6(105.06,13.9) ; v6(33.76,54.53) v5(33.39,54.53)
DCIN1_EN: length 88.5
  TOP w0.127: PR247.1 30.1,70.91 29.94,70.76 29.94,69.99 29.76,69.81 29.75,69.81 29.7,69.75 28.62,69.75 28.38,69.51 28.38,68.18 28.71,67.85 28.71,64.64 26.97,62.9 26.97,62.12 28.3,60.79 v1(28.55,60.79) 28.97,60.79 v2(29.49,60.27)
  IN1 w0.064: v4(28.57,19.5) 28.57,19.57 29.53,20.53 29.95,20.53 31.24,21.82 31.24,26.23 29.15,28.32 29.15,31.91 28.68,32.38 26.04,32.38 23.9,34.52 23.9,36.15 23.52,36.53 23.52,41.09 23.12,41.49 23.12,44.33 23.83,45.04 23.83,54.05 29.49,59.71 v2(29.49,60.27)
  GND2 w0.102: v5(28.23,19.16) 28.57,19.5 v4(28.57,19.5) ; v5(42.81,9.9) 43.1,10.19 v8(43.15,10.19)
  GND3 w0.102: v8(43.15,10.19) 42.86,9.9 v5(42.81,9.9) ; v5(28.23,19.16) 27.8,19.16 v8(27.48,18.84)
  IN3 w0.064: v8(43.15,10.19) 42.38,10.19 41.39,9.19 38.29,9.19 38.03,9.19 37.52,9.71 35.85,9.71 35.55,10.01 33.97,10.01 32.3,11.68 31.96,11.68 28.81,14.83 28.81,15.25 27.51,16.55 27.51,18.81 v8(27.48,18.84)
DCIN2_EN: length 180.2
  TOP w0.127: v2(49.16,7.45) 49.16,9 UE3.L12
  IN1 w0.064: v4(36.65,98.2) 36.65,100.22 37.6,101.17 37.6,104.41 36.92,105.09 v2(36.51,105.09) ; v2(49.16,7.45) 48.93,7.45 48.52,7.04 48.52,5.57 45.22,2.27 36.96,2.27 36.56,2.67 31.14,2.67 30.54,2.08 16.33,2.08 12.1,6.31 5.85,6.31 2.26,9.9 2.26,19.65 3.4,20.79 3.4,26.18 4.64,27.42 4.64,43.76 5.03,44.14 5.03,48.12 4.1,49.05 4.1,53.3 9.65,58.86 14.55,58.86 16.02,60.33 v4(16.38,60.33)
  GND2 w0.102: v5(16.05,60.51) 16.2,60.51 v4(16.38,60.33) ; v4(36.65,98.2) v5(36.65,97.8)
  IN2 w0.074: v5(16.05,60.51) 16.4,60.86 16.75,60.86 19.59,63.7 19.59,69.95 21.45,71.81 21.45,79.61 23.33,81.48 23.33,83.36 22.08,84.61 21.01,84.61 20.4,85.22 20.4,87.35 22.64,89.59 22.64,93.78 23.74,94.88 26.48,94.88 27.03,95.43 31.22,95.43 31.9,96.1 31.9,96.84 32.58,97.53 33.79,97.53 34.17,97.15 36.01,97.15 v5(36.65,97.8)
DCIN3_EN: length 90.7
  TOP w0.127: v7(42.01,9.81) 42.01,9.85 UE3.K3 ; v7(87.79,2.69) 87.41,3.07 v1(87.41,3.73) 87.41,12.53 v2(87.35,12.59)
  IN1 w0.064: v4(111.83,14.35) 111.83,14.2 111.61,13.97 111.35,13.97 111.23,14.08 110.95,14.08 110.29,13.42 109.62,13.42 109.06,13.98 104.83,13.98 104.48,13.63 103.77,13.63 103.45,13.31 102.87,13.31 102.45,12.88 98.4,12.88 97.92,12.41 94.21,12.41 93.8,12 90.63,12 89.91,12.71 87.47,12.71 v2(87.35,12.59)
  GND2 w0.102: v5(41.95,9.45) 41.95,9.75 v7(42.01,9.81) ; v5(112.37,14.58) 112.14,14.35 v4(111.83,14.35) ; v5(87.79,2.11) v7(87.79,2.69)
  GND3 w0.102: v8(87.79,1.73) v5(87.79,2.11) ; v8(41.93,8.57) 41.93,9.44 v5(41.95,9.45) ; v6(113.06,14.9) 112.79,14.9 112.47,14.58 v5(112.37,14.58)
  IN3 w0.064: v8(41.93,8.57) 41.95,8.57 43.89,6.62 44.3,6.62 44.41,6.51 44.41,6.26 45.44,5.23 45.69,5.23 46.8,4.12 50.95,4.12 51.23,4.4 52.25,4.4 52.81,3.84 54.87,3.84 55.22,3.49 56.55,3.49 57.88,2.15 69.14,2.15 69.53,2.54 73.96,2.54 74.21,2.3 78.46,2.3 78.61,2.44 v8(78.63,2.44) 79.22,3.03 80.43,3.03 81.28,2.18 84.2,2.18 84.65,1.73 v8(87.79,1.73)
DCIN4_EN: length 68.3
  TOP w0.127: v7(41.91,12.78) 41.91,12.45 41.55,12.1 UE3.H2
  GND2 w0.102: v5(42.24,12.64) 42.2,12.64 42.19,12.65 42.04,12.65 v7(41.91,12.78)
  IN2 w0.074: v5(86.14,11.55) 84.9,12.79 78.72,12.79 78.04,12.11 67.7,12.11 67.15,11.57 59.55,11.57 58.92,12.2 44.12,12.2 44.01,12.3 42.91,12.3 42.57,12.64 v5(42.24,12.64)
  GND3 w0.102: v6(85.72,11.32) 85.95,11.55 v5(86.14,11.55)
  IN3 w0.064: v3(86.18,8.62) 86.48,8.92 94.53,8.92 94.71,8.74 98.36,8.74 99.71,10.08 102.24,10.08 v3(103.06,10.9)
  BOTTOM w0.127: v3(86.18,8.62) 86.18,9.43 85.72,9.88 v1(85.72,10.88) v6(85.72,11.32)
DDR_A_ACT#: length 58.6
  IN1 w0.064: v2(141.39,104.08) 140.1,104.08 139.55,104.62 137.77,104.62 137.58,104.43 137.2,104.43 v12(137.07,104.29) 137.04,104.32 136.63,104.32 136.26,104.69 v14(134.27,104.69) 134,104.43 133.36,104.43 133.07,104.71 127.47,104.71 127.18,104.43 126.81,104.43 v12(126.67,104.29) 126.54,104.43 126.13,104.43 125.89,104.66 123.9,104.66 v14(123.87,104.69) 123.61,104.43 122.96,104.43 122.65,104.74 121.07,104.74
  IN1 w0.097: 121.07,104.74 120.18,103.84 120.18,88.3 120.14,88.27 120.14,88.05 120.3,87.89 120.47,87.89 120.95,87.42 121.32,87.42 121.56,87.18 121.56,83.07 121.42,82.93 121.42,82.08 121.28,81.95 120.76,81.95 120.68,81.88 120.68,81.63 120.77,81.54 121.13,81.54 121.42,81.26 121.42,80.95 121.31,80.85 119.9,80.85 119.77,80.98 119.77,83.66 119.73,83.71 119.73,84.62 119.34,85 119.34,85.99 118.91,86.42 118.59,86.42 118.41,86.24 118.41,85.77 v6(118.73,85.45)
  BOTTOM w0.127: UD4.L3 v14(123.87,104.69) ; UC1.CH3 119.06,85.12 v6(118.73,85.45) ; UD3.L3 v14(134.27,104.69)
DDR_A_ALERT#: length 90.2
  TOP w0.127: UD1.P9 132.67,107.09 v8(135.87,107.09) ; UD2.P9 122.27,107.09 v8(125.47,107.09)
  IN3 w0.064: v3(119.1,83.82) 118.28,83.82 117.95,83.5 115.76,83.5 115.44,83.81 115.44,84.97 115.22,85.18 115.22,85.23 115.03,85.42 114.94,85.42 113.41,86.95 113.41,88.45 117.82,92.86 117.82,106.26 122.52,110.96 135.41,110.96 136.35,110.02 137.28,110.02 138.12,109.18 138.12,108.06 137.66,107.61 137.25,107.61 136.74,107.09 v8(135.87,107.09) 135,107.09 134.88,107.21 134.44,107.21 134.32,107.09 v14(134.27,107.09) 134,107.36 133.36,107.36 133.2,107.2 131.37,107.2 131.19,107.38 127.7,107.38 127.48,107.61 126.86,107.61 126.34,107.09 v8(125.47,107.09) 124.6,107.09 124.49,107.21 123.99,107.21 v14(123.87,107.09) 123.61,107.36 122.91,107.36 122.57,107.01 121.28,107.01 v3(119.78,105.52)
  BOTTOM w0.127: v14(134.27,107.09) 138.27,107.09 UD3.P9 ; UD4.P9 127.87,107.09 v14(123.87,107.09)
DDR_A_BA0: length 57.7
  TOP w0.127: UD1.N2 v8(138.27,106.29) ; UD2.N2 v8(127.87,106.29)
  IN3 w0.064: 141.54,110.64 141.54,109.81 139.9,108.17 139.9,106.92 139.28,106.29 v8(138.27,106.29) 137.98,106 136.8,106 136.43,105.63 134.56,105.63 134.16,106.02 133.2,106.02 v14(133.07,105.89) 132.99,105.81 132.03,105.81 131.97,105.87 128.8,105.87 128.38,106.29 v8(127.87,106.29) 127.58,106 126.41,106 126.03,105.63 124.11,105.63 123.98,105.75 123.41,105.75 123.14,106.02 122.8,106.02 v14(122.67,105.89) 122.61,105.83 122.61,105.41 121.86,104.66 121.07,104.66
  IN3 w0.097: v3(116.84,84.15) 117.07,84.37 117.07,85.65 116.62,86.1 116.62,88.13 118.48,89.99 119.85,89.99 120.1,90.24 120.1,104.1 120.66,104.66 121.07,104.66 ; 141.54,110.64 141.54,111.17 141.78,111.41 142.48,111.41 v3(142.76,111.13)
  BOTTOM w0.127: UC1.BT5 111.88,84.15 v3(116.84,84.15)
DDR_A_BA1: length 66.8
  TOP w0.127: UD2.N8 123.07,105.49 v8(126.27,105.49) ; UD1.N8 133.47,105.49 v8(136.67,105.49)
  IN3 w0.064: 121.07,104.41 121.84,104.41 122.77,105.34 122.77,105.56 122.97,105.76 123.18,105.76 123.44,105.49 v14(123.87,105.49) 124.01,105.36 126.14,105.36 v8(126.27,105.49) 126.54,105.76 128.64,105.76 128.81,105.58 133.16,105.58 133.4,105.82 133.58,105.82 133.92,105.49 v14(134.27,105.49) 134.4,105.36 136.53,105.36 v8(136.67,105.49) 136.98,105.8 139.1,105.8 140.17,106.88 140.17,107.87 141.93,109.63 141.93,110.64
  IN3 w0.097: v3(117.03,87.45) 117.29,87.71 117.29,88.37 118.67,89.74 120.08,89.74 120.35,90.02 120.35,104 120.76,104.41 121.07,104.41 ; 141.93,110.64 141.93,110.88 v3(142.19,111.13)
  BOTTOM w0.127: UD4.N8 127.07,105.49 v14(123.87,105.49) ; v14(134.27,105.49) 137.47,105.49 UD3.N8 ; v3(117.03,87.45) 116.85,87.27 114.29,87.27 113.99,86.97 112.1,86.97 UC1.BT1
DDR_A_BG0: length 58.7
  IN1 w0.064: v2(142.56,104.08) 142.29,104.35 140.11,104.35 139.55,104.91 138.05,104.91 v12(137.87,105.09) 137.74,104.96 136.57,104.96 136.44,104.83 136.16,104.83 136.04,104.95 134.9,104.95 134.78,104.83 134.5,104.83 134.37,104.96 133.73,104.96 v14(133.47,104.69) 133.17,104.99 127.58,104.99 v12(127.47,105.09) 127.34,104.96 126.16,104.96 126.03,104.83 124.15,104.83 124.02,104.96 123.76,104.96 123.5,104.69 v14(123.07,104.69) 122.78,104.98 121.07,104.98
  IN1 w0.097: 121.07,104.98 120.91,104.98 119.93,104 119.93,87.94 120.73,87.13 121.19,87.13 121.33,87 121.33,83.88 121.23,83.78 120.84,83.78 120.75,83.69 120.75,83.49 120.84,83.4 121.23,83.4 121.33,83.3 121.33,83.1 121.25,83.02 120.88,83.02 120.78,82.93 120.78,82.73 120.83,82.69 121.16,82.69 121.23,82.62 121.23,82.37 121.12,82.26 120.58,82.26 120.5,82.18 120.5,81.3 120.43,81.24 120.18,81.24 120.11,81.3 120.11,83.01 120.25,83.15 120.25,84.59 120.05,84.79 119.86,84.79 119.53,85.13 119.53,86.06 118.84,86.75 v6(118.73,86.75)
  BOTTOM w0.127: UD4.M2 v14(123.07,104.69) ; UC1.CH1 119.06,86.42 v6(118.73,86.75) ; UD3.M2 v14(133.47,104.69)
DDR_A_BG1: length 57.6
  TOP w0.127: RD240.2 129.83,102.76 129.83,102.67
  TOP w0.191: 129.83,102.67 v7(129.82,102.66) ; v7(141.65,100.62) 141.47,100.44 RD238.2
  GND2 w0.102: v5(129.8,103.07) 129.8,102.67 v7(129.82,102.66) v5(129.82,102.16) ; v7(141.65,100.62) v5(141.27,100.62)
  IN2 w0.114: v5(129.82,102.16) 130.4,101.58 136.94,101.58 137.23,101.87 140.65,101.87 141.27,101.25 v5(141.27,100.62) ; v5(120.81,102.7) 120.81,101.89 121.53,101.17 123.86,101.17 124.47,101.78 128.38,101.78 129.16,102.56 129.29,102.56 v5(129.8,103.07)
  GND3 w0.102: v5(120.81,102.7) 120.81,103.46 v6(120.98,103.63) ; v5(129.8,103.07) 129.92,103.18 v6(129.92,103.78)
  BOTTOM w0.076: UC1.CH2 119.55,86.22 119.55,86.58 119.86,86.89 122.04,86.89 122.22,87.07
  BOTTOM w0.127: RD242.2 130.07,103.62 v6(129.92,103.78)
  BOTTOM w0.191: v6(120.98,103.63) RD244.2 119.54,103.83 118.16,103.83 117.88,103.56 v1(117.88,102.31) 117.88,95.66 115.93,93.71 115.93,92.36 117.08,91.22 120.38,91.22 122.51,89.08 122.51,87.36 122.22,87.07
DDR_A_CKE0: length 57.2
  IN1 w0.064: 121.07,103.75 121.08,103.76 121.08,103.89 121.37,104.18 121.59,104.18 122.46,104.18 122.78,103.87 123.05,103.87 v14(123.07,103.89) 123.07,103.74 123.22,103.59 123.3,103.59 123.52,103.8 125.47,103.8 125.56,103.89 125.9,103.89 126.19,103.6 127.36,103.6 v12(127.47,103.49) 127.47,103.94 127.78,104.24 129.27,104.24 129.33,104.18 129.33,103.84 129.4,103.78 129.52,103.78 129.59,103.84 129.59,104.18 129.65,104.24 129.78,104.24 129.84,104.18 129.84,103.84 129.9,103.78 131.27,103.78 131.73,104.24 132.9,104.24 133.25,103.89 v14(133.47,103.89) 134.79,103.89 135.05,103.63 137.73,103.63 v12(137.87,103.49) 138.36,103.49 138.46,103.59 139.45,103.59 139.52,103.52 v2(141.39,103.52)
  IN1 w0.097: v6(118.73,86.1) 119.03,85.8 119.03,85.05 119.48,84.6 119.48,80.82 119.84,80.46 121.33,80.46 121.73,80.85 121.73,81.62 121.6,81.75 121.6,82.62 121.77,82.79 121.77,87.39 121.53,87.63 121.17,87.63 120.84,87.97 120.84,88.67 120.67,88.84 120.67,103.36 121.07,103.75
  BOTTOM w0.076: v6(118.73,86.1) 118.41,86.42 UC1.CG1
  BOTTOM w0.127: UD4.K2 v14(123.07,103.89) ; UD3.K2 v14(133.47,103.89)
DDR_A_CLK0: length 67.9
  TOP w0.076: v2(137.47,103.09) 137.34,103.09 137.27,103.17 136.69,103.17 136.37,103.49 ; v2(127.07,103.09) 126.95,103.09 126.87,103.17 126.3,103.17 125.97,103.49
  TOP w0.145: UD2.K7 125.97,103.49 ; UD1.K7 136.37,103.49
  IN1 w0.086: v2(140.59,102.25) 139.86,102.98 138.56,102.98 138.39,102.81 138.13,102.81 137.97,102.98 137.58,102.98 v2(137.47,103.09) 137.3,102.93 137.21,102.93 137.05,103.08 136.31,103.08 136.23,103.01 136.23,102.79 136.18,102.74 135.96,102.74 135.86,102.84 135.86,103.01 135.8,103.08 135.54,103.08 135.47,103 135.47,102.8 135.37,102.71 135.17,102.71 135.1,102.78 135.1,102.99 135.01,103.08 134.75,103.08 134.64,102.96 134.64,102.81 134.53,102.7 134.34,102.7 134.27,102.77 v6(134.27,103.09) 134.19,103.02 133.79,103.02 133.55,102.78 133.39,102.78 133.18,102.99 128.16,102.99 127.97,102.79 127.76,102.79 127.59,102.97 127.2,102.97 v2(127.07,103.09) 126.5,103.09 126.42,103.01 126.42,102.8 126.34,102.72 126.17,102.72 126.08,102.82 126.08,103.03 126.01,103.09 125.81,103.09 125.73,103.01 125.73,102.8 125.65,102.72 125.48,102.72 125.39,102.82 125.39,103.03 125.32,103.09 125.12,103.09 125.04,103.01 125.04,102.8 124.96,102.72 124.79,102.72 124.7,102.82 124.7,103.03 124.64,103.09 124.42,103.09 124.35,103.01 124.35,102.91 124.31,102.87 123.94,102.87 123.87,102.94 v6(123.87,103.09) 123.7,103.27 123.62,103.27 123.48,103.12 123.48,103.09 123.16,102.78 122.98,102.78 122.66,103.1 121.79,103.1 121.45,102.75 121.45,102.63
  IN1 w0.112: v6(121.87,87.89) 121.77,87.99 121.77,88.36 121.64,88.5 121.64,89.42 121.45,89.61 121.45,98.76 121.95,99.27 121.95,99.81 121.45,100.31 121.45,101.07 121.89,101.51 121.89,102.06 121.45,102.51 121.45,102.63
  BOTTOM w0.145: v6(134.27,103.09) 134.67,103.49 UD3.K7 ; UD4.K7 124.27,103.49 v6(123.87,103.09)
  BOTTOM w0.178: v6(121.87,87.89) 122.01,87.76 122.01,87.51 121.81,87.32 121.58,87.32 121.38,87.52 121.04,87.52 120.82,87.3 117.87,87.3 117.42,87.76 114.4,87.76 113.97,87.33 111.06,87.33 110.8,87.06 110.8,86.92 110.92,86.8 111.11,86.8 111.23,86.68 111.23,86.23 111.1,86.11 110.92,86.11 110.82,86.21 UC1.BR1
DDR_A_CLK#0: length 72.3
  TOP w0.076: 136.42,103 137.2,103 137.36,102.84 137.58,102.84 137.72,102.99 137.72,103 137.81,103.09 v2(138.27,103.09) ; 126.02,103 126.8,103 126.97,102.84 127.18,102.84 127.33,102.99 127.33,103 127.42,103.09 v2(127.87,103.09)
  TOP w0.145: 136.42,103 136.32,103.1 133.58,103.1 133.2,103.49 UD1.K8 ; UD2.K8 123.06,103.1 125.92,103.1 126.02,103
  IN1 w0.086: v2(140.59,102.89) 140.32,102.89 139.97,103.24 138.42,103.24 v2(138.27,103.09) 138.15,103.21 137.75,103.21 137.57,103.39 134.08,103.39 134.02,103.33 133.7,103.33 v6(133.47,103.09) 133.27,103.29 133.27,103.56 133.17,103.66 133.02,103.66 132.94,103.59 132.94,103.4 132.84,103.3 129.36,103.3 129.28,103.38 129.28,103.51 129.19,103.61 129.05,103.61 128.95,103.51 128.95,103.25 128.9,103.2 128.65,103.2 128.58,103.27 128.58,103.59 128.52,103.66 128.24,103.66 128.18,103.59 128.18,103.38 128.09,103.3 128.03,103.3 127.87,103.14 v2(127.87,103.09) 127.75,103.09 127.62,103.21 127.37,103.21 127.18,103.4 123.92,103.4 123.77,103.54 123.53,103.54 v6(123.07,103.09) 122.8,103.37 121.67,103.37 121.19,102.89
  IN1 w0.112: v6(121.28,87.89) 121.51,88.12 121.51,88.25 121.38,88.39 121.38,89.31 121.18,89.5 121.18,98.87 121.69,99.38 121.69,99.7 121.18,100.21 121.18,101.18 121.63,101.62 121.63,101.95 121.18,102.4 121.18,102.88 121.19,102.89
  BOTTOM w0.076: v6(133.47,103.09) 133.9,103.09 134.14,102.85 134.15,102.85 134.16,102.84 134.6,102.84 134.64,102.87 ; v6(123.07,103.09) 123.5,103.09 123.75,102.85 123.76,102.85 123.77,102.84 123.98,102.84 123.99,102.85 124.07,102.85 124.09,102.87
  BOTTOM w0.145: 134.64,102.87 134.85,103.08 137.19,103.08 137.61,103.49 UD3.K8 ; UD4.K8 127.38,103.49 126.96,103.08 125.14,103.08 124.94,102.87 124.09,102.87
  BOTTOM w0.178: UC1.BR2 110.31,86.42 110.31,86.97 110.95,87.61 113.85,87.61 114.28,88.04 117.54,88.04 117.99,87.59 120.7,87.59 121.01,87.89 v6(121.28,87.89)
DDR_A_CS#0: length 67.8
  TOP w0.127: UD2.L7 v12(125.87,104.29) ; UD1.L7 v12(136.27,104.29)
  IN1 w0.064: 121.07,104.1 121.31,104.35 122.65,104.35 122.78,104.22 123.78,104.22 123.85,104.29 v14(124.27,104.29) 124.41,104.29 124.47,104.23 124.47,104.02 124.53,103.95 124.66,103.95 124.72,104.02 124.72,104.39 124.79,104.46 124.91,104.46 124.98,104.39 124.98,104.01 125.04,103.94 125.17,103.94 125.23,104.01 125.23,104.37 125.29,104.43 125.46,104.43 125.51,104.37 125.51,104.12 125.57,104.06 125.73,104.06 125.76,104.1 125.76,104.18 v12(125.87,104.29) 126.01,104.16 126.43,104.16 126.56,104.03 126.79,104.03 126.94,104.18 127.32,104.18 127.64,104.5 133,104.5 133.34,104.16 134.22,104.16 134.35,104.29 v14(134.85,104.29) 135.05,104.29 135.11,104.23 135.11,103.84 135.17,103.78 135.3,103.78 135.36,103.84 135.36,104.22 135.43,104.28 135.54,104.28 135.62,104.2 135.62,103.84 135.68,103.78 135.81,103.78 135.87,103.84 135.87,104.23 135.94,104.29 v12(136.27,104.29) 136.4,104.16 136.83,104.16 136.96,104.03 137.18,104.03 137.34,104.18 137.75,104.18 137.96,104.39 139.4,104.39 139.98,103.81 142.27,103.81 v2(142.56,103.52)
  IN1 w0.097: v6(120.41,88.16) 120.42,88.17 120.42,103.46 121.07,104.1
  BOTTOM w0.127: v6(120.41,88.16) 120.22,87.97 118.74,87.97 118.27,88.44 v1(115.8,88.44) 113.6,88.44 113.59,88.42 111.05,88.42 109.35,86.72 109.35,84.34 109.15,84.15 108.63,84.15 UC1.BL5 ; UD3.L7 v14(134.85,104.29) ; UD4.L7 v14(124.27,104.29)
