# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_SO_0_R: length 17.1
  IN3 w0.064: v3(11.76,58.15) 10.36,58.15 10.21,58.3 10.21,58.5 10.33,58.63 12.12,58.63 12.19,58.7 12.19,59.06 12.26,59.14 12.37,59.14 12.44,59.06 12.44,58.7 12.52,58.63 13.11,58.63 13.4,58.34 13.4,58.23 13.27,58.11 13.27,58 13.35,57.93 13.45,57.93 13.58,58.05 13.69,58.05 13.76,57.98 13.76,57.87 13.63,57.75 13.63,57.64 13.71,57.57 13.81,57.57 13.94,57.69 14.05,57.69 14.12,57.62 14.12,57.52 13.99,57.39 13.99,57.28 14.07,57.21 14.17,57.21 14.3,57.34 14.41,57.34 14.7,57.04 v3(14.7,56.62)
  BOTTOM w0.127: v3(14.7,56.62) 15.51,56.62 15.91,56.22 v9(15.91,54.5) 15.69,54.29 15.69,53.5 16.1,53.1 RP5.3 ; UH6.2 11.25,59.01 11.72,58.54 11.72,58.19 v3(11.76,58.15)
PCH_SPI_WP#: length 12.9
  BOTTOM w0.076: UH4.BC29 26.57,49.12 26.43,49.26 25.59,49.26 25.49,49.36 23.8,49.36 22.53,50.63 22.32,50.63 22.26,50.69 v1(22.13,50.69) 20.47,50.69 20.29,50.87
  BOTTOM w0.127: 20.29,50.87 19.82,51.34 19.5,51.34 RH110.2 18.16,52.69 18.16,53.32 17.88,53.6 RP5.5 17.45,53.6 17.32,53.73 17.32,54.16 17.5,54.34 RC21.1
PCH_SPI_WP#_0_R: length 11.1
  IN3 w0.064: v3(15.08,56.93) 12.47,59.54 v3(11.73,59.54)
  BOTTOM w0.127: v3(15.08,56.93) 15.57,56.93 16.32,56.18 v1(16.32,55.46) 16.32,54.27 15.95,53.91 15.95,53.73 16.08,53.6 RP5.4 ; UH6.3 10.99,60.28 v3(11.73,59.54)
PCH_SRTCRST#: length 12.5
  TOP w0.127: v9(18.69,40.79) 19.21,40.79 19.57,41.14 22.54,41.14 v1(22.88,40.8) v7(23.26,40.8)
  GND2 w0.102: v5(23.36,40.47) 23.36,40.7 v7(23.26,40.8)
  GND3 w0.102: v6(23.75,40.42) 23.69,40.47 v5(23.36,40.47)
  BOTTOM w0.076: v6(23.75,40.42) 23.8,40.36 26.64,40.36 26.74,40.26 27.01,40.26 27.21,40.05 UH4.BB10
  BOTTOM w0.127: CH79.1 RH131.2 17.85,41.01 CLRME.1 17.87,39.96 v9(18.69,40.79)
PCH_TBT_FORCE_PWR: length 5.1
  BOTTOM w0.076: UH4.P43 41.16,56.21 41.39,56.45 41.39,56.92 41.53,57.06 41.53,57.82 42.47,58.76
  BOTTOM w0.127: RH609.1 43.24,59.93 v1(43.42,60.11)
  BOTTOM w0.145: 42.47,58.76 42.98,59.26 RH609.1
PCH_TBT_PERST#: length 71.5
  TOP w0.127: v2(35.34,86.75) 34.95,87.14 RT428.1
  IN1 w0.064: v4(22.58,60.6) 24.6,62.62 24.6,65.89 25.98,67.27 25.98,69.94 28.44,72.4 31.49,72.4 31.82,72.73 33.88,72.73 35.38,74.24 35.8,74.24 36.02,74.46 36.02,74.89 35.96,74.95 34.88,74.95 34.32,74.95 33.34,75.93 33.34,77.52 35.47,79.65 39.34,79.65 39.54,79.85 39.54,81.22 39.22,81.54 39.04,81.54 38.75,81.83 38.75,84.67 v4(38.63,84.79) 38.63,84.91 38.24,85.3 37.95,85.3 36.5,86.75 v2(35.34,86.75)
  GND2 w0.102: v5(22.92,60.6) v4(22.58,60.6) ; v4(38.63,84.79) v5(38.96,84.79)
  IN2 w0.074: v5(25.33,46.5) 25.14,46.7 25.14,50.64 24.9,50.88 24.9,55 25.22,55.32 25.22,56.17 22.92,58.46 v5(22.92,60.6)
  GND3 w0.102: v5(25.33,46.5) 25.45,46.62 25.45,46.63 v6(25.56,46.74) ; v8(39.34,84.73) 39.03,84.73 v5(38.96,84.79) ; v6(22.28,60.6) v5(22.92,60.6)
  IN3 w0.064: v3(43.09,89.2) 43.09,87.01 42.01,85.94 42.01,85.01 41.73,84.73 v8(39.34,84.73)
  BOTTOM w0.076: v6(25.56,46.74) 25.58,46.76 26.27,46.76 UH4.BD24
  BOTTOM w0.127: RH643.1 21.71,60.6 v6(22.28,60.6)
PCH_TPM_CLK_C: length 5.3
  BOTTOM w0.127: v1(17.05,9.99) 18.65,9.99 RE31.1 RE21.2 20.21,11.61 UE2.19
PCH_TRIGGER: length 66.5
  IN1 w0.064: v4(63.36,44.67) 63.36,43.58 60.3,40.52 60.3,35.76 57.95,33.41 57.95,32.68 57.77,32.5 v4(57.77,32.1)
  GND2 w0.102: v5(57.69,31.27) 57.69,32.02 v4(57.77,32.1) ; v7(69.15,52.66) 69.29,52.66 v5(69.55,52.93) ; v5(63.62,44.41) v4(63.36,44.67)
  IN2 w0.074: v5(69.55,52.93) 69.04,52.93 68.86,53.11 64.83,53.11 64.23,52.51 v5(64.23,51.59)
  GND3 w0.102: v8(63.62,44.84) v5(63.62,44.41) ; v8(64.28,51.21) 64.23,51.26 v5(64.23,51.59) ; v6(57.84,30.84) 57.84,31.04 57.69,31.19 v5(57.69,31.27)
  IN3 w0.064: v8(64.28,51.21) 64.28,50.59 63.29,49.59 63.29,45.17 v8(63.62,44.84)
  BOTTOM w0.076: UH4.AL2 32.77,34.68 33.96,33.49 33.96,33.36
  BOTTOM w0.127: 33.96,33.36 33.96,33.19 34.24,32.91 34.24,30.91 37.94,27.21 41.54,27.21 44.66,24.1 50.76,24.1 v1(51.93,25.27) 54.13,27.47 54.82,27.47 57.84,30.49 v6(57.84,30.84)
PCH_TRIGGER_R: length 9.3
  TOP w0.127: RH62.2 v1(70.96,52.66) 71.09,52.66 71.48,53.05 73.72,53.05 76.27,55.61 v2(76.27,55.68)
  IN1 w0.064: v2(76.27,55.68) 76.27,56.44 v4(76.11,56.61)
  GND2 w0.102: v4(76.11,56.61) v5(76.11,56.97)
  GND3 w0.102: v6(75.97,57.36) 76.11,57.23 v5(76.11,56.97)
PCH_WAKE_GPU_N: length 8.6
  IN3 w0.064: v3(85.51,54.22) 84.69,55.03 83.05,55.03 82.83,55.26 82.83,56.33 83.03,56.53 83.03,60.22 v3(83.35,60.55)
PCH_XDP_CLK_N: length 2.3
  BOTTOM w0.122: UH4.L1 42.14,35.2 42.14,33.85 T812.1
PCH_XDP_CLK_P: length 3.2
  BOTTOM w0.076: UH4.L2 41.73,35.31 41.73,34.14 T813.1
PCIE_PRX_C_DTX_N5: length 1.6
  TOP w0.145: UR1.8 25.08,66.44 25.14,66.38 25.87,66.38 CR9.2
PCIE_PRX_C_DTX_P5: length 1.7
  TOP w0.145: UR1.7 25.11,66.04 25.14,66.07 25.67,66.07 CR8.2
PCIE_PRX_C_TTX_N9: length 2.5
  BOTTOM w0.076: CT4.2 40.8,74.66 40.8,74.88 40.54,75.14 40.54,75.75 40.39,75.89 40.39,76.4 UT2.V22
PCIE_PRX_C_TTX_N10: length 2.4
  BOTTOM w0.076: UT2.P22 38.99,76.4 38.99,75.98 38.86,75.86 38.86,75.14 38.99,75.01 38.99,74.65 CT21.2
PCIE_PRX_C_TTX_N11: length 2.5
  BOTTOM w0.076: CT8.2 37.14,74.68 37.14,74.95 36.87,75.22 36.87,75.77 36.71,75.92 36.71,76.32 36.93,76.54 UT2.K22
PCIE_PRX_C_TTX_N12: length 2.9
  BOTTOM w0.076: UT2.F22 34.87,76.31 34.87,75.98 35.02,75.83 35.02,75.29 35.4,74.91 35.79,74.91 35.91,74.79 35.91,74.63 CT12.2
PCIE_PRX_C_TTX_P9: length 2.5
  BOTTOM w0.076: CT2.2 40.97,74.7 40.97,74.95 40.7,75.21 40.7,75.77 40.85,75.92 40.85,76.27 40.78,76.33 40.68,76.33 40.61,76.27 UT2.V23
PCIE_PRX_C_TTX_P10: length 2.4
  BOTTOM w0.076: UT2.P23 38.77,76.3 38.71,76.35 38.62,76.35 38.54,76.27 38.54,75.98 38.7,75.82 38.7,75.07 38.82,74.95 38.82,74.71 CT19.2
PCIE_PRX_C_TTX_P11: length 2.5
  BOTTOM w0.076: UT2.K23 36.93,76.3 36.99,76.36 37.07,76.36 37.16,76.27 37.16,75.93 37.04,75.8 37.04,75.29 37.31,75.02 37.31,74.68 CT6.2
PCIE_PRX_C_TTX_P12: length 2.9
  BOTTOM w0.076: UT2.F23 35.09,76.25 35.17,76.32 35.27,76.32 35.33,76.26 35.33,75.98 35.19,75.84 35.19,75.35 35.47,75.08 35.86,75.08 36.08,74.86 36.08,74.73 CT10.2
PCIE_PRX_DTX_N1: length 93
  IN3 w0.086: v3(112.06,19.9) 112.06,19.53 111.72,19.18 111.72,16.2 111.21,15.69 110.39,15.69 110.17,15.47 110.17,15.17 109.25,14.24 102.02,14.24 101.34,13.57 98.05,13.57 97.58,13.09 82.38,13.09 81.75,13.72 78.75,13.72 78.61,13.87 65.9,13.87 53.2,26.56 52.76,26.56 50.09,29.23 50.09,34.34 49.95,34.48 49.95,39.27 48.83,40.39 47.88,40.39 46.93,39.44 44.55,39.44 44.1,39.89 44.1,42.21 v3(44.02,42.29)
PCIE_PRX_DTX_N5: length 63.5
  TOP w0.145: v9(27.63,66.43) 27.48,66.27 27.26,66.27 CR9.1
  BOTTOM w0.076: UH4.K19 43.22,44.72 43.22,44.9 43.33,45.01 45.01,45.01 45.11,44.9 45.7,44.9 45.75,44.85 46.28,44.85 46.35,44.92 47.79,44.92 48.49,45.63 48.58,45.63 48.66,45.56 48.68,45.56
  BOTTOM w0.145: v9(27.63,66.43) 27.74,66.31 28.01,66.31 28.51,65.82 28.51,64.71 30.08,63.14 45.17,63.14 46.05,62.25 51.64,62.25 53.16,60.73 53.16,59.16 56.77,55.56 56.77,54.8 56.98,54.59 57.21,54.59 57.54,54.27 57.54,53.57 57.21,53.25 56.98,53.25 56.77,53.04 56.77,52.74 56.98,52.52 57.74,52.52 58.13,52.13 58.13,51.57 57.74,51.18 56.98,51.18 56.77,50.97 56.77,49.45 56.44,49.13 v10(56.44,47.52) 56.44,46.68 54.15,44.39 51.47,44.39 50.3,45.56 48.68,45.56
PCIE_PRX_DTX_N14: length 80.6
  IN3 w0.086: v3(94.11,17.53) 94.11,17.5 94.09,17.48 94.09,17.47 93.56,16.94 90.43,16.94 89.79,17.58 84.47,17.58 83.77,16.88 80.27,16.88 80.16,16.98 77.37,16.98 76.55,17.81 74.18,17.81 73.54,18.45 67.8,18.45 54.06,32.18 54.06,40.94 47.95,47.05 47.95,49.94 47.52,50.37 47.52,52.26 45.84,53.93 45.84,54.07 v3(45.95,54.17)
  BOTTOM w0.145: v3(94.11,17.53) 93.74,17.16 93.74,14.65 95.78,12.62 JNGFF2.29
PCIE_PRX_DTX_N15: length 85.5
  IN3 w0.086: v3(45.32,54.61) 45.44,54.73 45.44,55.07 45.69,55.32 46.14,55.32 47.21,54.25 47.21,53.57 48.26,52.53 48.26,50.91 48.66,50.5 48.66,47.38 54.76,41.28 54.76,32.52 68.14,19.15 74.41,19.15 74.96,18.6 76.75,18.6 77.67,17.68 80.72,17.68 80.79,17.61 83.32,17.61 83.33,17.62 84.03,18.32 90.5,18.32 91.08,17.74 93.04,17.74 93.21,17.91 93.21,18.11 v3(93.17,18.14)
  BOTTOM w0.076: UH4.F41 45.42,54.99 45.42,54.71 v3(45.32,54.61)
  BOTTOM w0.145: JNGFF2.17 95.85,9.62 94.12,11.35 94.12,12.76 92.98,13.9 92.98,17.65 93.21,17.88 93.21,18.11 v3(93.17,18.14)
PCIE_PRX_DTX_N16: length 88.6
  IN3 w0.086: v3(93.1,19.06) 93.07,19.03 83.75,19.03 83.04,18.32 81.07,18.32 81.01,18.38 78.11,18.38 76.65,19.85 68.44,19.85 55.46,32.83 55.46,41.59 49.37,47.68 49.37,51.11 48.99,51.5 48.99,52.79 48.1,53.68 48.1,54.84 47.25,55.7 47.25,55.97 46.95,56.27 46.14,56.27 46.05,56.36 v3(46.05,56.52)
  BOTTOM w0.145: JNGFF2.5 95.71,6.62 93.36,8.97 93.36,12.42 92.22,13.57 92.22,18.55 92.72,19.06 v3(93.1,19.06)
PCIE_PRX_DTX_P1: length 93
  IN3 w0.086: v3(111.06,19.9) 111.29,20.13 111.54,20.13 111.75,19.92 111.75,19.66 111.41,19.31 111.41,16.32 111.08,16 110.26,16 109.86,15.6 109.86,15.3 109.12,14.55 101.89,14.55 101.21,13.88 97.92,13.88 97.45,13.4 82.51,13.4 81.88,14.03 78.88,14.03 78.74,14.18 66.03,14.18 53.33,26.87 52.89,26.87 50.4,29.36 50.4,34.47 50.26,34.61 50.26,39.4 48.96,40.7 47.75,40.7 46.8,39.75 44.68,39.75 44.41,40.02 44.41,41.91 v3(44.78,42.29)
PCIE_PRX_DTX_P5: length 63.5
  TOP w0.145: CR8.1 27.26,65.96 27.51,65.96 v9(27.63,65.84)
  BOTTOM w0.076: 48.68,45.87 48.66,45.87 48.58,45.79 48.43,45.79 47.72,45.09 46.29,45.09 46.21,45.01 45.82,45.01 45.77,45.07 45.18,45.07 45.07,45.17 43.27,45.17 43.06,44.97 43.06,44.49 42.93,44.36 42.71,44.36 42.6,44.47 UH4.L19
  BOTTOM w0.145: 48.68,45.87 50.43,45.87 51.6,44.7 54.02,44.7 56.13,46.81 56.13,49.26 56.46,49.58 56.46,51.1 56.85,51.49 57.61,51.49 57.82,51.7 57.82,52 57.61,52.22 56.85,52.22 56.46,52.61 56.46,53.17 56.85,53.56 57.08,53.56 57.23,53.7 57.23,54.14 57.08,54.28 56.85,54.28 56.46,54.68 56.46,55.43 52.85,59.03 52.85,60.6 51.51,61.94 45.92,61.94 45.04,62.83 29.95,62.83 28.2,64.58 28.2,65.69 27.89,66 27.73,66 27.63,65.91 v9(27.63,65.84)
PCIE_PRX_DTX_P14: length 80.5
  IN3 w0.086: v3(94.41,17.2) 94.26,17.2 93.69,16.63 90.3,16.63 89.66,17.27 84.6,17.27 83.89,16.57 80.14,16.57 80.03,16.67 77.25,16.67 76.42,17.5 74.05,17.5 73.41,18.14 67.67,18.14 53.75,32.05 53.75,40.81 47.64,46.92 47.64,49.81 47.21,50.25 47.21,52.13 45.89,53.45 v3(45.75,53.45)
  BOTTOM w0.145: v3(94.41,17.2) 94.22,17.2 94.05,17.03 94.05,14.78 95.9,12.93 96.14,12.93 96.26,13.06 96.26,13.24 96.39,13.36 96.57,13.36 96.67,13.26 96.67,13.04 96.77,12.93 96.89,12.93 97.08,13.12 JNGFF2.31
PCIE_PRX_DTX_P15: length 85.5
  IN3 w0.086: v3(93.55,18.14) 93.52,18.11 93.52,17.78 93.17,17.43 90.95,17.43 90.37,18.01 84.16,18.01 83.87,17.72 83.45,17.3 80.66,17.3 80.59,17.37 77.54,17.37 76.62,18.29 74.83,18.29 74.28,18.84 68.01,18.84 54.45,32.39 54.45,41.15 48.35,47.25 48.35,50.37 47.95,50.78 47.95,52.4 46.9,53.44 46.9,54.12 46.01,55.01 45.82,55.01 45.75,54.94 45.75,54.83 v3(45.96,54.61)
  BOTTOM w0.076: UH4.E41 45.8,54.77 v3(45.96,54.61)
  BOTTOM w0.145: v3(93.55,18.14) 93.52,18.11 93.52,17.75 93.29,17.53 93.29,14.03 94.43,12.88 94.43,11.47 95.98,9.93 96.24,9.93 96.38,10.07 96.38,10.32 96.5,10.45 96.72,10.45 97.04,10.12 JNGFF2.19
PCIE_PRX_DTX_P16: length 88.6
  IN3 w0.086: v3(93.1,18.67) 93.05,18.72 83.88,18.72 83.17,18.01 80.94,18.01 80.88,18.07 77.98,18.07 76.52,19.54 68.32,19.54 55.16,32.7 55.16,41.46 49.06,47.55 49.06,50.98 48.68,51.37 48.68,52.66 47.79,53.55 47.79,54.72 46.94,55.57 46.94,55.84 46.82,55.96 v3(45.83,55.96)
  BOTTOM w0.145: JNGFF2.7 97.19,7.12 97.02,6.95 96.81,6.95 96.67,7.09 96.67,7.42 96.52,7.57 96.36,7.57 96.22,7.42 96.22,7.04 96.11,6.93 95.84,6.93 93.67,9.1 93.67,12.55 92.53,13.7 92.53,18.43 92.85,18.75 93.03,18.75 v3(93.1,18.67)
PCIE_PRX_TTX_N9: length 61.1
  IN3 w0.086: v3(44.86,50.46) 44.9,50.5 44.9,50.7 44.81,50.79 44.51,50.79 44.43,50.7 44.43,50.36 44.61,50.18 45.17,50.18 45.35,50.36 45.35,50.71 44.23,51.82 44.23,56.85 44.38,57 44.38,57.93 44.79,58.33 45.19,58.33 45.77,57.74 45.92,57.74 46.02,57.85 46.02,57.99 45.31,58.69 45.31,59.11 45.72,59.52 46.12,59.52 48.82,56.82 48.82,55.01 48.9,54.92 49.28,54.92 49.36,55.01 49.36,56.77 46.17,59.96 46.17,60.43 46.88,61.14 46.88,62.19 46.56,62.5 46.56,63.07 47.66,64.17 47.66,64.32 47.56,64.42 47.42,64.42 46.3,63.29 45.9,63.29 45.61,63.58 45.61,63.98 47.67,66.04 47.67,66.18 47.57,66.28 47.43,66.28 46.92,65.78 46.52,65.78 46.14,66.16 46.14,66.56 46.49,66.92 46.49,67.1 46.08,67.51 45.92,67.51 45.18,66.77 45.18,66.63 46.28,65.53 46.28,65.13 45.52,64.37 45.02,64.37 44.72,64.66 44.72,65.45 43.59,66.58 43.59,67.14 43.93,67.48 44.3,67.48 45.02,68.2 45.02,68.4 43.79,69.63 43.79,70.19 42.1,71.88 41.94,71.88 41.69,71.62 41.01,71.62 40.73,71.9 40.73,73.11 v3(40.63,73.22)
  BOTTOM w0.145: v3(40.63,73.22) 40.75,73.34 40.75,73.78 CT4.1
PCIE_PRX_TTX_N10: length 61.1
  IN3 w0.086: v3(44.88,49.31) 44.88,49.54 45.01,49.67 45.24,49.67 45.34,49.57 45.34,48.77 46.14,47.96 46.14,46.3 46.76,45.68 46.76,45.54 46.42,45.2 46.42,44.8 46.76,44.45 47.16,44.45 47.54,44.82 47.71,44.82 49.12,43.41 49.12,43.2 48.85,42.93 48.59,42.93 48,43.52 47.61,43.52 47.13,43.03 46.88,43.03 46.82,43.09 46.82,43.78 46.32,44.28 45.77,44.28 45.51,44.03 45.51,43.1 45.39,42.98 44.8,42.98 44.72,43.06 44.72,45.09 44.82,45.19 45.53,45.19 45.81,45.47 45.81,46.01 45.47,46.35 44.61,46.35 44.54,46.42 44.54,46.84 44.26,47.12 44,47.12 43.82,47.29 43.82,47.73 43.93,47.84 44.3,47.84 44.59,48.14 44.59,48.79 44.34,49.04 44.11,49.04 43.98,49.16 43.98,49.7 43.83,49.86 43.83,53.6 43.65,53.78 43.65,56.95 43.98,57.28 43.98,58.1 44.83,58.96 44.83,59.2 45.61,59.98 45.61,60.44 46.36,61.18 46.36,62.11 44.33,64.15 44.33,65.28 42.82,66.78 42.82,67.1 42.95,67.23 42.95,67.79 43.04,67.88 44,67.88 44.29,68.17 44.29,68.58 43.95,68.92 43.08,68.92 42.98,69.02 42.98,69.23 43.38,69.63 43.38,70.03 43.1,70.31 42.7,70.31 42.35,69.96 42.28,69.96 42.11,70.13 42.11,70.21 42.46,70.56 42.46,70.96 42.18,71.23 41.24,71.23 40.92,70.91 40.56,70.91 40,71.47 40,72.6 39.72,72.88 39.23,72.88 39.03,73.08 39.03,73.27 v3(39.06,73.31)
  BOTTOM w0.145: CT21.1 39.03,73.78 39.03,73.34 v3(39.06,73.31)
PCIE_PRX_TTX_N11: length 61.7
  IN3 w0.086: v3(36.94,73.9) 37.05,73.79 37.05,73.44 37.4,73.09 37.9,73.09 38.01,72.98 38.01,72.48 38.46,72.03 38.46,71.57 39.6,70.43 39.6,70.07 39.88,69.79 41,69.79 41.94,68.85 41.94,67.64 41.85,67.56 41.51,67.56 41.38,67.69 41.38,68.6 40.69,69.29 40.17,69.29 39.85,68.97 39.85,68.46 40.03,68.28 40.03,67.53 41.09,66.47 41.09,66.3 40.94,66.16 40.8,66.16 40.33,66.62 39.99,66.62 39.57,66.2 39.57,65.82 40.36,65.03 40.36,64.76 40.64,64.47 41.36,64.47 41.46,64.37 41.46,64.23 41.36,64.13 40.68,64.13 40.41,63.86 40.41,63.45 40.79,63.07 40.79,62.9 40.46,62.57 40.46,61.9 40.77,61.6 41.15,61.6 41.96,62.41 41.96,63.27 42.75,64.05 42.75,64.65 41.87,65.53 41.87,65.72 42.05,65.9 42.19,65.9 43.23,64.86 43.23,63.79 45.31,61.72 45.31,61.57 45.04,61.31 44.7,61.31 44.29,61.72 44.29,62.19 43.14,63.34 42.69,63.34 42.4,63.05 42.4,62.37 43.28,61.49 43.28,61.26 43.06,61.04 42.94,61.04 42.23,61.75 41.78,61.75 41.42,61.38 41.42,60.89 42.06,60.25 42.06,59.68 42.37,59.37 42.86,59.37 43.9,60.42 44.14,60.42 44.29,60.27 44.29,60.15 42.94,58.8 42.94,57.83 42.56,57.45 42.56,55.41 42.39,55.24 42.39,53.41 42.91,52.89 42.91,50.92 42.77,50.78 42.77,50.19 v3(42.72,50.15)
  BOTTOM w0.076: v3(42.72,50.15) 42.57,50.3 UH4.L31
PCIE_PRX_TTX_N12: length 61
  IN3 w0.086: v3(42.1,51.46) 42.19,51.46 42.28,51.55 42.28,52.55 41.34,53.48 41.34,54.06 41.57,54.29 41.57,54.56 41.35,54.79 40.53,54.79 40.1,55.22 40.1,56.04 39.78,56.37 39.78,56.77 40.27,57.26 40.71,57.26 41.23,56.75 41.23,55.98 41.35,55.86 41.55,55.86 41.72,56.03 41.72,56.88 41.5,57.1 41.5,57.5 42.21,58.22 42.21,58.59 42.12,58.68 41.75,58.68 41.67,58.61 41.67,58.17 41.25,57.75 40.85,57.75 40.54,58.06 40.54,59.11 41.3,59.87 41.3,60.02 40.72,60.6 40.72,60.63 40.63,60.72 40.45,60.72 40.31,60.58 40.31,60.46 40.65,60.11 40.65,59.73 40.25,59.33 39.73,59.33 39.42,59.63 39.16,59.63 38.99,59.47 38.99,58.86 39.16,58.69 39.73,58.69 40.06,58.35 40.06,57.74 39.4,57.08 38.74,57.08 38.2,57.62 37.24,57.62 36.68,58.18 36.68,58.89 36.97,59.18 37.61,59.18 37.7,59.27 37.7,59.44 37.61,59.53 37.12,59.53 36.68,59.96 36.68,60.85 37.06,61.22 37.57,61.22 37.91,60.88 38.03,60.88 38.12,60.96 38.12,61.06 38,61.18 38,61.25 37.86,61.39 37.86,62.03 38.21,62.38 38.77,62.38 39.41,61.74 39.65,61.74 39.73,61.83 39.73,62.85 39.65,62.93 38.96,62.93 38.66,63.24 38.66,63.32 38.66,63.66 38.96,63.96 39.56,63.96 39.73,64.13 39.73,64.4 39.66,64.47 39.66,64.74 39.5,64.9 39.32,64.9 39.15,64.73 38.62,64.73 38.29,65.06 38.29,66.38 38.55,66.64 38.98,66.64 39.33,66.98 39.33,67.4 38.85,67.87 38.85,68.43 39.15,68.72 39.15,68.86 39.06,68.95 38.85,68.95 38.53,69.27 38.53,69.69 38.88,70.04 38.88,70.16 37.7,71.33 37.7,71.69 37.62,71.78 37.44,71.78 37.25,71.59 36.87,71.59 36.46,72 36.46,72.38 36.73,72.65 36.73,72.77 36.58,72.92 36.05,72.92 35.78,73.18 35.78,73.88 v3(35.76,73.9)
  BOTTOM w0.076: UH4.G33 44.57,51.58 44.57,51.69 44.23,52.03 42.37,52.03 42.2,51.86 42.2,51.56 v3(42.1,51.46)
PCIE_PRX_TTX_P9: length 61.2
  IN3 w0.086: v3(44.1,50.46) 44.12,50.44 44.12,50.24 44.48,49.87 45.3,49.87 45.66,50.23 45.66,50.84 44.54,51.95 44.54,56.72 44.69,56.87 44.69,57.8 44.91,58.02 45.06,58.02 45.64,57.43 46.04,57.43 46.33,57.72 46.33,58.12 45.62,58.82 45.62,58.98 45.85,59.21 45.99,59.21 48.51,56.69 48.51,54.88 48.78,54.61 49.41,54.61 49.67,54.88 49.67,56.89 46.48,60.09 46.48,60.3 47.19,61.01 47.19,62.31 46.87,62.63 46.87,62.94 47.97,64.05 47.97,64.44 47.69,64.73 47.29,64.73 46.17,63.6 46.02,63.6 45.92,63.71 45.92,63.85 47.98,65.91 47.98,66.31 47.7,66.59 47.3,66.59 46.79,66.09 46.65,66.09 46.45,66.29 46.45,66.43 46.8,66.79 46.8,67.23 46.21,67.82 45.79,67.82 44.87,66.9 44.87,66.5 45.97,65.4 45.97,65.26 45.39,64.68 45.14,64.68 45.03,64.79 45.03,65.58 43.9,66.71 43.9,67.02 44.06,67.17 44.43,67.17 45.33,68.07 45.33,68.52 44.1,69.76 44.1,70.31 42.23,72.19 41.82,72.19 41.56,71.93 41.14,71.93 41.04,72.03 41.04,73.08 v3(41.19,73.23)
  BOTTOM w0.145: CT2.1 41.06,73.78 41.06,73.35 v3(41.19,73.23)
PCIE_PRX_TTX_P10: length 61.1
  IN3 w0.086: v3(45.65,49.31) 45.65,48.9 46.45,48.09 46.45,46.43 47.07,45.81 47.07,45.41 46.73,45.07 46.73,44.92 46.89,44.76 47.03,44.76 47.41,45.13 47.84,45.13 49.43,43.54 49.43,43.07 48.98,42.62 48.46,42.62 47.87,43.21 47.74,43.21 47.26,42.72 46.75,42.72 46.51,42.96 46.51,43.65 46.19,43.97 45.89,43.97 45.82,43.9 45.82,42.97 45.51,42.67 44.67,42.67 44.41,42.93 44.41,45.22 44.69,45.5 45.4,45.5 45.5,45.6 45.5,45.88 45.35,46.04 44.48,46.04 44.23,46.3 44.23,46.71 44.13,46.81 43.87,46.81 43.51,47.17 43.51,47.86 43.8,48.15 44.17,48.15 44.28,48.27 44.28,48.66 44.21,48.73 43.98,48.73 43.67,49.03 43.67,49.57 43.52,49.73 43.52,53.48 43.34,53.65 43.34,57.08 43.67,57.41 43.67,58.23 44.52,59.09 44.52,59.33 45.3,60.11 45.3,60.57 46.05,61.31 46.05,61.99 44.02,64.02 44.02,65.15 42.51,66.65 42.51,67.22 42.64,67.35 42.64,67.92 42.92,68.19 43.87,68.19 43.98,68.3 43.98,68.45 43.82,68.61 42.95,68.61 42.67,68.89 42.67,69.35 43.07,69.76 43.07,69.9 42.97,70 42.83,70 42.48,69.65 42.15,69.65 41.8,70 41.8,70.33 42.15,70.68 42.15,70.83 42.05,70.92 41.37,70.92 41.05,70.6 40.43,70.6 39.69,71.34 39.69,72.47 39.59,72.57 39.1,72.57 38.72,72.95 38.72,73.27 v3(38.68,73.31)
  BOTTOM w0.145: CT19.1 38.72,73.77 38.72,73.35 v3(38.68,73.31)
PCIE_PRX_TTX_P11: length 61.7
  IN3 w0.086: v3(43.12,50.14) 43.08,50.19 43.08,50.65 43.22,50.8 43.22,53.02 42.7,53.53 42.7,55.11 42.87,55.28 42.87,57.33 43.25,57.7 43.25,58.67 44.6,60.02 44.6,60.4 44.27,60.73 43.77,60.73 42.73,59.68 42.5,59.68 42.37,59.81 42.37,60.38 41.73,61.02 41.73,61.25 41.91,61.44 42.1,61.44 42.81,60.73 43.19,60.73 43.59,61.13 43.59,61.62 42.71,62.5 42.71,62.92 42.82,63.03 43.01,63.03 43.98,62.06 43.98,61.59 44.57,61 45.17,61 45.62,61.44 45.62,61.85 43.54,63.92 43.54,64.99 42.32,66.21 41.92,66.21 41.56,65.84 41.56,65.4 42.44,64.52 42.44,64.18 41.65,63.4 41.65,62.54 41.02,61.91 40.9,61.91 40.77,62.03 40.77,62.44 41.1,62.77 41.1,63.2 40.72,63.58 40.72,63.73 40.81,63.82 41.49,63.82 41.77,64.1 41.77,64.5 41.49,64.78 40.77,64.78 40.67,64.89 40.67,65.16 39.88,65.95 39.88,66.08 40.12,66.31 40.2,66.31 40.67,65.85 41.07,65.85 41.4,66.18 41.4,66.6 40.34,67.66 40.34,68.41 40.16,68.59 40.16,68.84 40.29,68.98 40.56,68.98 41.07,68.47 41.07,67.57 41.38,67.25 41.98,67.25 42.25,67.52 42.25,68.98 41.13,70.1 40.01,70.1 39.9,70.2 39.9,70.56 38.77,71.7 38.77,72.15 38.32,72.61 38.32,73.11 38.03,73.4 37.52,73.4 37.36,73.56 37.36,73.76 v3(37.5,73.9)
  BOTTOM w0.076: UH4.K31 43.34,50.44 v3(43.12,50.14)
PCIE_PRX_TTX_P12: length 61
  IN3 w0.086: v3(36.32,73.9) 36.17,73.9 36.09,73.82 36.09,73.31 36.18,73.23 36.71,73.23 37.04,72.9 37.04,72.52 36.77,72.25 36.77,72.13 37,71.9 37.12,71.9 37.31,72.09 37.75,72.09 38.01,71.82 38.01,71.46 39.19,70.29 39.19,69.91 38.84,69.56 38.84,69.4 38.98,69.26 39.19,69.26 39.46,68.99 39.46,68.59 39.16,68.3 39.16,68 39.64,67.52 39.64,66.85 39.11,66.33 38.67,66.33 38.6,66.25 38.6,65.19 38.75,65.03 39.02,65.03 39.2,65.21 39.63,65.21 39.97,64.87 39.97,64.59 40.04,64.53 40.04,64 39.69,63.65 39.09,63.65 38.97,63.53 38.97,63.45 38.97,63.45 38.97,63.37 39.09,63.24 39.78,63.24 40.04,62.98 40.04,61.7 39.78,61.43 39.28,61.43 38.64,62.07 38.34,62.07 38.17,61.9 38.17,61.52 38.31,61.38 38.31,61.31 38.43,61.19 38.43,60.84 38.16,60.57 37.78,60.57 37.44,60.91 37.18,60.91 36.99,60.72 36.99,60.09 37.25,59.84 37.74,59.84 38.01,59.57 38.01,59.14 37.74,58.87 37.1,58.87 36.99,58.76 36.99,58.31 37.37,57.93 38.33,57.93 38.87,57.39 39.27,57.39 39.75,57.87 39.75,58.23 39.6,58.38 39.03,58.38 38.68,58.73 38.68,59.6 39.03,59.94 39.55,59.94 39.86,59.64 40.12,59.64 40.34,59.86 40.34,59.98 40,60.33 40,60.71 40.32,61.03 40.76,61.03 41.03,60.76 41.03,60.73 41.61,60.15 41.61,59.74 40.85,58.98 40.85,58.19 40.98,58.06 41.12,58.06 41.36,58.3 41.36,58.73 41.62,58.99 42.25,58.99 42.52,58.72 42.52,58.09 41.81,57.37 41.81,57.23 42.03,57 42.03,55.9 41.68,55.55 41.22,55.55 40.92,55.85 40.92,56.62 40.58,56.95 40.4,56.95 40.09,56.64 40.09,56.49 40.41,56.17 40.41,55.35 40.66,55.1 41.47,55.1 41.88,54.69 41.88,54.16 41.65,53.93 41.65,53.61 42.59,52.68 42.59,51.48 v3(42.61,51.46)
  BOTTOM w0.076: v3(42.61,51.46) 42.48,51.46 42.36,51.59 42.36,51.79 42.44,51.87 44.16,51.87 44.41,51.62 44.41,51.51 44.35,51.45 UH4.H33
PCIE_PTX_C_DRX_N5: length 62.3
  TOP w0.145: UR1.4 25.03,64.84 25.29,64.57 25.9,64.57 v9(26.01,64.67)
  BOTTOM w0.145: CR7.2 54.11,45.42 55.57,46.88 55.57,48.08 55.22,48.43 54.5,48.43 54.33,48.6 54.33,48.84 54.5,49.01 55.22,49.01 55.57,49.36 55.57,50.04 55.2,50.41 54.85,50.41 54.64,50.62 54.64,50.94 54.82,51.12 55.58,51.12 56,51.55 56,53.48 55.65,53.83 54.64,53.83 54.47,54 54.47,54.24 54.64,54.41 55.65,54.41 56,54.76 56,55.18 54.87,56.31 54.37,56.31 54.18,56.12 53.94,56.12 53.77,56.29 53.77,56.53 53.96,56.72 53.96,57.21 53.61,57.57 53.12,57.57 52.83,57.28 52.59,57.28 52.42,57.45 52.42,57.69 52.71,57.98 52.71,58.47 52.4,58.78 52.4,60.2 51.15,61.45 46.47,61.45 46.19,61.17 46.19,60.02 46.42,59.79 46.42,58.67 46.09,58.34 45.54,58.34 45.22,58.65 45.22,59.78 45.43,59.99 45.43,61.74 44.8,62.38 29.76,62.38 27.55,64.6 26.08,64.6 v9(26.01,64.67)
PCIE_PTX_C_DRX_N14: length 4.1
  TOP w0.145: CD67.2 95.57,15.53 95.57,15.31 v9(95.5,15.12)
  BOTTOM w0.145: JNGFF2.35 97.09,14.12 96.78,13.81 96.08,13.81 95.5,14.4 v9(95.5,15.12)
PCIE_PTX_C_DRX_N15: length 7.5
  TOP w0.145: CD59.2 93.32,13.6 93.95,12.97 95.36,12.97 95.6,12.73 95.6,12.17 v9(95.5,11.97)
  BOTTOM w0.145: JNGFF2.23 96.93,11.12 96.8,10.99 95.93,10.99 95.5,11.42 v9(95.5,11.97)
PCIE_PTX_C_DRX_N16: length 8.7
  TOP w0.145: v9(95.5,9.12) 95.56,9.19 95.56,9.53 94.98,10.12 92.9,10.12 92.14,10.87 92.14,11.98 CD64.2
  BOTTOM w0.145: JNGFF2.11 97.79,8.11 95.96,8.11 95.57,8.5 95.57,8.95 v9(95.5,9.12)
PCIE_PTX_C_DRX_P5: length 62.3
  TOP w0.145: v9(26.01,64.09) 25.83,64.26 25.17,64.26 24.99,64.44 UR1.3
  BOTTOM w0.145: v9(26.01,64.09) 26.2,64.29 27.42,64.29 29.64,62.07 44.67,62.07 45.12,61.61 45.12,60.12 44.91,59.9 44.91,58.53 45.41,58.03 46.22,58.03 46.73,58.54 46.73,59.92 46.5,60.14 46.5,61.04 46.6,61.14 51.02,61.14 52.09,60.07 52.09,58.65 52.4,58.34 52.4,58.11 52.11,57.82 52.11,57.32 52.46,56.97 52.96,56.97 53.24,57.26 53.48,57.26 53.65,57.09 53.65,56.85 53.46,56.66 53.46,56.16 53.82,55.81 54.31,55.81 54.5,56 54.74,56 55.69,55.05 55.69,54.89 55.52,54.72 54.51,54.72 54.16,54.37 54.16,53.87 54.51,53.52 55.52,53.52 55.69,53.35 55.69,51.68 55.45,51.43 54.69,51.43 54.33,51.06 54.33,50.5 54.72,50.1 55.08,50.1 55.26,49.91 55.26,49.49 55.09,49.32 54.37,49.32 54.02,48.97 54.02,48.47 54.37,48.12 55.09,48.12 55.26,47.95 55.26,47.01 53.98,45.73 53.83,45.73 53.7,45.86 53.7,46.54 53.6,46.63 53.39,46.63 53.2,46.44 CR6.2
PCIE_PTX_C_DRX_P14: length 4.1
  TOP w0.145: CD68.2 95.97,15.62 95.88,15.54 95.88,15.33 v9(96.08,15.12)
  BOTTOM w0.145: JNGFF2.37 96.92,14.62 96.79,14.48 96.79,14.26 96.65,14.12 96.21,14.12 95.81,14.52 95.81,14.81 95.99,14.99 v9(96.08,15.12)
PCIE_PTX_C_DRX_P15: length 7.5
  TOP w0.145: v9(96.08,11.97) 95.91,12.15 95.91,12.86 95.49,13.28 v10(94.46,13.28) 94.08,13.28 93.63,13.73 93.63,14.03 CD66.2
  BOTTOM w0.145: JNGFF2.25 96.99,11.62 96.67,11.3 96.06,11.3 95.81,11.55 95.81,11.63 96.01,11.83 v9(96.08,11.97)
PCIE_PTX_C_DRX_P16: length 8.6
  TOP w0.145: v9(96.08,9.12) 95.87,9.34 95.87,9.66 95.11,10.42 v10(94.01,10.42) 93.03,10.42 92.45,11 92.45,11.59 CD65.2
  BOTTOM w0.145: v9(96.08,9.12) 95.88,8.92 95.88,8.63 96.09,8.42 96.48,8.42 96.58,8.51 96.58,8.58 96.69,8.69 96.91,8.69 96.99,8.62 JNGFF2.13
PCIE_PTX_C_RD_DRX_N1: length 4.1
  BOTTOM w0.145: JIO1.A6 109.06,21.23 108.74,21.55 108.74,22.57 108.31,23 107.78,23 CH114.2
PCIE_PTX_C_RD_DRX_P1: length 4.1
  BOTTOM w0.145: JIO1.A7 108.31,19.9 108.75,20.34 108.75,21.1 108.43,21.42 108.43,22.44 108.18,22.69 107.83,22.69 CH115.2
PCIE_PTX_C_TRX_N9: length 57.8
  IN3 w0.086: v3(41.53,76.62) 41.6,76.54 42.23,76.54 49.68,69.1 50,69.1 51.8,67.3 51.8,66.39 52.98,65.21 53.52,65.21 53.88,64.85 53.88,64.27 53.34,63.73 53.34,63.28 53.71,62.91 54.14,62.91 54.83,63.6 55.4,63.6 56.34,62.66 56.34,62.19 56.07,61.91 56.07,61.46 56.29,61.24 57.22,61.24 57.29,61.31 58.12,61.31 58.8,60.63 58.8,57.81 58.39,57.4 58.39,55.7 58.87,55.22 58.87,53.06 58.39,52.59 58.39,51.75 57.83,51.18 57.83,49.62 57.72,49.51 57.72,48.2 58.25,47.67 58.25,46.74 57.43,45.92 57.06,45.92 56.67,45.54 56.17,45.54 55.85,45.85 55.85,46.25 56.7,47.1 56.7,47.24 56.6,47.34 56.45,47.34 55.61,46.5 55.21,46.5 54.92,46.78 54.92,47.18 55.77,48.03 55.77,48.17 55.67,48.27 55.53,48.27 54.68,47.42 54.28,47.42 53.87,47.83 53.87,51.03 53.66,51.24 v3(53.37,51.24)
PCIE_PTX_C_TRX_N10: length 55.7
  IN3 w0.086: v3(54.92,52.67) 54.36,52.67 54.09,52.4 54.09,51.83 54.57,51.35 54.57,51.02 55.01,50.58 55.75,50.58 55.86,50.48 55.86,50.34 55.75,50.24 54.84,50.24 54.57,49.97 54.57,49.36 54.93,49 56.64,49 57.02,49.38 57.02,49.8 57.13,49.91 57.13,51.34 56.76,51.71 56.01,51.71 55.62,52.1 55.62,52.35 55.76,52.49 56.4,52.49 56.68,52.22 57.1,52.22 57.46,52.57 57.46,53.07 57.42,53.11 57.42,53.36 57.17,53.61 55.54,53.61 55.39,53.76 55.39,53.93 55.58,54.13 55.82,54.13 56.1,54.41 56.1,55.24 56.2,55.34 56.35,55.34 56.45,55.24 56.45,54.41 56.73,54.13 57.78,54.13 58.12,54.46 58.12,54.94 57.68,55.38 57.68,57.27 57.19,57.76 57.19,59.98 56.69,60.48 56.01,60.48 55.19,61.3 55.19,61.73 54.72,62.19 53.38,62.19 52.62,62.95 52.62,64.54 51.07,66.09 51.07,67.02 49.71,68.38 49.16,68.38 48.03,69.5 48.03,69.63 42.24,75.42 40.94,75.42 40.75,75.61 40.75,76.23 40.44,76.54 39.77,76.54 v3(39.69,76.62)
PCIE_PTX_C_TRX_N11: length 56.7
  IN3 w0.086: v3(53.37,53.78) 53.52,53.63 53.72,53.63 54.29,54.2 54.29,54.74 54.56,55.01 54.9,55.01 55.04,55.15 55.04,55.31 54.9,55.45 54.27,55.45 53.77,55.95 53.77,57.35 54.24,57.82 54.64,57.82 55.1,57.35 55.1,56.62 55.25,56.48 55.43,56.48 55.56,56.61 55.96,56.61 56.16,56.4 56.42,56.4 56.54,56.53 56.54,56.97 55.91,57.6 55.45,57.6 55.06,58 55.06,58.42 55.42,58.78 56.03,58.78 56.15,58.9 56.15,59.21 56.02,59.34 55.18,59.34 54.88,59.64 54.88,60.18 54.72,60.34 54.35,60.34 53.73,59.71 53.73,59.54 54.1,59.18 54.1,58.36 53.61,57.87 53.02,57.87 52.73,58.16 52.73,58.56 52.84,58.66 52.84,58.8 52.25,59.39 52.25,59.95 53.01,60.71 53.01,61 52.87,61.14 52.57,61.14 51.76,60.33 51.3,60.33 50.65,60.99 50.65,61.63 50.95,61.93 51.67,61.93 51.81,62.07 51.81,62.28 51.69,62.4 50.68,62.4 50.21,62.87 50.21,63.29 50.51,63.59 51.26,63.59 51.52,63.86 51.52,64.13 51.35,64.31 51.23,64.31 50.93,64.01 50.44,64.01 50.05,64.4 50.05,64.82 50.39,65.17 50.39,65.31 50.29,65.42 50.15,65.42 49.91,65.17 49.51,65.17 49.12,65.56 49.12,66.67 49.44,66.99 49.44,67.21 49.31,67.34 48.7,67.34 47.01,69.04 47.01,69.2 41.8,74.4 40.26,74.4 40.12,74.54 38.27,74.54 37.53,75.28 37.53,75.91 v3(37.85,76.62)
PCIE_PTX_C_TRX_N12: length 57.4
  IN3 w0.086: v3(36.01,76.62) 36.01,76.28 36.1,76.2 36.76,76.2 37.1,75.86 37.1,75.15 38.14,74.11 39.81,74.11 39.98,73.95 41.7,73.95 43.25,72.4 43.25,72.18 43.62,71.81 43.84,71.81 44.17,71.48 44.17,71.25 44.55,70.88 44.77,70.88 45.1,70.55 45.1,70.11 45,70.01 45,69.86 45.38,69.48 45.56,69.48 45.64,69.57 46.08,69.57 46.58,69.07 46.58,68.87 46.68,68.77 46.68,68.43 46.91,68.2 47.25,68.2 47.61,67.84 47.61,67.54 47.82,67.32 48.13,67.32 48.71,66.74 48.71,65.62 48.41,65.32 48.41,65.01 48.62,64.79 48.75,64.79 48.85,64.89 49.22,64.89 49.59,64.52 49.59,64.02 49.26,63.68 48.65,63.68 47.89,62.92 47.89,62.7 47.99,62.6 48.61,62.6 48.71,62.7 48.71,62.77 49,63.05 49.4,63.05 49.68,62.77 49.68,62.7 49.78,62.6 49.92,62.6 50.21,62.31 50.21,61.91 49.92,61.63 49.51,61.63 49.41,61.53 49.41,61.23 49.51,61.13 49.99,61.13 50.27,60.85 50.27,60.45 49.99,60.17 49.51,60.17 49.41,60.06 49.41,59.93 49.13,59.65 48.73,59.65 48.45,59.93 48.45,61.53 48.34,61.63 47.99,61.63 47.89,61.53 47.89,60.5 47.66,60.28 47.66,59.91 48.87,58.7 49.01,58.7 50.2,59.89 50.6,59.89 50.88,59.61 50.88,59.21 49.69,58.01 49.69,57.87 49.79,57.77 49.94,57.77 51.41,59.25 51.81,59.25 52.1,58.96 52.1,58.57 51.99,58.45 51.99,58.31 53.35,56.95 53.35,56.55 53.06,56.27 52.66,56.27 51.3,57.63 51.16,57.63 50.67,57.14 50.67,57 50.81,56.86 51.3,56.86 53.06,55.09 53.3,55.09 53.39,55.19 v3(53.39,55.28)
PCIE_PTX_C_TRX_P9: length 57.8
  IN3 w0.086: v3(53.37,51.8) 53.37,51.63 53.44,51.55 53.79,51.55 54.18,51.16 54.18,47.96 54.41,47.73 54.55,47.73 55.4,48.58 55.8,48.58 56.08,48.3 56.08,47.9 55.23,47.05 55.23,46.91 55.33,46.81 55.48,46.81 56.33,47.65 56.72,47.65 57.01,47.37 57.01,46.97 56.16,46.12 56.16,45.98 56.3,45.85 56.54,45.85 56.93,46.23 57.3,46.23 57.94,46.87 57.94,47.54 57.41,48.07 57.41,49.64 57.52,49.75 57.52,51.31 58.08,51.87 58.08,52.71 58.56,53.19 58.56,55.09 58.08,55.57 58.08,57.53 58.49,57.94 58.49,60.5 57.99,61 57.42,61 57.34,60.93 56.16,60.93 55.76,61.33 55.76,62.04 56.03,62.32 56.03,62.53 55.27,63.29 54.96,63.29 54.27,62.6 53.58,62.6 53.03,63.15 53.03,63.86 53.57,64.4 53.57,64.72 53.4,64.9 52.85,64.9 51.49,66.26 51.49,67.17 49.87,68.79 49.55,68.79 42.1,76.23 41.62,76.23 41.54,76.16 v3(41.54,75.75)
  BOTTOM w0.076: v3(41.54,75.75) 41.53,75.76 UT2.Y23
PCIE_PTX_C_TRX_P10: length 55.7
  IN3 w0.086: v3(39.69,75.72) 39.34,75.72 39.23,75.83 39.23,76.11 39.35,76.23 40.31,76.23 40.44,76.1 40.44,75.48 40.81,75.11 42.11,75.11 47.72,69.5 47.72,69.37 49.03,68.07 49.58,68.07 50.76,66.89 50.76,65.96 52.31,64.41 52.31,62.82 53.25,61.88 54.6,61.88 54.88,61.6 54.88,61.17 55.88,60.17 56.56,60.17 56.88,59.86 56.88,57.63 57.37,57.15 57.37,55.25 57.81,54.81 57.81,54.59 57.65,54.44 56.86,54.44 56.76,54.54 56.76,55.37 56.47,55.65 56.07,55.65 55.79,55.37 55.79,54.54 55.69,54.44 55.46,54.44 55.08,54.06 55.08,53.63 55.41,53.3 57.04,53.3 57.11,53.23 57.11,52.98 57.15,52.94 57.15,52.7 56.97,52.53 56.81,52.53 56.53,52.8 55.63,52.8 55.31,52.48 55.31,51.97 55.88,51.4 56.64,51.4 56.82,51.22 56.82,50.04 56.71,49.93 56.71,49.51 56.51,49.31 55.06,49.31 54.88,49.49 54.88,49.84 54.97,49.93 55.88,49.93 56.17,50.21 56.17,50.61 55.88,50.89 55.14,50.89 54.88,51.15 54.88,51.48 54.4,51.96 54.4,52.27 54.49,52.36 54.92,52.36 55,52.28 55,52.19 v3(54.92,52.11)
  BOTTOM w0.076: UT2.T23 v3(39.69,75.72)
PCIE_PTX_C_TRX_P11: length 56.7
  IN3 w0.086: v3(53.37,53.22) 53.46,53.32 53.85,53.32 54.6,54.07 54.6,54.61 54.69,54.7 55.03,54.7 55.35,55.02 55.35,55.43 55.02,55.76 54.4,55.76 54.08,56.08 54.08,57.22 54.37,57.51 54.51,57.51 54.79,57.22 54.79,56.5 55.12,56.17 55.56,56.17 55.69,56.3 55.83,56.3 56.03,56.09 56.55,56.09 56.85,56.4 56.85,57.1 56.03,57.91 55.58,57.91 55.37,58.13 55.37,58.3 55.54,58.47 56.16,58.47 56.46,58.78 56.46,59.34 56.15,59.65 55.31,59.65 55.19,59.77 55.19,60.3 54.85,60.65 54.22,60.65 53.42,59.84 53.42,59.42 53.79,59.05 53.79,58.49 53.48,58.18 53.15,58.18 53.04,58.29 53.04,58.43 53.15,58.53 53.15,58.93 52.56,59.52 52.56,59.82 53.32,60.58 53.32,61.13 53,61.45 52.44,61.45 51.63,60.64 51.43,60.64 50.96,61.11 50.96,61.5 51.08,61.62 51.8,61.62 52.12,61.94 52.12,62.41 51.82,62.71 50.81,62.71 50.52,63 50.52,63.16 50.64,63.28 51.39,63.28 51.83,63.73 51.83,64.26 51.48,64.62 51.1,64.62 50.8,64.32 50.57,64.32 50.36,64.53 50.36,64.69 50.7,65.04 50.7,65.44 50.42,65.73 50.02,65.73 49.78,65.48 49.63,65.48 49.43,65.69 49.43,66.54 49.75,66.86 49.75,67.34 49.44,67.65 48.83,67.65 47.32,69.17 47.32,69.33 41.93,74.71 40.38,74.71 40.25,74.85 38.4,74.85 37.84,75.41 37.84,75.7 v3(37.85,75.71)
  BOTTOM w0.076: UT2.M23 v3(37.85,75.71)
PCIE_PTX_C_TRX_P12: length 57.4
  IN3 w0.086: v3(53.39,54.72) 53.33,54.78 52.93,54.78 51.17,56.55 50.69,56.55 50.36,56.87 50.36,57.27 51.03,57.94 51.43,57.94 52.79,56.58 52.93,56.58 53.04,56.68 53.04,56.82 51.68,58.18 51.68,58.58 51.79,58.69 51.79,58.84 51.68,58.94 51.54,58.94 50.06,57.46 49.66,57.46 49.38,57.74 49.38,58.14 50.57,59.33 50.57,59.48 50.47,59.58 50.33,59.58 49.14,58.39 48.74,58.39 47.35,59.78 47.35,60.41 47.58,60.63 47.58,61.66 47.86,61.94 48.47,61.94 48.76,61.66 48.76,60.06 48.86,59.95 49,59.95 49.1,60.06 49.1,60.19 49.38,60.48 49.86,60.48 49.96,60.58 49.96,60.72 49.86,60.82 49.38,60.82 49.1,61.1 49.1,61.66 49.38,61.94 49.79,61.94 49.9,62.04 49.9,62.19 49.79,62.29 49.65,62.29 49.37,62.57 49.37,62.64 49.27,62.74 49.12,62.74 49.02,62.64 49.02,62.57 48.74,62.29 47.86,62.29 47.58,62.57 47.58,63.05 48.52,63.99 49.13,63.99 49.28,64.15 49.28,64.39 49.1,64.58 48.97,64.58 48.88,64.48 48.49,64.48 48.1,64.88 48.1,65.45 48.4,65.75 48.4,66.61 48,67.01 47.7,67.01 47.3,67.41 47.3,67.72 47.12,67.89 46.79,67.89 46.37,68.3 46.37,68.64 46.27,68.74 46.27,68.94 45.95,69.26 45.77,69.26 45.69,69.17 45.25,69.17 44.69,69.73 44.69,70.14 44.79,70.24 44.79,70.42 44.64,70.57 44.42,70.57 43.86,71.13 43.86,71.35 43.71,71.5 43.49,71.5 42.94,72.05 42.94,72.27 41.57,73.64 39.85,73.64 39.68,73.8 38.01,73.8 36.79,75.02 36.79,75.73 36.63,75.89 36.16,75.89 v3(36.01,75.74)
  BOTTOM w0.076: UT2.H23 v3(36.01,75.74)
PCIE_PTX_DRX_N1: length 77.7
  IN3 w0.086: v3(96.85,21.75) 96.78,21.68 96.58,21.68 96.37,21.89 96.37,22.25 95.44,23.18 93.7,23.18 93.42,22.89 91.72,22.89 91.39,23.22 82.44,23.22 82.05,23.62 77.66,23.62 77.26,24.01 70,24.01 58.97,35.05 58.97,43.14 58.09,44.02 58.09,45.03 57.82,45.3 57.26,45.3 v3(57.23,45.34)
  BOTTOM w0.076: UH4.A16 47.41,43.04 47.35,42.98 47.35,42.87 47.43,42.79 48.35,42.79 48.62,43.07 48.62,43.17 48.68,43.22
  BOTTOM w0.145: v3(57.23,45.34) 57.17,45.28 55.73,45.28 v10(55.01,44.55) 54.4,43.94 50.67,43.94 50.1,43.37 48.82,43.37 48.68,43.22 ; CH114.1 106.87,22.94 106.56,22.94 106.14,23.36 100.35,23.36 98.66,21.68 96.92,21.68 v3(96.85,21.75)
PCIE_PTX_DRX_N5: length 7.2
  BOTTOM w0.076: 48.68,46.33 48.66,46.33 48.58,46.4 48.44,46.4 47.82,45.78 47.63,45.78 47.41,45.57 47.01,45.57 46.9,45.54 46.75,45.43 46.39,45.43 46.22,45.59 46.22,45.76 UH4.D22
  BOTTOM w0.145: 48.68,46.33 50.73,46.33 v10(51.14,45.92) 51.35,45.71 51.99,45.71 CR7.1
PCIE_PTX_DRX_N14: length 80.7
  TOP w0.145: v9(97.32,20.17) 97.39,20.1 v10(97.39,18.88) 97.39,18.16 96.82,17.59 96.27,17.59 CD67.1
  IN3 w0.086: v9(97.32,20.17) 97.36,20.17 97.55,20.37 97.55,20.55 97.45,20.66 97.13,20.66 96.9,20.43 96.9,20.05 96.29,19.44 83.6,19.44 82.89,18.73 81.22,18.73 81.17,18.78 78.27,18.78 76.8,20.25 69.02,20.25 55.86,33.41 55.86,41.76 50.5,47.12 50.5,47.36 49.78,48.08 49.78,51.36 49.59,51.54 49.59,53.69 49.47,53.82 49.34,53.82 49.28,53.75 49.28,53.64 49.17,53.54 49.04,53.54 48.94,53.63 v3(48.94,53.82)
  BOTTOM w0.089: v3(48.94,53.82) 48.74,54.02 48.46,54.02 48.09,53.65 47.46,53.65 47.3,53.5 47.03,53.5 46.94,53.59 46.94,53.7 46.99,53.75 UH4.B38
PCIE_PTX_DRX_N15: length 77.5
  TOP w0.145: CD59.1 v10(93.32,19.39) 93.32,21.04 94.24,21.97 v9(94.24,22.19)
  IN3 w0.086: v3(50.27,54.97) 50.35,54.89 51.16,54.89 52.22,53.84 52.22,47.88 57.57,42.53 57.57,34.17 69.58,22.16 81.02,22.16 81.48,21.7 90.8,21.7 91.33,21.16 93.59,21.16 94.24,21.82 v9(94.24,22.19)
  BOTTOM w0.076: UH4.B39 47.42,54.51 47.72,54.51 47.79,54.59 48.09,54.59 48.36,54.86 48.78,54.86 48.85,54.93 48.87,54.93
  BOTTOM w0.145: v3(50.27,54.97) 50.24,54.93 48.87,54.93
PCIE_PTX_DRX_N16: length 78.5
  TOP w0.145: CD64.1 92.05,19.01 91.42,19.63 91.42,21.81 91.79,22.18 v9(92.81,22.18)
  IN3 w0.086: v3(50.29,55.82) 50.36,55.75 51.34,55.75 52.96,54.13 52.96,48.16 58.27,42.85 58.27,34.71 69.71,23.27 74.86,23.27 75.23,22.9 81.33,22.9 81.73,22.5 91.04,22.5 91.37,22.18 v9(92.81,22.18)
  BOTTOM w0.076: UH4.A41 47.69,55.15 47.81,55.15 48.38,55.71 48.77,55.71 48.85,55.79 48.87,55.79
  BOTTOM w0.145: v3(50.29,55.82) 50.25,55.79 48.87,55.79
PCIE_PTX_DRX_P1: length 77.7
  IN3 w0.086: v3(57.23,44.96) 57.26,44.99 57.69,44.99 57.78,44.9 57.78,43.89 58.66,43.01 58.66,34.92 69.88,23.7 77.14,23.7 77.53,23.31 81.92,23.31 82.32,22.91 91.26,22.91 91.59,22.58 93.54,22.58 93.83,22.87 95.32,22.87 96.07,22.12 96.07,21.76 96.46,21.37 v3(96.85,21.37)
  BOTTOM w0.076: UH4.B16 47.19,42.86 47.19,42.8 47.36,42.63 48.41,42.63 48.74,42.95 48.84,42.95 48.86,42.97
  BOTTOM w0.145: CH115.1 106.92,22.63 106.43,22.63 106.01,23.06 100.48,23.06 98.79,21.37 v3(96.85,21.37) ; v3(57.23,44.96) 55.85,44.96 54.52,43.63 50.8,43.63 50.23,43.06 48.95,43.06 48.86,42.97
PCIE_PTX_DRX_P5: length 7.2
  BOTTOM w0.076: 48.68,46.64 48.66,46.64 48.58,46.57 48.37,46.57 47.75,45.95 47.56,45.95 47.34,45.73 46.99,45.73 46.83,45.69 46.69,45.59 46.46,45.59 46.39,45.66 46.39,45.87 46.47,45.95 46.57,45.95 UH4.C22
  BOTTOM w0.145: 48.68,46.64 v10(49.95,46.64) 50.86,46.64 51.48,46.02 52,46.02 CR6.1
PCIE_PTX_DRX_P14: length 80.6
  TOP w0.145: v9(97.9,20.17) 97.7,19.97 97.7,18.03 96.95,17.28 96.4,17.28 96.1,16.98 96.1,16.81 CD68.1
  IN3 w0.086: v9(97.9,20.17) 97.86,20.28 97.86,20.68 97.58,20.97 97,20.97 96.59,20.55 96.59,20.18 96.16,19.75 83.47,19.75 82.76,19.04 81.35,19.04 81.3,19.09 78.4,19.09 76.93,20.56 69.15,20.56 56.17,33.54 56.17,41.89 50.81,47.25 50.81,47.49 50.09,48.21 50.09,51.49 49.9,51.67 49.9,53.82 49.53,54.2 v3(48.94,54.2)
  BOTTOM w0.089: v3(48.94,54.2) 48.38,54.2 48.01,53.83 47.5,53.83 47.21,53.99 47.01,53.99 UH4.C38
PCIE_PTX_DRX_P15: length 77.6
  TOP w0.145: CD66.1 93.63,16.1 93.63,20.91 94.48,21.77 v9(94.66,21.77)
  IN3 w0.086: v9(94.66,21.77) 94.48,21.62 93.72,20.85 91.21,20.85 90.67,21.39 81.35,21.39 80.89,21.85 69.45,21.85 57.26,34.04 57.26,42.41 51.91,47.75 51.91,53.71 51.03,54.58 v3(50.27,54.58)
  BOTTOM w0.076: UH4.A39 47.52,54.08 47.6,54.01 47.71,54.01 47.79,54.09 47.79,54.35 47.86,54.42 48.15,54.42 48.43,54.69 48.78,54.69 48.84,54.63 48.83,54.62 48.85,54.62 48.85,54.62 48.94,54.62
  BOTTOM w0.145: 48.94,54.62 50.24,54.62 v3(50.27,54.58)
PCIE_PTX_DRX_P16: length 78.5
  TOP w0.145: CD65.1 92.36,13.56 92.36,19.13 91.73,19.76 v10(91.73,20.59) 91.73,21.68 91.92,21.87 92.12,21.87 92.28,21.72 92.28,21.64 92.43,21.48 92.7,21.48 v9(92.81,21.6)
  IN3 w0.086: v9(92.81,21.6) 92.53,21.87 91.24,21.87 90.92,22.19 81.6,22.19 81.21,22.59 75.1,22.59 74.73,22.96 69.58,22.96 57.96,34.58 57.96,42.72 52.65,48.03 52.65,54 51.21,55.44 v3(50.29,55.44)
  BOTTOM w0.076: UH4.A40 47.69,54.99 47.88,54.99 48.44,55.55 48.77,55.55 48.85,55.48 48.87,55.48
  BOTTOM w0.145: v3(50.29,55.44) 50.25,55.48 48.87,55.48
PCIE_PTX_TRX_N9: length 6.9
  BOTTOM w0.076: UH4.C31 46.73,50.33 46.73,50.26 46.9,50.09 48.1,50.09 48.99,50.98 51.13,50.98 51.49,51.35
  BOTTOM w0.145: CT95.2 52.68,51.35 v10(51.85,51.35) 51.49,51.35
PCIE_PTX_TRX_N10: length 8.6
  BOTTOM w0.076: UH4.C32 46.83,51.23 47.18,51.23 47.25,51.3 48.37,51.3 48.78,51.71 50.9,51.71 51.65,52.46 51.76,52.46 51.83,52.54 51.85,52.54
  BOTTOM w0.145: 51.85,52.54 53.53,52.54 53.53,52.54 54.21,52.54 CT20.2
PCIE_PTX_TRX_N11: length 7.2
  BOTTOM w0.076: UH4.C33 47.05,51.9 47.35,51.9 47.51,51.75 48.08,51.75 48.52,52.19 50.24,52.19 50.57,52.52
  BOTTOM w0.145: CT7.2 52.73,53.73 v10(51.95,53.73) 51.78,53.73 50.57,52.52
PCIE_PTX_TRX_N12: length 7.3
  BOTTOM w0.076: 51.35,54.44 51.34,54.42 51.34,54.32 51.13,54.11 51.13,53.82 49.96,52.66 48.35,52.66 48.27,52.58 47.83,52.58 47.61,52.36 47.38,52.36 UH4.B35
  BOTTOM w0.145: 51.35,54.44 v10(51.92,55.01) 52.11,55.2 52.73,55.2 CT11.2
PCIE_PTX_TRX_P9: length 7
  BOTTOM w0.076: UH4.B31 46.95,50.52 46.9,50.47 46.9,50.33 46.97,50.25 48.03,50.25 48.92,51.15 51.06,51.15 51.29,51.38 51.29,51.43 51.41,51.55 51.45,51.55 51.48,51.58 51.49,51.58
  BOTTOM w0.145: CT94.2 52.78,51.78 52.67,51.66 51.57,51.66 51.49,51.58
PCIE_PTX_TRX_P10: length 8.6
  BOTTOM w0.076: 51.85,52.23 51.83,52.23 51.76,52.3 51.72,52.3 50.97,51.54 48.85,51.54 48.44,51.14 47.32,51.14 47.24,51.06 47.24,50.83 47.16,50.75 46.95,50.75 46.87,50.84 46.87,50.93 UH4.B32
  BOTTOM w0.145: 51.85,52.23 53.65,52.23 53.66,52.23 54.21,52.23 CT5.2
PCIE_PTX_TRX_P11: length 7.2
  BOTTOM w0.076: UH4.B33 47.04,51.58 47.04,51.66 47.12,51.74 47.28,51.74 47.44,51.58 48.15,51.58 48.59,52.03 50.31,52.03 50.42,52.14 50.52,52.14
  BOTTOM w0.145: 50.52,52.14 v10(50.97,52.59) 51.8,53.42 52.17,53.42 52.23,53.36 52.23,53.13 52.38,52.99 52.59,52.99 52.78,53.18 CT22.2
PCIE_PTX_TRX_P12: length 7.3
  BOTTOM w0.076: UH4.A35 47.52,51.97 47.59,51.91 47.81,51.91 47.88,51.98 47.88,52.1 47.8,52.18 47.8,52.32 47.9,52.42 48.34,52.42 48.42,52.49 50.03,52.49 51.29,53.75 51.29,54.05 51.45,54.21 51.55,54.21 51.57,54.22
  BOTTOM w0.145: CT9.2 52.64,54.89 52.24,54.89 51.57,54.22
PCIE_RBIAS: length 2.3
  IN1 w0.152: v2(38.88,77.13) 38.53,77.48 v4(38.53,78.57)
  GND2 w0.152: v4(38.53,78.57) 38.53,78.86 v5(38.48,78.92)
  GND3 w0.152: v5(38.48,78.92) 38.5,78.94 v6(38.5,79.27)
PCIE_RCOMPN: length 3
  BOTTOM w0.152: UH4.B18 47.7,43.7 47.8,43.79
  BOTTOM w0.305: 47.8,43.79 48.47,44.47 49.27,44.47 RH158.2
PCIE_RCOMPP: length 3.3
  BOTTOM w0.102: 48,43.44 46.8,43.44 UH4.C17
  BOTTOM w0.305: RH158.1 48.51,43.95 48,43.44
PCIE_WAKE#: length 208.2
  TOP w0.127: v7(98.34,18.87) 98.34,18.01 97.08,16.74 97.08,7.96 v1(95.67,6.55) 94.78,5.66 v2(94.52,5.66) ; RT429.2 v9(44.74,87.41)
  IN1 w0.064: v4(25.64,41.36) 26.37,42.09 26.37,46.82 26.85,47.3 26.85,50.58 29.36,53.09 29.36,53.35 29.58,53.57 30.46,53.57 30.9,54.01 30.9,55.2 32.36,56.66 34.75,56.66 37.13,59.05 37.42,59.05 40.52,62.15 40.52,62.67 42.33,64.47 42.33,69.23 43.27,70.18 44.82,71.72 44.82,87.33 v9(44.74,87.41) ; v2(94.52,5.66) 94.48,5.7 91.51,5.7 90.46,4.65 86.51,4.65 86,4.14 84.86,4.14 84.61,4.39 83.73,4.39 83.5,4.17 79.98,4.17 79.78,3.97 78.65,3.97 78.38,4.24 73.1,4.24 72.95,4.39 61.09,4.39 59.94,5.54 55.97,5.54 55.73,5.77 53.12,5.77 52.69,6.2 51.91,6.2 51.66,5.96 51.66,4.87 v2(51.41,4.62) 51.25,4.62 50.77,5.1 49.39,5.1 49.01,4.72 49.01,3.43 47.7,2.13 36.54,2.13 v9(36.28,1.88) ; v4(104.48,19.47) 103.19,18.18 99.6,18.18 98.92,18.87 v7(98.34,18.87)
  GND2 w0.102: v7(37.26,9.1) v5(36.93,9.1) ; v4(25.64,41.36) v5(25.31,41.36) ; v7(98.34,18.87) 98.34,19.03 v5(98.5,19.2) ; v5(104.71,19.71) v4(104.48,19.47)
  GND3 w0.102: v8(24.99,41.28) 25.23,41.28 v5(25.31,41.36) ; v6(105.06,19.9) 104.9,19.9 v5(104.71,19.71) ; v6(98.83,19.2) v5(98.5,19.2) ; v5(36.93,9.1) v6(37.36,9.1)
  IN3 w0.064: v3(36.67,14.24) 36.32,14.24 35.97,14.59 35.97,16.08 33.09,18.95 33.09,20.58 31.98,21.69 31.98,26.36 30.89,27.44 30.54,27.44 29.52,28.46 29.52,28.87 26.61,31.78 26.33,31.78 25.98,32.14 25.61,32.14 23.15,34.59 23.15,38.14 24.85,39.83 24.85,41.14 v8(24.99,41.28)
  BOTTOM w0.127: v9(36.28,1.88) 36.28,2.33 37.88,3.93 37.88,6.81 38.24,7.17 38.24,8.39 37.52,9.1 v6(37.36,9.1) 36.85,9.61 36.85,13.14 36.67,13.32 v3(36.67,14.24) ; RD18.2 87.02,19.75 87.44,20.18 88.93,20.18 89.44,20.7 94.12,20.7 94.46,21.04 96.3,21.04 96.41,20.93 98.51,20.93 98.97,20.47 98.97,19.33 v6(98.83,19.2) ; RT429.2 v9(44.74,87.41)
PCIE_WAKE#_AR: length 12.8
  TOP w0.127: RT242.1 47.32,88.9 46.96,88.54 46.22,88.54 RT430.1 RT431.1 45.56,89.55 45.47,89.64 v1(45.12,89.64) 44.83,89.64 44.74,89.55 RT429.1 44.97,88.28 44.98,88.28 45.18,88.09 45.18,86.89 44.87,86.57 42.5,86.57 v9(41.67,87.4)
  BOTTOM w0.076: RT27.2 41.88,87.61 v9(41.67,87.4) 41.67,87.16 41.07,86.56 UT2.W1
PCIE_WAKE#_AR_R: length 2.6
  TOP w0.127: v1(48.8,89.05) RT242.2 47.91,88.16 47.93,88.14 RT241.2
  GND2 w0.102: v7(47.93,88.09) 47.93,88.21 v5(47.76,88.38)
  GND3 w0.102: v6(47.7,88.04) 47.7,88.32 v5(47.76,88.38)
PCIE_WAKE#_R: length 3.7
  TOP w0.127: UE3.N13 50.35,7.61 51.25,6.71 v1(51.25,6.05) 51.41,5.89 RE185.1 RE127.1
PD1_LPS1#: length 234.2
  TOP w0.127: v7(17.62,76.66) 17.62,74.86 17.92,74.56 PQ134.1 ; PQ134.1 17.92,73.76 15.91,71.75 15.91,70.99 15.64,70.72 14.22,70.72 13.88,70.38 13.88,69.17 14.46,68.59 14.46,63.46 13.51,62.5 13.51,55.82 v1(13.75,55.58) 13.75,54.35 v7(14.4,53.7) ; PQ134.1 18.46,74.03 18.52,73.97 PR114.2
  IN1 w0.064: v9(13.94,20.61) 13.94,20.88 14.48,21.43 14.48,23.85 15.13,24.5 15.13,26.12 15.6,26.59 15.6,27.78 14.63,28.76 14.63,32.43 10.18,36.87 9.67,36.87 8.09,38.45 8.09,52.24 8.89,53.04 13.74,53.04 v7(14.4,53.7) ; v4(17.88,92.56) 21.26,92.56 22.84,90.98 23.63,90.98 24.29,90.32 25.2,90.32 25.84,90.96 27.63,90.96 28.93,92.26 30.95,92.26 31.67,92.98 34.99,92.98 36,94 38.68,94 40.26,95.57 40.26,98.09 42.83,100.67 44.92,100.67 v2(45.2,100.95)
  GND2 w0.102: v5(17.62,76.19) v7(17.62,76.66) ; v5(17.42,92.56) v4(17.88,92.56)
  IN2 w0.074: v5(112.49,19.9) 110.81,19.9 106.35,24.37 104.31,24.37 103.92,23.97 98.59,23.97 98.42,24.14 96.66,24.14 95.84,23.33 91.24,23.33 88.41,20.5 88.41,19.67 85.9,17.15 85.9,15.55 83.29,12.94 78.66,12.94 78.06,12.35 44.18,12.35 43.35,13.18 34.19,13.18 33.53,13.83 25.41,13.83 22.75,16.49 19.45,16.49 17.2,18.74 17.2,19.01 15.35,20.86 14.2,20.86 v9(13.94,20.61) ; v5(17.62,76.19) 17.62,77.81 16.79,78.65 16.79,91.93 v5(17.42,92.56)
  GND3 w0.102: v5(112.49,19.9) v6(113.06,19.9)
PD2_LPS1#: length 180.9
  TOP w0.127: PR142.2 17.14,102.14 v9(17.1,102.1) ; PQ137.1 39.95,93.7 v1(40.45,93.2) v7(40.87,92.79)
  GND2 w0.102: v7(40.87,92.79) 40.78,92.79 v5(40.57,93)
  IN2 w0.074: v5(40.57,93) 40.88,92.69 41.25,92.69 43.2,90.74 46.32,90.74 46.58,90.47 48.5,90.47 50.49,88.48 50.49,82.33 49.81,81.65 49.81,77.98 52.44,75.35 54.65,75.35 55.74,74.25 55.74,71.32 54.91,70.49 54.91,67.54 51.13,63.76 51.13,63.3 49.85,62.03 49.85,54.76 52.73,51.88 52.73,44.62 52.28,44.18 52.28,34.59 52.33,34.54 52.33,29.59 55.12,26.8 55.12,26.55 55.84,25.84 58.47,25.84 59.4,24.91 72.42,24.91 73.92,26.4 75.64,26.4 76.1,25.94 77,25.94 77.23,25.71 78.56,25.71 79.11,26.26 88.93,26.26 91,28.32 95.6,28.32 96.98,26.95 103.51,26.95 103.74,26.72 v5(104.81,26.72)
  GND3 w0.102: v5(104.81,26.72) 104.85,26.75 v8(105.36,26.75) ; v8(40.15,93) v5(40.57,93)
  IN3 w0.064: v8(40.15,93) 40.15,93.15 36.78,96.53 34.57,96.53 v3(34.26,96.83) 34.01,97.08 34.01,98.51 33.65,98.86 33.65,102.42 31.98,104.1 28.14,104.1 26.57,102.53 17.53,102.53 v9(17.1,102.1) ; v3(105.89,21.36) 105.89,26.22 v8(105.36,26.75)
  BOTTOM w0.102: 105.56,20.32 105.56,18.4 JIO1.C9
  BOTTOM w0.127: 105.56,20.32 105.56,21.03 v3(105.89,21.36)
PD3_LPS1#: length 220
  TOP w0.127: v7(41.66,98.06) 42.84,98.06 PQ204.1 43.3,97.2 v1(42.64,96.54)
  IN1 w0.064: v4(81.96,16.69) 82.46,16.19 86.78,16.19 86.95,16.02 87.37,16.02 87.54,16.19 89.99,16.19 92.38,13.81 97.34,13.81 97.87,14.33 100.94,14.33 102.18,15.58 106.21,15.58 106.52,15.27 110.22,15.27 110.7,15.75 113.89,15.75 114.2,15.44 114.2,14.43 113.72,13.96 113.72,13.96 113.72,12.71 113.94,12.48 113.94,9.13 113.66,8.85 113.23,8.85 v4(112.35,7.97)
  GND2 w0.102: v5(111.92,7.9) 112.28,7.9 v4(112.35,7.97) ; v5(41.32,98.12) 41.39,98.06 v7(41.66,98.06) ; v4(81.96,16.69) v5(81.96,17.13)
  IN2 w0.074: v5(41.32,98.12) 40.27,98.12 37.45,100.94 36.71,100.94 35.39,102.26 32.54,102.26 31.56,101.28 31.56,98.6 29.47,96.51 26.58,96.51 26.04,95.96 23.29,95.96 21.55,94.22 21.55,90.03 19.32,87.8 19.32,79.74 20.37,78.69 20.37,72.26 18.3,70.19 18.3,66.28 16.43,64.4 16.43,63.18 14.4,61.16 14.4,59.32 16.35,57.37 18.36,57.37 20.45,55.28 21.54,55.28 23.34,53.48 23.34,50.61 23.85,50.09 23.85,42.33 23.45,41.93 23.45,41.44 24.08,40.82 24.08,36.74 23.72,36.38 23.72,35.33 24.45,34.6 25.7,34.6 28.17,32.13 30.14,32.13 31.43,30.84 31.43,27.76 33.82,25.37 34.96,25.37 37.81,22.52 37.81,20.69 38.46,20.03 45.28,20.03 45.88,20.63 49.44,20.63 50.04,20.03 52.33,20.03 52.51,19.85 55.6,19.85 56.48,18.97 61.3,18.97 63.32,20.99 72.93,20.99 74.34,19.58 76.89,19.58 77.89,18.57 80.52,18.57 v5(81.96,17.13)
  GND3 w0.102: v6(111.06,7.9) v5(111.92,7.9)
  GND3 w0.203: v5(41.32,98.12) 41.3,98.1 v6(40.87,98.1)
  BOTTOM w0.203: v6(40.87,98.1) 40.87,98.09 40.33,97.55 38.83,97.55 38.11,96.83 PQ201.1
PD4_LPS1#: length 207.3
  TOP w0.127: PQ203.1 44.98,96.81 43.43,98.35 v7(41.93,98.35) ; v7(81.89,17.71) 82.11,17.48 v1(82.11,12.62) 83.16,11.57 v7(83.16,8.7)
  GND2 w0.102: v7(83.16,8.7) 83.21,8.65 v5(83.6,8.65) ; v5(82.39,17.4) 82.19,17.4 v7(81.89,17.71) ; v5(41.74,97.63) 41.94,97.83 41.94,98.35 v7(41.93,98.35)
  IN2 w0.074: v5(41.74,97.63) 40.51,97.63 37.38,100.77 36.67,100.77 35.33,102.11 32.6,102.11 31.71,101.22 31.71,98.54 29.53,96.36 26.64,96.36 26.1,95.81 23.35,95.81 21.7,94.16 21.7,89.97 19.47,87.74 19.47,79.81 20.52,78.75 20.52,72.2 18.65,70.33 18.65,64.61 16.44,62.4 15.86,62.4 14.55,61.1 14.55,59.42 16.27,57.7 20.6,57.7 22.42,55.87 22.42,55.03 23.53,53.93 23.53,50.69 24,50.21 24,42.27 23.97,42.24 23.6,41.87 23.6,41.51 24.23,40.88 24.23,36.68 23.87,36.32 23.87,35.4 24.52,34.75 25.76,34.75 28.23,32.28 30.2,32.28 31.58,30.9 31.58,27.83 33.83,25.58 35,25.58 37.96,22.62 37.96,20.75 38.53,20.18 45.22,20.18 45.82,20.78 49.5,20.78 50.1,20.18 52.39,20.18 52.57,20 55.66,20 56.54,19.12 61.24,19.12 63.26,21.14 72.99,21.14 74.4,19.73 76.95,19.73 77.93,18.75 81.05,18.75 v5(82.39,17.4)
  GND3 w0.102: v8(83.96,8.63) 83.94,8.65 v5(83.6,8.65)
  GND3 w0.203: v6(40.93,97.43) 41.13,97.63 v5(41.74,97.63)
  IN3 w0.064: v8(83.96,8.63) 83.96,8.48 84.43,8.02 84.74,8.02 84.83,7.93 86.62,7.93 87.04,8.36 94.29,8.36 94.47,8.18 98.6,8.18 99.94,9.52 102.68,9.52 v6(103.06,9.9)
  BOTTOM w0.203: PQ202.1 40.33,96.83 v6(40.93,97.43)
