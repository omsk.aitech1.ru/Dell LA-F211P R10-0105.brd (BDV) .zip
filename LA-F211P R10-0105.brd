# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N152653999: length 4.3
  TOP w0.127: RH655.2 36.98,57.32 v1(36.98,57.31) 35.87,57.31 35.63,57.55 v7(35.27,57.55)
  GND2 w0.102: v7(35.27,57.55) 35.26,57.56 35.12,57.56 v5(34.96,57.4)
  GND3 w0.102: v6(35.42,57.52) 35.09,57.52 v5(34.96,57.4)
  BOTTOM w0.076: v6(35.42,57.52) 35.48,57.46 UH4.AE45
N153236284: length 3.8
  BOTTOM w0.127: v1(41.69,100.48) 41.31,100.86 39.72,100.86 39.43,101.15 PR189.1
  BOTTOM w0.203: PR189.1 39.07,100.88 PQ132.2
N153237165: length 3.2
  BOTTOM w0.127: v1(38.45,101.11) 38.13,101.11 37.88,100.86 36.93,100.86 36.64,101.15 PR188.1
  BOTTOM w0.203: PR188.1 36.51,101.11 PQ133.2
N153246077: length 2.1
  TOP w0.127: v1(16.51,71.28) 16.71,71.08 PR120.2
  TOP w0.203: PR120.2 17.42,71.98 PQ134.2
N153246648: length 1.1
  TOP w0.203: PR249.1 31.34,72.79 PQ199.2
N153246695: length 0.9
  TOP w0.203: PR256.1 38.85,105.8 PQ213.2
N153247080: length 2.5
  TOP w0.127: PR258.2 41.65,95.43 v1(41.88,95.21)
  TOP w0.254: PQ137.2 41.51,96.67 PR258.2
N153247431: length 7.3
  TOP w0.203: PR102.2 18.59,78.29 19,78.7 19.86,78.7 20.29,78.26 21.54,78.26 22.18,77.62 22.18,75.28 22.21,75.25 PQ143.1
N153248104: length 2.9
  TOP w0.203: v1(18.64,96.03) 19.44,95.23 PQ144.1 20.11,95.23 20.52,95.63 PR129.2
N153256887: length 2.3
  GND2 w0.102: v5(43.33,12.66) 43.4,12.59 v7(43.95,12.59)
  GND3 w0.102: v6(42.67,12.58) 42.67,12.58 43.25,12.58 v5(43.33,12.66)
  BOTTOM w0.127: v6(42.67,12.58) 42.67,13.25 v1(42.86,13.44)
N153257573: length 2.2
  TOP w0.127: v7(44.36,9.33) 44.69,9.33 UE3.L6
  IN1 w0.064: v7(44.36,9.33) 44.22,9.33 43.88,9.66 v4(43.88,9.77)
  GND2 w0.102: v4(43.88,9.77) 43.88,10.08 v5(44.03,10.22)
  GND3 w0.102: v5(44.03,10.22) 44.25,10.45 v6(44.25,10.68)
N153586557: length 9.8
  IN3 w0.064: v3(4.34,10.96) 4.34,14.34 5.98,15.98 5.98,19.36 6.11,19.48 v3(6.11,20.01)
N153659070: length 1.5
  BOTTOM w0.127: v1(7.34,8.22) 7.17,8.38 R5859.2
N153659804: length 4.8
  BOTTOM w0.127: R5858.2 5.76,12.67 v1(5.53,12.9) 4.2,12.9 R5860.2 3.04,11.75 Q6.2
N153786804: length 3.5
  TOP w0.127: T831.1 38.54,9.38 39.25,9.38 39.73,8.89 40.53,8.89 40.62,8.98 41.09,8.98 41.5,9.39 UE3.L2
N153786824: length 2.7
  TOP w0.127: UE3.M1 39.71,8.59 39.33,8.97 38.91,8.97 38.55,8.62 T832.1
N153786852: length 1.7
  GND2 w0.102: v7(47.95,10.99) 48.25,10.99 v5(48.33,10.92)
  GND3 w0.102: v6(49,10.87) 48.98,10.89 48.35,10.89 v5(48.33,10.92)
  BOTTOM w0.127: v6(49,10.87) 48.69,10.56 T833.1
N153948494: length 10.4
  TOP w0.127: v9(77.77,3.51) 78.26,4 78.26,5.47 78.83,6.03 JAPS1.11 78.83,8.86 v1(78.01,9.67)
  BOTTOM w0.127: v9(77.77,3.51) 77.77,3.36 76.49,2.08 R5862.2 R5863.2
N154167476: length 1.8
  TOP w0.254: PR2313.1 67.95,52.71 PR2311.2 67.18,53.48 PR2316.1
N154167480: length 2.4
  TOP w0.254: PU4255.9 66.86,50.48 65.9,51.44 PR2320.2 PR2321.2
N154167794: length 1.7
  TOP w0.254: PR2319.2 66.91,52.83 PR2312.1 66.32,53.49 PR2315.1
N154167819: length 3.7
  BOTTOM w0.127: v1(66.28,53.56) 64.92,53.56 64.69,53.33 PC3266.1
  BOTTOM w0.508: PC3266.1 64.69,52.2 PR2308.2
N154167903: length 1.8
  TOP w0.254: PC3287.1 66.48,51.36 67.36,50.49 PU4255.8
N154224423: length 2.4
  BOTTOM w0.254: PR2331.1 v1(149.84,92.93) 149.24,92.32 PU2304.9
N154411599: length 1.1
  TOP w0.127: v1(119.94,18.8) 119.94,19.11 119.78,19.28 RV810.1
N154411647: length 1.8
  TOP w0.127: v1(121.01,18.04) 121.59,18.63 QV13.1
N154419141: length 2
  TOP w0.127: QV13.2 122.94,18.6 122.7,18.35 R5864.2 122.7,17.61 v1(122.41,17.32)
N154450732: length 1
  TOP w0.127: R5867.2 v1(142.95,82.89)
N154827175: length 12.6
  TOP w0.076: UE3.D9 v7(47.64,15.48)
  GND2 w0.102: v5(47.55,16.06) 47.55,15.89 47.64,15.79 v7(47.64,15.48)
  GND3 w0.102: v5(47.55,16.06) 48.12,16.63 v8(48.3,16.63)
  IN3 w0.064: v3(54.11,10.63) 51.85,10.63 50.4,12.07 50.4,15.5 49.66,16.24 48.7,16.24 v8(48.3,16.63)
N155024407: length 2.1
  TOP w0.127: PU78.1 PR2340.2 43.21,46.16 v1(43.35,46.3)
N155489719: length 3.9
  BOTTOM w0.127: JIO1.R13 101.56,5.4 101.56,3.19 101.88,2.88 R5869.1
N155489761: length 3.9
  BOTTOM w0.127: R5870.1 103.04,2.91 102.56,3.4 102.56,5.21 103.06,5.71 JIO1.R12
N1557527231: length 1.6
  TOP w0.254: PU102.2 44.99,106.32 44.63,106.68 44.62,106.68 44.28,107.02 PR267.2
N1557528950: length 2.4
  TOP w0.127: PU2302.2 39.13,99.32 39.33,99.12 39.33,98.05 PR271.2
N1557533360: length 1.3
  TOP w0.254: PU2301.2 41.33,101.99 PR269.2
N1557544241: length 1.3
  TOP w0.254: PR273.2 43.94,103.64 PU2303.2

## Copper pours and planes (outline as drawn)
1.2V_DDRP_LX on BOTTOM (solid shape): 80.61,101.64 82.03,100.67 83.28,100.67 84.8,99.52 84.86,99.36 84.53,98.87 84.37,98.81 84.11,99.02 84,99.12 82.82,99 81.06,97.24 79.66,97.24 79.54,97.11 79.54,94.57 79.41,94.44 79.35,94.44 79.25,94.54 79.25,95.28 79.07,95.46 78.65,95.46 78.58,95.52 78.58,96.54 78.2,96.92 77.19,96.92 77.19,97.75 76.74,98.19 76.74,98.3 77.23,99 79.6,101.36 79.6,101.36 79.89,101.65 80.6,101.65
1.2V_DDRP_VIN on BOTTOM (solid shape): 80.3,94.95 80.3,93.24 80.87,92.67 80.87,92.22 81,92.09 81.57,92.09 81.7,91.97 81.7,90.38 81.63,90.32 80.55,90.32 80.49,90.38 80.49,91.14 80.36,91.27 79.73,91.27 79.6,91.4 79.6,92.28 79.73,92.41 79.73,95.08 79.79,95.14 80.11,95.14
1.05V_VMMP_ALW_VIN on TOP (solid shape): 18.64,22.31 18.96,21.99 20.99,21.99 20.99,18.75 20.85,18.61 19.95,18.61 19.81,18.75 19.81,20.86 19.53,21.14 18.59,21.14 18.39,21.34 18.39,22.43 18.64,22.43
1.8VALW_VIN on BOTTOM (solid shape): 69.25,79.92 69.47,79.67 69.79,79.72 71.03,79.72 71.03,79.72 71.27,79.72 71.38,79.61 71.38,77.64 70.96,77.22 68.88,77.22 68.88,78.11 69.06,78.29 69.06,79.36 68.73,79.69 68.41,79.69 68.34,79.75 68.34,79.9 68.41,79.97 69.25,79.97
1.8VALWP_LX on BOTTOM (solid shape): 67.08,77.83 67.08,75.82 67.13,75.77 68.42,75.77 68.42,74.31 68.16,74.05 66.34,74.05 66.11,74.27 66.11,77.78 66.2,77.87 67.04,77.87
1.8VALWP_LX on BOTTOM (solid shape): 68.22,80.27 68.22,79.63 68.27,79.58 68.45,79.58 68.58,79.46 68.7,79.46 68.88,79.28 68.88,78.39 68.7,78.21 68.15,78.21 67.83,78.53 67.83,80.29 67.89,80.35 68.14,80.35
1.8VALWP_LX on IN3 (solid shape): outline of 85 points within 66.27,74.38 68.93,79.58
3VALW_LX on BOTTOM (solid shape): 12.9,27.49 12.9,26.9 13.56,26.24 14.07,26.24 14.45,25.86 14.45,25.1 14.32,24.97 13.94,24.97 13.46,25.46 11.07,25.46 10.26,24.64 10.26,22.94 10.13,22.94 10,23.07 10,23.45 9.88,23.58 9.62,23.58 9.5,23.7 9.5,24.09 8.28,25.3 8.28,27.67 8.48,27.87 12.52,27.87
3VALW_VIN on TOP (solid shape): 11.4,21.55 11.91,21.55 12.16,21.29 12.16,19.13 11.91,18.88 10.39,18.88 10.26,19.01 10.26,20.15 10.51,20.4 10.51,21.42 10.89,21.8 11.15,21.8
3VALW_VIN on BOTTOM (solid shape): 10.89,23.32 10.89,22.18 11.15,21.93 11.66,21.93 11.91,21.67 11.91,17.95 11.35,17.4 9.93,17.4 9.89,17.44 9.89,17.65 9.89,17.66 9.9,17.76 9.89,17.86 9.89,17.87 9.89,19.65 10.51,20.28 10.51,23.32 10.64,23.45 10.77,23.45
3VD_LX on TOP (solid shape): 71.21,107.09 71.21,102.81 70.71,102.32 64.49,102.32 64.23,102.57 64.23,102.76 64.11,102.89 63.79,102.89 63.66,103.02 63.66,103.33 65.5,103.33 66.96,104.79 67.09,104.79 67.41,105.11 67.41,106 67.66,106.25 67.98,106.25 68.36,106.64 68.36,107.33 68.47,107.44 70.85,107.44
3VD_LX on BOTTOM (solid shape): 71.54,107.14 71.54,103.02 71.28,102.76 68.93,102.76 68.81,102.89 68.81,107.33 68.93,107.46 71.22,107.46
3VD_VIN on TOP (solid shape): 62.46,105.11 62.84,105.11 62.9,105.05 62.9,104.22 63.09,104.03 63.98,104.03 64.17,103.84 64.17,103.52 64.11,103.46 58.56,103.46 58.34,103.67 58.34,104.11 58.48,104.24 59.3,104.24 59.41,104.35 59.66,104.35 60.3,104.98 60.3,105.93 60.42,106.05 61.52,106.05
3VD_VIN on BOTTOM (solid shape): 62.84,104.79 62.84,104.01 62.33,103.5 59.3,103.5 59.15,103.65 59.15,104.22 59.28,104.35 59.66,104.35 60.42,105.11 62.52,105.11
5VALW_LX on BOTTOM (solid shape): 62.33,85.5 62.33,83.33 62.22,83.22 59.38,83.22 58.86,82.7 57.54,82.7 56.84,82 56.84,80.44 56.84,80.24 56.66,80.07 56.46,80.07 56.36,80.17 56.36,80.65 56.25,80.76 55.99,80.76 54.61,82.14 54.61,83.55 55.3,84.24 55.3,84.83 56.33,85.86 61.97,85.86
5VALW_VIN on BOTTOM (solid shape): 57.55,80.3 57.55,79.25 57.65,79.15 58.24,79.15 59.28,78.11 59.28,77.43 59.38,77.32 60.06,77.32 60.41,76.98 60.41,75.66 60.27,75.51 57.25,75.51 56.61,74.87 56.07,74.87 55.95,74.99 55.95,77.2 56.44,77.68 56.44,78.16 56.94,78.67 56.94,80.4 57.1,80.55 57.3,80.55
5VD_LX on TOP (solid shape): 125.88,23.36 125.88,22.28 125.85,22.26 123.94,22.26 123.82,22.37 123.82,23.39 123.92,23.49 125.75,23.49
5VD_LX on BOTTOM (solid shape): 123.12,28.61 123.12,26.15 123.57,25.7 123.57,24.4 123.87,24.1 125.6,24.1 125.65,24.05 125.65,23.78 125.57,23.7 125.26,23.7 125.26,23.7 124.74,23.7 124.42,23.37 124.42,22.59 124.19,22.37 120.68,22.37 120.56,22.5 120.56,28.39 120.87,28.7 123.03,28.7
5VD_VIN on BOTTOM (solid shape): 127.3,25.89 127.3,25.41 127.48,25.23 130.4,25.23 130.75,24.88 130.75,20.77 130.71,20.74 129.71,20.74 129.54,20.9 129.54,23.42 129.38,23.58 127.61,23.58 127.54,23.64 127.54,24.21 127.5,24.26 125.29,24.26 125.23,24.31 125.23,24.72 125.34,24.83 126.34,24.83 126.48,24.98 126.48,25.73 126.77,26.02 127.17,26.02
+0.6V_VREFCA on IN2 (solid shape): outline of 179 points within 130.4,78.06 135.1,79.46
+0.6VS on TOP (solid shape): 92.68,110.64 92.68,110.45 92.81,110.32 92.81,109.82 92.66,109.82 92.66,109.03 92.81,109.03 92.81,102.83 92.43,102.83 92.4,102.85 92.4,103.81 92.36,103.86 92.36,104.48 92.3,104.54 91.79,104.54 91.35,104.1 89.89,104.1 89.63,104.35 89.63,105.62 92.32,105.62 92.32,106.21 91.76,106.21 91.76,105.62 89.63,105.62 89.63,108.32 92.32,108.32 92.32,108.9 91.76,108.9 91.76,108.32 89.63,108.32 89.63,108.91 91.42,108.91 91.42,109.62 90.64,109.62 90.64,108.91 89.63,108.91 89.63,110.57 89.95,110.89 92.43,110.89
+0.6VS on TOP (solid shape): 143.98,110.65 143.98,102.37 143.93,102.32 141.58,102.32 141.46,102.2 141.09,102.2 141.09,101.83 140.94,101.68 140.94,101.62 140.7,101.38 140.35,101.38 140.31,101.43 140.31,101.81 140.43,101.94 140.81,101.94 140.84,101.96 140.87,101.96 140.87,101.99 140.94,102.06 140.94,103.14 140.88,103.21 140.43,103.21 140.37,103.27 140.37,103.65 140.43,103.71 140.81,103.71 141.07,103.46 141.07,103.27 141.13,103.21 141.7,103.21 141.74,103.24 142.85,103.24 142.85,106.59 142.27,106.59 142.27,103.24 141.74,103.24 141.77,103.27 141.77,107.21 141.64,107.33 140.54,107.33 140.45,107.42 140.45,107.99 143.7,107.99 143.7,108.58 143.14,108.58 143.14,107.99 140.45,107.99 140.45,108.32 140.74,108.6 141.36,108.6 141.45,108.51 142.81,108.51 142.83,108.53 142.83,108.84 143.06,109.07 143.14,109.07 143.23,109.17 143.23,110.64 143.35,110.76 143.87,110.76
+0.6VS on BOTTOM (solid shape): 74.33,93.68 74.33,91.97 74.27,91.9 73.76,91.9 73.57,92.09 73.57,93.63 73.71,93.78 74.23,93.78
+0.6VS on BOTTOM (solid shape): 92.81,110.19 92.81,103.46 92.68,103.33 92.43,103.33 91.67,104.1 89.83,104.1 89.76,104.17 89.73,104.2 89.73,104.31 89.74,104.31 89.74,104.82 89.73,104.82 89.73,105.15 89.74,105.15 89.74,105.71 89.73,105.71 89.73,105.94 92.32,105.94 92.32,106.53 91.76,106.53 91.76,105.94 89.73,105.94 89.73,108.28 92.32,108.28 92.32,108.87 91.76,108.87 91.76,108.28 89.73,108.28 89.73,108.91 91.42,108.91 91.42,109.62 90.64,109.62 90.64,108.91 89.73,108.91 89.73,110.29 90.01,110.57 92.43,110.57
+0.6VS on BOTTOM (solid shape): 145.23,110.78 145.38,110.63 145.38,108.74 144.42,107.78 144.06,107.78 143.65,107.37 143.65,107.18 143.64,107.17 143.61,107.05 143.64,106.93 143.65,106.92 143.65,106.68 143.64,106.67 143.61,106.55 143.64,106.43 143.65,106.42 143.65,106.18 143.63,106.14 143.62,106.09 143.53,106 142.58,106 142.51,106.06 142.51,107.02 142.58,107.08 142.96,107.08 143.04,107.16 143.04,108.03 142.89,108.18 142.89,109.78 142.85,109.82 142.06,109.82 141.98,109.9 141.98,110.76 142,110.78 143.99,110.78
+0.6VS on IN1 (solid shape): outline of 404 points within 89.51,108.54 148.05,111.33
+0.6VS on IN3 (solid shape): 74.52,94.95 74.52,92.72 74.41,92.61 73.62,92.61 73.5,92.73 73.5,94.95 73.76,95.21 74.27,95.21
+0.6VS on IN3 (solid shape): 92.3,110.19 92.3,109.81 92.01,109.52 91.95,109.52 91.69,109.47 91.48,109.33 91.3,109.15 91.19,109.01 91.13,108.83 91.12,108.79 89.63,108.79 88.49,109.94 88.49,110.45 88.74,110.7 91.79,110.7
+0.6VSP on BOTTOM (solid shape): 78.27,96.48 78.27,95.9 78.14,95.78 76.93,95.78 76.74,95.59 76.23,95.59 76.17,95.65 76.17,96.4 76.22,96.45 76.88,96.45 76.97,96.54 78.2,96.54
+0.6VSP on BOTTOM (solid shape): 78.33,94.63 78.33,94.44 78.2,94.32 77.38,94.32 77.33,94.27 77.25,94.27 76.66,93.68 76.04,93.68 75.98,93.62 75.98,92.28 75.54,91.84 74.58,91.84 74.52,91.9 74.52,92.22 75.09,92.22 75.09,92.73 74.52,92.73 74.52,93.36 74.77,93.62 75.16,93.62 75.28,93.74 75.28,94.44 75.35,94.51 77.12,94.51 77.31,94.7 78.27,94.7
+0.6VSP on IN3 (solid shape): 78.46,96.67 78.46,96.09 78.01,95.65 77.19,95.65 76.43,94.89 76.43,94.06 75.85,93.49 75.85,93.05 75.73,92.92 75.03,92.92 74.81,93.14 74.81,94.98 74.86,95.04 75.23,95.04 75.23,94.99 75.24,94.95 75.25,94.91 75.28,94.88 75.31,94.84 75.34,94.82 75.38,94.8 75.42,94.79 75.46,94.78 75.5,94.79 75.54,94.8 75.58,94.82 75.61,94.84 75.64,94.88 75.67,94.91 75.68,94.95 75.69,94.99 75.69,95.04 75.68,95.08 75.67,95.12 75.64,95.15 75.61,95.18 75.58,95.21 75.54,95.23 75.5,95.24 75.46,95.24 75.42,95.24 75.38,95.23 75.34,95.21 75.31,95.18 75.28,95.15 75.25,95.12 75.24,95.08 75.23,95.04 74.86,95.04 76.41,96.59 76.46,96.58 76.5,96.58 76.54,96.58 76.58,96.6 76.62,96.62 76.65,96.64 76.68,96.68 76.7,96.71 76.71,96.75 76.72,96.79 76.72,96.83 76.71,96.88 76.74,96.92 78.2,96.92
+0.95VSP on TOP (solid shape): 102.84,44.72 102.84,39.07 102.71,38.94 100.09,38.94 99.86,39.17 99.86,43.77 99.73,43.9 99.03,43.9 98.9,44.02 98.9,44.79 99.29,45.17 102.4,45.17
+0.95VSP on BOTTOM (solid shape): 104.19,44.65 104.19,41.05 103.54,40.4 99.97,40.4 99.84,40.53 99.84,44.71 100.11,44.98 103.86,44.98
+0.95VSP on IN3 (solid shape): 102.84,44.91 102.84,42.12 102.59,41.87 100.05,41.87 99.79,42.12 99.79,44.53 100.3,45.04 102.71,45.04
+1.2V_DDR on TOP (solid shape): outline of 104 points within 95.09,78.44 121.76,84.03
+1.2V_DDR on TOP (solid shape): 129.89,105.38 130.02,105.38 130.02,104.59 129.62,104.59 128.94,103.91 128.94,102.72 128.73,102.51 127.9,102.51 127.8,102.57 127.83,102.68 128.39,103.24 128.39,103.25 128.55,103.51 128.35,103.75 128.32,103.77 127.97,104.12 127.83,104.12 127.76,104.16 127.74,104.24 127.68,104.47 127.46,104.57 127.44,104.56 127.3,104.7 127.3,104.75 127.29,104.78 127.3,104.84 127.35,104.85 127.64,104.88 127.74,105.15 127.76,105.22 127.83,105.26 127.92,105.26 127.99,105.22 128.01,105.15 128,105.11 128,105.08 128.01,105.04 128.05,104.94 128.1,104.88 128.16,104.84 128.18,104.83 128.27,104.82 128.37,104.83 128.39,104.84 128.47,104.9 128.52,104.98 128.53,104.98 129.02,105.48 129.89,105.48
+1.2V_DDR on TOP (solid shape): 102.08,105.23 102.11,105.14 102.13,104.97 102.26,104.84 102.28,104.83 102.38,104.82 102.47,104.83 102.49,104.84 102.57,104.9 102.62,104.98 102.63,104.98 102.88,105.24 103.91,105.24 104,105.16 104,103.85 103.55,103.4 103.55,102.72 103.32,102.48 101.14,102.48 101.05,102.52 101.04,102.61 101.05,102.7 101.34,102.7 101.59,102.95 101.78,102.95 102.06,102.86 102.2,103.11 102.23,103.2 102.32,103.22 102.64,103.43 102.45,103.76 102.43,103.76 102.07,104.12 101.93,104.12 101.86,104.16 101.84,104.24 101.78,104.47 101.56,104.57 101.54,104.56 101.41,104.69 101.43,104.79 101.53,104.82 101.77,104.9 101.85,105.14 101.87,105.23 101.95,105.26 102,105.26
+1.2V_DDR on TOP (solid shape): 138.3,105.26 138.38,105.23 138.4,105.14 138.59,104.83 138.92,104.98 138.92,104.98 139.18,105.24 140.05,105.24 140.05,101.57 139.09,102.53 137.44,102.53 137.36,102.57 137.34,102.65 137.35,102.7 137.63,102.7 137.89,102.95 138.09,102.95 138.36,102.88 138.5,103.12 138.53,103.2 138.62,103.22 138.86,103.69 138.4,103.44 138.38,103.35 138.3,103.32 138.24,103.32 138.16,103.35 138.14,103.44 138.06,103.69 137.82,103.76 137.73,103.79 137.7,103.87 137.7,103.91 137.73,104 137.82,104.02 137.87,104.02 137.92,104.02 138.14,104.27 137.96,104.55 137.91,104.56 137.85,104.57 137.83,104.56 137.7,104.69 137.72,104.79 137.82,104.82 138.06,104.9 138.14,105.14 138.16,105.23 138.24,105.26
+1.2V_DDR on TOP (solid shape): outline of 7511 points within 90.46,92.73 141.83,110.97
+1.2V_DDR on BOTTOM (solid shape): 92.38,103.23 92.4,103.23 92.84,102.79 93.16,102.79 93.44,102.51 93.44,101.56 93.57,101.43 94.59,101.43 94.71,101.3 94.71,99.02 94.33,98.63 90.65,98.63 90.4,98.89 90.4,99.42 90.95,99.42 90.95,101.43 90.4,101.43 90.4,102.34 90.75,102.7 90.76,102.7 91.29,103.23 91.39,103.23 91.49,103.33 91.49,103.61 91.6,103.72 91.89,103.72
+1.2V_DDR on GND2 (solid shape): 96.87,79.71 97,79.71 97.06,79.65 97.38,79.65 97.44,79.71 97.76,79.71 97.82,79.65 97.82,79.27 97.44,78.89 96.55,78.89 96.49,78.95 96.49,79.71 96.55,79.77 96.81,79.77
+1.2V_DDR on IN3 (solid shape): outline of 6379 points within 89.66,77.93 122.53,103.74
+1.2V_DDR on VCC: 96.47,93.43 92.43,97.47 92.43,99.88 91.28,101.03 91.28,110.59 91.64,110.95 140.96,110.95 141.45,110.47 141.45,93.79 141.09,93.43
+1.2V_DDR on VCC: 91.15,77.81 91.06,77.84 90.97,77.85 90.52,78.29 90.52,87.61 91.01,88.09 121.26,88.09 121.26,79.46 105.34,79.46 103.69,77.81
+1.2V_DDR on GND3: 91.28,101.37 91.14,101.22 91.14,94.83 89.63,93.33 89.63,90.03 90.8,88.86 92.71,88.86 93.15,89.3 93.15,101.27 93.05,101.37
+1.2V_DDRP on BOTTOM (solid shape): 85.55,104.86 85.59,104.86 85.64,104.86 86.09,104.86 86.14,104.81 86.14,103.46 86.39,103.21 89.38,103.21 90.22,102.37 90.22,98.89 90.17,98.84 89.13,98.84 88.15,99.81 86.22,99.81 84.92,100.65 83.66,101.36 82.43,101.36 81.57,102.01 81.57,104.35 82.08,104.86
+1.2V_DDRP on IN3 (solid shape): 89.24,101.37 89.24,100.61 89.04,100.41 87.43,100.41 86.93,100.9 86.93,101.35 87.15,101.56 89.05,101.56
+1.2V_DDRP on IN3 (solid shape): 77.76,94.82 77.76,94.13 77.63,94 76.87,94 76.74,94.13 76.74,94.95 77.06,95.27 77.31,95.27
+1.2V_VCCPLL_OC on TOP (solid shape): 130.06,79.26 130.06,78.5 129.71,78.15 128.5,78.15 128.45,78.2 128.45,78.34 128.59,78.48 128.59,79.42 128.61,79.44 129.88,79.44
+1.8VALW on TOP (solid shape): 66.65,86.32 66.65,85.55 66.14,85.05 64.86,85.05 64.61,85.29 64.61,86.19 64.87,86.44 66.52,86.44
+1.8VALW on TOP (solid shape): 66.14,79.71 66.14,79.05 65.58,78.49 65.27,78.49 65.25,78.52 65.25,79.03 65.22,79.05 64.72,79.05 64.69,79.03 64.69,78.52 64.66,78.49 64.46,78.49 64.44,78.52 64.44,79.03 64.41,79.05 63.9,79.05 63.88,79.03 63.88,78.52 63.85,78.49 63.6,78.49 63.34,78.75 63.34,79.71 63.53,79.9 65.94,79.9
+1.8VALW on IN2 (solid shape): 66.27,80.35 66.27,79.2 66.01,78.95 63.85,78.95 63.6,79.2 63.6,80.35 63.85,80.6 66.01,80.6
+1.8VALW on VCC: 63.7,78.95 63.22,79.44 63.22,87.23 63.58,87.59 65.91,87.59 66.01,87.48 66.01,79.44 65.52,78.95
+1.8VALWP on TOP (solid shape): 64.28,78.36 64.31,78.34 64.84,78.34 64.84,78.9 65.1,78.9 65.1,78.36 65.96,78.36 66.01,78.31 67.92,78.31 68.17,78.06 68.17,75.27 67.66,74.76 63.85,74.76 63.32,75.29 63.32,78.11 63.55,78.34 64.03,78.34 64.03,78.9 64.28,78.9
+1.8VALWP on BOTTOM (solid shape): 64.74,79.2 64.74,79 64.72,78.97 64.72,77.45 65.63,76.54 65.63,75.01 65.38,74.76 63.7,74.76 63.45,75.01 63.45,78.44 63.46,78.45 63.46,78.81 64.11,79.46 64.49,79.46
+1V_MPHY on TOP (solid shape): 40.33,48.24 40.34,48.18 40.3,48.15 40.29,48.15 40.29,47.26 40.36,47.26 40.36,45.1 40.99,44.47 40.99,43.9 40.74,43.64 38.45,43.64 37.69,44.41 37.69,48.34 38.07,48.72 39.85,48.72
+1V_MPHY on BOTTOM (solid shape): 39.34,48.85 39.34,48.47 39.6,48.22 39.98,48.22 40.23,47.96 40.23,45.55 39.98,45.29 39.6,45.29 39.47,45.42 39.47,47.07 38.58,47.96 38.58,48.85 38.71,48.98 39.21,48.98
+1V_MPHY on GND1 (solid shape): 40.24,47.7 40.24,45.54 39.96,45.26 39.55,45.26 39.47,45.34 39.47,47.67 39.59,47.79 40.15,47.79
+1V_MPHY on IN1 (solid shape): 40.53,47.76 40.53,46.24 40.25,45.96 40.25,45.4 40.1,45.24 39.48,45.24 39.38,45.35 39.38,47.72 39.56,47.9 40.4,47.9
+1V_MPHY on GND2 (solid shape): 40.23,47.82 40.23,47.48 40.06,47.31 40.06,46.14 39.98,45.93 40.06,45.71 40.06,45.5 39.89,45.33 39.68,45.33 39.63,45.34 39.26,45.72 39.26,46.31 39.26,46.36 39.26,46.4 39.26,47.09 39.26,47.13 39.26,47.18 39.26,48.34 39.35,48.43 39.61,48.43
+1V_MPHY on IN2 (solid shape): 39.97,48.32 39.97,45.62 39.89,45.55 39.28,45.55 39.12,45.7 39.12,48.4 39.23,48.5 39.78,48.5
+1V_MPHY on GND4 (solid shape): 40.01,47.99 40.01,45.51 39.94,45.44 39.51,45.44 39.36,45.59 39.36,48.03 39.43,48.1 39.89,48.1
+1V_MPHY on VCC: 39.31,45.63 39.77,45.63 39.85,45.72 39.85,48.28 39.7,48.43 39.32,48.43 39.2,48.3 39.2,45.75
+1V_MPHY on GND3: 39.67,48.43 39.34,48.43 39.26,48.35 39.26,45.71 39.51,45.45 39.86,45.45 40,45.59 40,48.1
+1V_MPHY_MPHYPLL on BOTTOM (solid shape): outline of 120 points within 46.27,55.88 51.66,60.76
+1V_PCH on IN2 (solid shape): outline of 1065 points within 30.32,40.21 42.01,46.69
+1V_PCH_CLK5 on TOP (solid shape): 43.28,36.4 43.28,35.13 43.15,35.01 42.68,35.01 42.24,34.56 40.29,34.56 40.1,34.75 40.1,36.28 40.36,36.53 43.15,36.53
+1V_PCH_PRIM on TOP (solid shape): 37.06,48.58 37.06,42.88 36.74,42.56 34.31,42.56 34.3,42.58 34.3,43.69 34.13,43.86 34.13,48.46 34.39,48.72 36.92,48.72
+1V_PCH_PRIM on GND1 (solid shape): 35.73,43.8 35.73,43.24 35.32,42.84 34.75,42.84 34.67,42.92 34.67,43.73 34.82,43.87 35.65,43.87
+1V_PCH_PRIM on GND2 (solid shape): 35.73,43.81 35.73,43.17 35.43,42.87 34.74,42.87 34.64,42.97 34.64,43.73 34.82,43.91 35.63,43.91
+1V_PCH_PRIM on BOTTOM: 34.05,44.47 33.37,44.47 33.24,44.61 33.24,48.92 33.55,49.23 37.76,49.23 38.07,48.92 38.07,47.87 38.56,47.37 38.56,46.06 38.31,45.8 34.28,45.8 34.1,45.62 34.1,44.52
+1V_PCH_PRIM on IN1: 34.72,42.85 35.49,42.85 35.72,43.07 35.72,45.47 37.21,46.97 37.21,47.77 37.06,47.92 35.53,47.92 34.62,47.02 34.62,42.95
+1V_PCH_PRIM on GND2: 36.33,49.15 37.47,49.15 37.58,49.04 37.58,48.26 38.33,47.51 38.33,46.5 38.18,46.35 35.49,46.35 35.35,46.49 35.35,48.31 35.55,48.51 36.16,48.51 36.17,48.52 36.17,48.87 36.15,48.88 36.15,48.98
+1V_PCH_PRIM on IN2: 38.15,49.14 34.31,49.14 33.14,47.97 33.14,44.4 34.66,42.89 35.3,42.89 35.49,43.08 35.49,45.83 35.76,46.1 38.37,46.1 38.47,46.2 38.47,48.81
+1V_PCH_PRIM on VCC: 31.57,42.18 30.07,43.68 30.07,52.28 31.25,52.28 31.89,52.91 40.38,52.91 41.88,51.41 41.88,42.92 41.14,42.18
+1V_PCH_PRIM on IN3: 34.1,44.49 33.38,44.49 33.21,44.66 33.21,48.98 33.48,49.25 38.47,49.25 38.78,48.94 38.78,46.06 38.48,45.77 37.56,45.77 37.55,45.78 34.53,45.78 34.21,45.45 34.21,44.59
+1V_PCH_USBPLL on TOP (solid shape): 34.58,38.75 34.58,37.86 34.72,37.86 34.72,36.85 34.57,36.71 32.33,36.71 32.03,37.01 32.03,38.08 32.91,38.97 34.36,38.97
+1VALW on TOP (solid shape): 111.52,26.8 111.52,26.5 111.64,26.37 113.98,26.37 114.05,26.31 114.05,24.73 114.01,24.69 112.86,24.69 112.73,24.56 112.73,23.93 112.68,23.89 111.36,23.89 111.27,23.97 111.27,24.89 110.87,25.3 110.18,25.3 110.12,25.36 110.12,25.85 111.18,26.91 111.41,26.91
+1VALW on TOP (solid shape): outline of 265 points within 14.39,31.71 42.52,44.48
+1VALW on BOTTOM (solid shape): 81.78,25.86 81.77,25.85 81.77,25.39 81.61,25.23 79.42,25.23 78.89,25.76 78.02,25.76 77.95,25.84 77.95,26.73 78.05,26.83 79.85,26.83 80.11,27.08 80.11,28.93 81.78,28.93
+1VALW on BOTTOM (solid shape): 16.04,37.1 16.04,33.99 15.78,33.74 14,33.74 13.81,33.93 13.81,34.5 13.85,34.5 13.88,34.56 14.3,34.56 14.3,35.22 13.81,35.22 13.81,35.76 14.3,35.76 14.3,36.42 13.81,36.42 13.81,37.1 14.13,37.42 15.72,37.42
+1VALW on GND1: 14.63,37.03 14.63,32.68 14.96,32.35 22.97,32.35 24.11,31.22 35.63,31.22 38.26,33.85 38.26,38.13 37.69,38.7 34.3,38.7 33.71,38.11 33.71,35.81 33.36,35.46 28.31,35.46 26.12,37.65 15.24,37.65
+1VALW on VCC: 79.96,25.23 79.2,25.99 25.48,25.99 17.6,33.86 15.19,33.86 15.19,33.86 15,33.86 14.58,34.29 14.58,36.93 14.81,37.17 17.14,37.17 26.15,28.15 57.23,28.15 58.31,29.23 98.25,29.23 100.43,31.41 100.43,37.51 102.5,39.58 108.79,39.58 110.19,40.98 113.23,40.98 115.9,43.64 140.94,43.64 140.94,37.8 104.77,37.8 103.98,37.02 103.98,33.44 105.06,32.36 105.06,26.16 104.89,25.99 83.69,25.99 82.92,25.23
+1VALWP on BOTTOM (solid shape): 13.69,41.53 13.69,37.29 13.66,37.27 13.66,33.72 13.17,33.23 9.84,33.23 9.55,33.52 9.55,37.7 9.56,37.71 9.56,41.5 9.83,41.76 13.46,41.76
+2.5V_MEM on TOP (solid shape): 86.46,104.76 86.46,102.83 86.39,102.76 85.44,102.76 85.32,102.89 85.32,104.74 85.39,104.82 86.39,104.82
+2.5V_MEM on BOTTOM (solid shape): 128.37,110.64 128.37,110.15 128.41,110.15 129.66,108.9 130.8,108.9 130.91,108.79 130.91,107.59 130.86,107.54 129.5,107.54 127.16,109.87 118.14,109.87 117.95,109.68 117.95,108.79 118.21,108.54 118.33,108.54 118.33,108.48 119.03,108.48 119.09,108.42 119.08,108.39 119.09,108.22 119.2,108.09 119.22,108.08 119.22,107.4 119.1,107.27 118.34,107.27 117.83,107.78 117.32,107.78 116.94,108.16 115.8,108.16 115.54,107.91 115.54,107.14 115.33,106.93 114.74,106.93 112.62,109.05 106.14,109.05 105.38,108.29 105.38,108.17 105.38,108.16 105.36,108.06 105.38,107.96 105.38,107.95 105.38,107.27 105,106.89 104.64,106.89 104.64,106.93 104.09,106.93 104.09,106.91 103.86,107.14 103.86,108.54 103.35,109.05 96.11,109.05 94.84,107.78 94.46,107.78 94.33,107.91 94.33,108.54 95.63,109.83 95.63,110.61 95.72,110.7 96.34,110.7 97.1,109.94 105.25,109.94 105.38,110.06 105.38,110.57 105.51,110.7 112.49,110.7 113.89,109.3 114.63,109.3 114.63,109.26 115.19,109.26 115.19,109.3 116.56,109.3 116.81,109.56 116.81,110.45 117.32,110.95 128.06,110.95
+2.5V_MEM on GND2 (solid shape): 86.56,103.54 86.56,102.48 86.39,102.3 85.7,102.3 85.53,102.48 85.53,103.38 85.78,103.64 86.46,103.64
+2.5V_MEM on IN2 (solid shape): outline of 2084 points within 85.19,93.55 142.34,111.21
+2.5V_MEM on GND3 (solid shape): 86.56,103.7 86.56,102.48 86.4,102.32 85.78,102.32 85.69,102.32 85.53,102.48 85.53,103.6 85.85,103.92 86.34,103.92
+2.5V_MEM on IN3 (solid shape): outline of 96 points within 84.85,103.32 86.92,109.2
+3.3V_EC5105 on BOTTOM (solid shape): outline of 95 points within 37.79,7.65 47.85,16.03
+3.3VDX_SSD on BOTTOM (solid shape): outline of 150 points within 82.65,4.55 92.49,24.21
+3V_LDO on TOP (solid shape): 32.39,4.69 32.39,3.55 31.66,2.81 31.66,1.97 31.54,1.86 29.92,1.86 29.71,2.06 29.71,3.61 29.85,3.75 30.83,3.75 31.07,3.99 31.07,3.99 31.43,4.35 31.43,4.72 31.52,4.81 32.28,4.81
+3V_LDO on TOP (solid shape): 32.17,102.73 32.17,102.5 32.48,102.19 32.48,101.34 32.37,101.23 31.96,101.23 31.85,101.34 31.85,101.77 31.85,101.94 31.72,102.06 31.69,102.06 31.68,102.07 31.57,102.1 31.45,102.07 31.44,102.06 31.23,102.06 31.06,102.23 31.06,102.51 30.81,102.76 29.69,102.76 29.69,103.84 29.98,104.14 30.77,104.14
+3V_LDO on TOP (solid shape): 39.24,101.45 39.24,101.07 39.72,100.59 41.15,100.59 41.16,100.59 41.92,100.59 42.01,100.51 42.01,99.85 41.89,99.74 40.45,99.74 40.44,99.74 40.34,99.75 40.25,99.74 40.24,99.74 39.6,99.74 39.6,99.74 38.73,100.61 38.73,100.63 38.63,100.81 38.45,100.9 38.43,100.91 36.84,100.91 36.73,101.02 36.73,101.63 36.87,101.77 38.93,101.77
+3V_LDO on IN1 (solid shape): outline of 893 points within 26.9,95.18 49.07,107.45
+3V_PCH on TOP (solid shape): 74.38,9.64 74.38,9.15 73.99,8.77 73.99,7.54 73.96,7.51 73.36,7.51 73.36,9.02 73.45,9.1 73.72,9.27 73.72,9.59 73.72,9.66 73.81,9.74 74.27,9.74
+3V_PCH on TOP (solid shape): 23.82,20.24 23.82,18.65 23.69,18.52 22.73,18.52 22.48,18.78 22.48,18.88 22.49,18.91 22.52,18.93 22.84,19.26 22.52,19.59 22.49,19.6 22.48,19.64 22.48,20.17 22.6,20.3 23.76,20.3
+3V_PCH on TOP (solid shape): 31.67,47.05 31.67,45.78 31.36,45.48 31.36,45.01 31.19,44.84 31.19,38.83 31.19,38.04 31.23,38.04 31.42,37.85 31.42,37.34 30.78,36.71 30.77,36.71 30.77,36.7 30.02,35.95 25.19,35.95 24.89,36.25 24.89,37.04 24.98,37.13 29.61,37.13 30.25,37.78 30.25,40.01 30.16,40.1 30.16,40.16 29.03,40.16 29.03,40.14 28.34,40.14 28.27,40.21 28.27,41.61 28.32,41.66 29.05,41.66 29.28,41.89 29.28,43.49 29.13,43.64 27.23,43.64 27.1,43.77 27.1,44.36 27.17,44.49 27.15,44.64 27.13,44.67 27.43,44.96 29.14,44.96 29.35,44.86 29.54,44.99 29.54,44.99 29.66,45.12 29.66,46.97 29.73,47.03 30.52,47.03 30.61,47.12 31.59,47.12
+3V_PCH on TOP (solid shape): outline of 88 points within 21.51,54.82 36.67,60.1
+3V_PCH on BOTTOM (solid shape): 42.89,61.32 42.89,60.61 42.74,60.46 40.03,60.46 39.98,60.51 39.98,61.33 40.12,61.47 42.75,61.47
+3V_PCH on BOTTOM (solid shape): 26.64,36.95 26.64,36.45 26.5,36.3 26.27,36.3 26.09,36.12 25.99,36.12 25.7,36.04 25.71,35.74 25.74,35.67 25.71,35.6 24.12,34.01 24.12,32.74 23.47,32.09 22.32,32.09 22.2,32.21 22.2,33.14 22.37,33.31 22.37,34.27 25.23,37.13 26.47,37.13
+3V_PCH on BOTTOM (solid shape): 28.55,61.98 28.55,61.27 28.61,61.21 28.94,61.21 29.02,61.13 29.02,60.69 28.99,60.66 26.23,60.66 26.19,60.7 26.19,60.93 26.14,60.98 25.51,60.98 25.43,60.91 25.43,60.04 25.43,60.04 25.43,59.47 24.97,59.01 22.96,59.01 22.96,59.45 22.07,59.45 22.07,59.04 21.56,58.53 21.56,58.12 21.43,57.99 20.8,57.99 20.67,58.12 20.67,59.01 21.2,59.54 21.2,59.96 21.31,60.07 21.83,60.07 22.04,60.28 23.17,60.28 23.21,60.32 23.21,60.49 23.27,60.55 24.3,60.55 24.55,60.79 24.55,61.23 25.37,62.06 28.47,62.06
+3V_PCH on IN1 (solid shape): outline of 316 points within 22.2,19.08 30.93,35.38
+3V_PCH on IN2 (solid shape): outline of 150 points within 33.62,58.64 37.69,62.57
+3V_PCH on VCC: 25.1,36.02 24.74,36.38 24.74,44.64 23.59,45.78 23.59,49.84 22.3,51.14 21.58,51.14 19.55,49.1 16.84,49.1 16.48,49.46 16.48,52.05 17.35,52.91 20.19,52.91 20.69,52.41 22.94,52.41 23.59,53.06 23.59,55.35 26.24,57.99 28.82,57.99 29.56,57.25 29.56,43.47 31.21,41.82 31.21,36.89 30.35,36.02
+3V_PCH_DSW on TOP (solid shape): 15.34,32.62 15.34,30.94 15.24,30.84 13.69,30.84 13.56,30.97 13.56,32.52 13.71,32.67 15.29,32.67
+3V_PCH_DSW on BOTTOM (solid shape): 19.14,43.11 19.14,42.6 19.28,42.46 20.91,42.46 20.98,42.39 20.98,41.92 20.93,41.87 20.18,41.87 20.08,41.96 19.31,41.96 19.26,41.92 19.26,41.53 19.22,41.48 19.17,41.48 19.12,41.47 18.9,41.47 18.87,41.48 18.83,41.48 18.57,41.74 18.57,42.39 18.41,42.55 18.41,43.15 18.43,43.17 19.08,43.17
+3V_PCH_DSW on IN1 (solid shape): outline of 417 points within 30.32,40.95 39.09,43.52
+3V_PCH_DSW on IN2 (solid shape): outline of 382 points within 26.64,42.37 30.2,47.58
+3V_PCH_SPI on BOTTOM (solid shape): 25.75,56.47 25.96,56.47 26.06,56.37 26.06,55.91 26.13,55.84 26.13,55.2 26.01,55.07 25.63,55.07 25.37,55.33 25.37,55.58 23.09,57.87 22.07,57.87 21.94,57.99 21.94,58.69 22.07,58.82 22.96,58.82 22.96,58.83 23.39,58.83
+3V_TBT on TOP (solid shape): 29.5,87.9 30.39,87.9 32.17,87.9 32.29,87.78 32.29,87.25 32.35,87.19 32.82,87.19 32.9,87.1 32.9,86.8 33,86.71 33.45,86.71 33.49,86.66 33.49,86.06 33.37,85.93 32.51,85.93 32.29,86.06 32.07,85.93 30.76,85.93 30.5,86.19 29.44,86.19 29.37,86.25 29.37,87.01 29.18,87.2 28.29,87.2 28.23,87.27 28.23,87.84 28.42,88.03 29.37,88.03
+3V_TBT on BOTTOM (solid shape): 31.62,85.93 32.88,85.93 32.97,85.85 32.97,85.58 33.05,85.49 33.31,85.49 33.37,85.43 33.37,85.24 33.31,85.17 32.53,85.17 32.37,85.24 32.21,85.17 32.1,85.17 31.82,84.89 29.85,84.89 29.7,85.05 29.7,86.24 29.78,86.32 31.24,86.32
+3V_TBT on IN1 (solid shape): outline of 130 points within 30.71,82.14 36.32,87.64
+3V_TBT_S0 on TOP (solid shape): 30.48,85.49 30.48,83.74 30.37,83.64 29.64,83.64 29.61,83.66 29.61,84.65 29.41,84.85 28.17,84.85 28.17,85.49 28.22,85.54 30.43,85.54
+3V_TBT_S0 on IN1 (solid shape): outline of 357 points within 36.67,80.09 39.41,84.92
+3V_VCCPGPPBCDEFGH on BOTTOM (solid shape): 26.23,60.49 26.23,59.99 26.24,59.99 26.24,59.23 27.92,57.56 27.92,57.11 27.81,57 27.41,57 27.17,56.76 27.17,56.46 27.1,56.39 26.77,56.39 26.64,56.51 26.64,57.02 26.59,57.07 26.59,57.38 25.53,58.45 25.53,60.08 25.53,60.09 25.53,60.59 25.54,60.6 26.12,60.6
+3V_VCCPGPPBCDEFGH on IN2 (solid shape): outline of 146 points within 32.1,54.95 36.55,57.04
+3V_VCCPGPPBCDEFGH on GND3 (solid shape): 26.75,55.66 26.78,55.63 26.81,55.6 27.09,55.33 27.09,55.14 26.58,54.63 26.32,54.63 26.07,54.88 26.07,55.39 26.51,55.84 26.58,55.84
+3V_VCCPGPPBCDEFGH on IN3 (solid shape): outline of 148 points within 25.56,54.65 27.91,57.54
+3VA_TBT on BOTTOM (solid shape): 53.82,102.66 53.82,102.04 53.34,101.56 50.14,101.56 50.01,101.68 50.01,102.06 50.14,102.19 52.04,102.19 52.68,102.83 53.65,102.83
+3VA_TBT on BOTTOM (solid shape): 29.38,86.54 29.38,85.05 29.23,84.89 28.14,84.89 27.23,85.81 27.23,86.61 27.25,86.63 29.3,86.63
+3VA_TBT on BOTTOM (solid shape): outline of 102 points within 35.09,89.57 41.55,91.91
+3VA_TBT on IN3 (solid shape): 29.82,85.68 30.71,85.68 30.86,85.84 30.89,85.83 31.12,85.89 31.18,86.12 31.17,86.14 31.21,86.19 32.16,86.19 32.31,86.14 32.45,86.19 33.12,86.19 33.96,85.35 33.96,85.34 34.01,85.26 34.09,85.21 34.1,85.21 35.4,83.9 35.4,83.01 35.28,82.89 33.75,82.89 33.53,83.11 33.53,84.16 33.5,84.2 33.5,84.36 33.51,84.39 33.55,84.41 33.77,84.65 33.53,84.87 33.5,84.88 33.48,84.91 33.25,85.12 33.02,84.91 32.96,84.82 32.85,84.84 32.56,85.13 32.56,85.14 32.39,85.23 32.21,85.17 28.29,85.17 27.4,86.06 27.4,86.32 27.62,86.53 28.97,86.53
+3VA_TBT_LC on TOP (solid shape): 40,84.6 40,83.69 39.95,83.64 38.99,83.64 38.99,84.02 39.01,84.04 39.47,84.04 39.57,84.14 39.57,84.6 39.6,84.63 39.98,84.63
+3VALW on TOP (solid shape): 49.95,24.34 49.95,23.77 48.93,22.75 48.93,22.62 48.87,22.56 48.49,22.56 48.42,22.62 48.42,23.32 49.5,24.4 49.88,24.4
+3VALW on TOP (solid shape): 16.58,28.81 16.58,26.6 16.34,26.36 13.47,26.36 13.31,26.52 13.31,28.28 13.7,28.67 13.8,28.67 13.81,28.68 15.59,28.68 15.82,28.91 16.48,28.91
+3VALW on TOP (solid shape): 19.63,20.67 19.63,18.76 19.45,18.59 18.44,18.59 18.27,18.75 18.27,19.07 17.87,19.47 17.87,20.75 18.11,20.99 19.31,20.99
+3VALW on TOP (solid shape): 17.41,76.13 17.41,74.29 17.24,74.12 16.2,74.12 16.09,74.23 16.09,74.91 15.85,75.16 15.85,76.14 16.08,76.38 17.16,76.38
+3VALW on TOP (solid shape): 31.37,65.64 31.37,65.56 31.55,65.37 31.55,64.64 31.83,64.37 31.83,63.32 31.68,63.18 30.58,63.18 30.13,63.63 30.13,64.65 30.44,64.95 30.44,65.65 30.5,65.71 31.3,65.71
+3VALW on TOP (solid shape): 156.35,25.71 156.62,25.27 157.18,24.05 157.21,23.32 157.21,22.99 157.01,22.79 156.26,22.79 156.19,22.86 156.19,23.67 156.16,23.74 156.08,23.91 155.61,24.79 155.46,25.12 155.48,25.37 155.49,25.5 155.9,25.71 156.17,25.84
+3VALW on TOP (solid shape): 32.32,10.48 32.32,9.39 32.34,9.36 32.34,9.1 32.25,9.01 31.06,9.01 30.9,9.17 30.91,9.19 30.89,9.34 30.81,9.47 30.81,10.32 31.09,10.6 32.2,10.6
+3VALW on TOP (solid shape): 47.37,3.87 47.37,3.32 47.4,3.28 47.84,3.28 47.94,3.19 47.94,2.75 47.95,2.74 48.56,2.74 48.61,2.79 48.61,3.23 48.65,3.26 49.05,3.26 49.08,3.23 49.08,2.74 49.11,2.71 50.21,2.71 50.5,2.42 50.5,1.86 50.39,1.75 47.2,1.75 46.45,2.5 46.45,3.57 46.96,4.08 47.15,4.08
+3VALW on TOP (solid shape): 23.92,30.46 23.92,28.73 23.82,28.63 22.96,28.63 22.55,28.23 22.55,27.72 22.25,27.42 20.48,27.42 20.29,27.23 20.23,27.21 20.18,27.18 19.91,27.18 19.53,27.56 17.47,27.56 17.27,27.77 17.27,28.83 17.34,28.91 18.46,28.91 19.18,29.63 19.26,29.66 19.33,29.62 19.73,29.52 19.96,29.85 19.96,30.41 20.32,30.77 23.62,30.77
+3VALW on BOTTOM (solid shape): 58.39,11.36 58.39,7.24 57.93,6.79 56.11,6.79 56.03,6.86 56.03,7.8 55.7,8.13 55.7,10.92 56.33,11.54 58.21,11.54
+3VALW on BOTTOM (solid shape): 79.83,22.41 79.83,20.55 79.73,20.45 78.29,20.45 78.2,20.54 78.2,22.4 78.33,22.54 79.7,22.54
+3VALW on BOTTOM (solid shape): 13.39,49.69 13.39,49.18 13.34,49.13 12.59,49.13 12.53,49.19 11.36,49.19 11.27,49.28 11.27,49.46 11.35,49.54 12.38,49.54 12.56,49.71 13.37,49.71
+3VALW on BOTTOM (solid shape): 41.03,7.7 41.03,7.21 41.06,7.19 41.44,7.19 41.47,7.22 41.47,7.7 41.48,7.71 42.1,7.71 42.19,7.63 42.19,7.19 42.23,7.14 42.45,7.14 42.49,7.09 42.49,6.62 42.47,6.59 41.89,6.59 41.73,6.75 40.46,6.75 40.34,6.86 40.34,7.56 40.5,7.71 41.02,7.71
+3VALW on BOTTOM (solid shape): 22.2,30.18 22.83,30.18 23.09,29.93 23.09,29.04 22.58,28.53 22.58,27.39 20.55,25.36 17.45,25.36 17.14,25.66 17.14,26.65 17.17,26.68 17.65,26.68 17.67,26.7 17.67,27.36 17.62,27.41 17.19,27.41 17.14,27.46 17.14,27.79 17.22,27.87 17.65,27.87 17.7,27.92 17.7,28.56 17.65,28.61 17.27,28.61 17.24,28.63 17.24,28.66 17.12,28.78 17.12,29.06 17.22,29.17 20.55,29.17 20.93,29.55 20.93,30.31 21.18,30.56 21.82,30.56
+3VALW on BOTTOM (solid shape): 104.53,20.19 104.53,18.29 104.47,18.19 104.36,18.21 103.84,18.27 103.65,17.78 103.63,17.69 103.55,17.65 103.45,17.62 103.38,17.55 102.97,17.55 102.51,17.09 102.51,16.71 102.35,16.55 101.83,16.55 101.72,16.67 101.72,18.14 101.89,18.32 102.19,18.32 103.15,19.27 103.15,20 103.49,20.34 104.37,20.34
+3VALW on BOTTOM (solid shape): outline of 121 points within 112.64,4.48 124.89,18.32
+3VALW on IN1 (solid shape): 24.9,79.67 24.9,78.86 24.61,78.57 17.62,78.57 17.12,78.06 17.12,74.5 16.74,74.12 15.72,74.12 15.59,74.25 15.59,74.31 16.03,74.4 15.59,74.5 15.59,79.58 15.85,79.84 24.74,79.84
+3VALW on IN2 (solid shape): outline of 266 points within 99.07,17.99 108.26,24.08
+3VALW on VCC: 54.94,11 52.78,13.16 23.7,13.16 11.66,25.21 11.66,62.08 12.6,63.02 16.46,63.02 17.19,63.76 17.19,67.62 18.51,68.94 18.51,70.72 19,71.2 23.06,71.2 24.38,72.52 24.38,80.14 27.53,83.29 27.53,84.81 35.15,92.43 35.15,99.16 36.53,100.54 44.06,100.54 44.48,100.12 44.48,86.98 44.46,86.95 33.77,86.95 31.47,84.64 31.47,69.02 15.97,53.53 15.97,37.67 14.6,37.67 14.07,37.14 14.07,34.08 14.79,33.36 17.39,33.36 24.36,26.39 24.36,26.1 23.85,25.59 23.85,23.09 24.38,22.56 76.07,22.56 76.83,21.8 88.85,21.8 90.52,23.47 90.52,25 91.01,25.48 105.53,25.48 109.15,21.86 111.82,21.86 112.77,20.91 122.93,20.91 123.54,20.3 123.54,20.29 125.02,18.81 134.17,18.81 134.97,18.01 134.97,12.38 134.61,12.02 124.03,12.02 119.08,16.97 99.31,16.97 93.34,11 ; 1 cut-out
+3VALW_DSW_R on TOP (solid shape): 16.74,32.62 16.74,31.58 16.61,31.45 16.61,30.41 16.53,30.33 15.74,30.33 15.62,30.46 15.62,31.57 15.82,31.77 16.04,31.77 16.04,32.67 16.68,32.67
+3VALWP on TOP (solid shape): 13.33,32.06 13.33,28.94 13.08,28.68 8.96,28.68 8.81,28.83 8.81,32.01 9.06,32.26 13.13,32.26
+3VALWP on BOTTOM (solid shape): 13.31,32.09 13.31,31.58 13.69,31.2 17.24,31.2 17.37,31.07 17.37,30.31 16.99,29.93 16.99,28.5 17.01,28.48 17.5,28.48 17.52,28.45 17.52,28.05 17.5,28.02 17.04,28.02 16.99,27.97 16.99,27.36 17.07,27.29 17.47,27.29 17.55,27.21 17.55,26.85 17.5,26.8 17.09,26.8 17.01,26.73 17.01,26.14 16.99,26.12 15.47,26.12 15.21,26.37 15.21,27.51 15.1,27.63 15.1,27.65 14.83,27.92 13.08,27.92 12.72,28.28 9.29,28.28 8.84,28.73 8.84,32.04 9.06,32.26 13.13,32.26
+3VD on TOP (solid shape): 69.27,86.19 69.88,86.19 70.01,86.06 70.01,85.43 69.57,84.98 68.69,84.98 68.04,85.63 68.04,86.38 68.11,86.44 69.02,86.44
+3VD on TOP (solid shape): 64.94,53.05 64.94,52.49 65.05,52.38 65.48,52.38 65.53,52.34 65.53,51.95 65.44,51.86 63.49,51.86 63.32,52.04 63.32,53.05 63.42,53.15 64.84,53.15
+3VD on TOP (solid shape): 81.12,108.79 81.12,107.78 81,107.65 80.24,107.65 79.73,107.14 79.73,102.51 76.81,99.59 76.81,98.83 75.92,97.94 75.92,96.42 75.83,96.22 75.92,96.03 75.92,93.3 75.54,92.92 72.23,92.92 71.54,93.62 71.54,96.86 72.3,97.62 72.3,101.81 72.68,102.19 73.63,102.19 73.63,101.62 75.6,101.62 75.6,102.19 77.06,102.19 78.2,103.33 78.2,107.65 78.58,108.03 79.22,108.03 80.11,108.92 81,108.92
+3VD on BOTTOM (solid shape): 55.22,70.69 55.22,70.19 55.09,70.06 53.06,70.06 52.93,70.19 52.93,70.57 53.18,70.82 55.09,70.82
+3VD on BOTTOM (solid shape): 69.07,90.26 69.07,90.09 68.3,89.32 66.99,89.32 66.86,89.45 66.86,90.19 67.01,90.33 69,90.33
+3VD on GND2 (solid shape): 64.44,53.11 64.44,52.67 64.14,52.37 63.78,52.37 63.36,52.8 63.36,53.16 63.56,53.36 64.19,53.36
+3VD on GND2 (solid shape): 74.84,93.55 74.84,92.35 74.65,92.16 72.68,92.16 72.49,92.35 72.49,93.43 72.81,93.74 74.65,93.74
+3VD on VCC: 67.32,42.94 59.28,50.99 59.28,66.74 57.48,68.54 52.53,68.54 51.91,69.15 51.91,72.49 52.4,72.98 61.54,72.98 63.22,74.65 63.22,77.95 63.7,78.44 65.74,78.44 66.52,79.22 66.52,87.99 71.58,93.05 78.1,93.05 83.05,88.09 89.53,88.09 90.01,87.61 90.01,78.29 89.53,77.81 69.97,77.81 64.11,71.94 64.11,62.84 65.65,61.3 68.57,61.3 69.19,60.68 69.19,43.49 68.64,42.94
+3VD_LDO on TOP (solid shape): 64.87,101.87 64.87,101.75 65.63,100.98 65.63,99.97 65.5,99.84 64.93,99.84 64.87,99.9 64.87,100.6 64.55,100.92 64.55,101.87 64.61,101.94 64.8,101.94
+3VDP on TOP (solid shape): 76.17,106.38 77.31,106.38 77.7,106 77.7,103.33 76.81,102.44 72.93,102.44 72.62,102.76 72.62,103.33 71.47,104.48 71.47,104.98 71.73,105.24 72.62,105.24 72.87,105.49 72.87,106 73.12,106.25 74.01,106.25 74.27,106.51 76.04,106.51
+3VDP on BOTTOM (solid shape): 77.57,106.13 77.57,103.08 77.19,102.7 73.25,102.7 72.87,103.08 72.87,106.25 73.12,106.51 77.19,106.51
+3VLP on BOTTOM (solid shape): 9.12,24.21 9.12,23.96 8.99,23.83 8.07,23.83 7.62,24.29 6.7,24.29 6.51,24.48 6.51,25.16 6.56,25.22 8.11,25.22
+3VS on TOP (solid shape): 21.18,57.89 21.18,55.96 20.93,55.71 19.53,55.71 19.26,55.97 19.26,57.52 19.81,58.06 21.01,58.06
+3VS on TOP (solid shape): 31.34,30.82 31.34,28.78 31.09,28.53 28.63,28.53 28.58,28.58 28.58,30.13 28.42,30.3 28.42,31.2 28.55,31.32 30.83,31.32
+3VS on TOP (solid shape): 151.16,101.25 151.16,97.9 151.01,97.75 150.27,97.75 150.2,97.82 150.2,99.91 149.94,100.16 149.94,101.3 150.19,101.55 150.86,101.55
+3VS on TOP (solid shape): 134.9,29.51 134.9,27.98 134.77,27.85 134.03,27.85 133.45,27.27 132.98,27.27 132.46,27.78 132.46,28.2 133.51,29.25 133.51,29.25 133.84,29.59 134.83,29.59
+3VS on TOP (solid shape): 34.13,88.86 34.13,88.07 34.52,87.69 34.52,86.06 34.26,85.81 33.88,85.81 33.63,86.06 33.63,86.95 33.52,87.05 33.52,87.32 32.99,87.85 32.99,88.22 32.36,88.86 30.71,88.86 30.39,88.54 29.42,88.54 29.18,88.78 29.18,89.49 29.82,90.13 32.86,90.13
+3VS on BOTTOM (solid shape): 26.41,31.1 26.41,29.83 26.23,29.65 25.5,29.65 25.35,29.5 25.35,28.83 25.24,28.73 23.77,28.73 23.67,28.83 23.67,29.29 24.1,29.72 24.1,31.1 24.23,31.22 26.29,31.22
+3VS on BOTTOM (solid shape): 21.69,57.36 21.69,52.91 21.63,52.85 20.99,52.85 20.29,53.55 20.29,54.57 19.73,55.12 19.73,56.64 19.78,56.69 19.82,56.76 20.67,57.61 21.43,57.61
+3VS on BOTTOM (solid shape): 165.24,3.58 165.24,1.5 164.91,1.17 164.13,1.17 164.12,1.16 161.63,1.16 161.4,1.39 161.41,1.4 161.41,2.24 161.55,2.38 163.52,2.38 163.96,2.81 163.96,3.52 164.17,3.74 165.07,3.74
+3VS on BOTTOM (solid shape): 22.63,19.77 22.74,19.75 22.86,19.77 22.86,19.78 23.2,19.78 23.21,19.77 23.33,19.75 23.44,19.77 23.45,19.78 24.36,19.78 24.46,19.68 24.46,18.97 24.36,18.87 22.45,18.87 22.25,19.07 22.25,19.62 22.41,19.78 22.62,19.78
+3VS on IN1 (solid shape): 149.51,80.14 149.51,78.71 149.22,78.42 147.79,78.42 147.65,78.55 147.66,78.64 147.64,78.72 147.64,78.88 147.25,79.27 147.25,80.26 147.35,80.37 149.29,80.37
+3VS on GND2 (solid shape): 30.71,30.82 30.71,28.78 30.58,28.66 29.82,28.66 29.56,28.91 29.56,30.82 29.69,30.94 30.58,30.94
+3VS on IN2 (solid shape): 129.26,20.66 129.26,19.89 129.13,19.77 127.99,19.77 127.99,20.66 128.11,20.78 129.13,20.78
+3VS on IN2 (solid shape): 57.22,29.07 57.22,26.38 57.12,26.27 56.04,26.27 55.89,26.42 55.89,28.95 56.21,29.28 57.02,29.28
+3VS on IN2 (solid shape): 107.49,28 107.49,27.09 107.41,27.02 103.63,27.02 103.53,27.12 103.53,28.02 103.56,28.05 107.43,28.05
+3VS on IN2 (solid shape): 142.43,45.65 142.43,45.16 141.35,44.09 141.04,44.09 140.61,44.51 140.61,44.81 141.51,45.7 141.51,46 141.62,46.11 141.97,46.11
+3VS on IN2 (solid shape): 139.92,31.79 139.92,30.58 139.67,30.33 137.53,30.33 136.77,29.57 134.83,29.57 134.65,29.75 134.62,29.78 134.62,30.05 135.91,31.33 135.91,31.47 135.94,31.49 135.94,31.86 135.97,31.89 139.82,31.89
+3VS on IN3 (solid shape): 151.23,7.19 151.23,6.31 151.1,6.18 149.32,6.18 149.07,6.43 149.07,7.32 149.2,7.45 150.97,7.45
+3VS on IN3 (solid shape): 150.48,49.39 150.48,47.08 148.13,44.74 147.4,44.74 147.39,44.75 142.37,44.75 141.73,45.39 141.73,45.91 141.97,46.15 142.51,46.15 142.82,45.84 143.13,45.84 143.17,45.8 147.79,45.8 149.48,47.48 149.48,48.97 149.48,48.97 149.48,49.4 149.62,49.54 150.33,49.54
+3VS on IN3 (solid shape): outline of 166 points within 154.02,2.75 165.22,5.76
+3VS on VCC: 26.37,28.66 17.35,37.67 16.48,37.67 16.48,48.24 16.84,48.6 19.76,48.6 21.79,50.63 22.09,50.63 23.09,49.63 23.09,45.57 24.23,44.43 24.23,36.17 24.88,35.52 30.56,35.52 31.72,36.68 31.72,41.67 41.35,41.67 42.39,42.71 42.39,51.62 40.59,53.42 31.68,53.42 31.04,52.79 30.07,52.79 30.07,57.46 29.03,58.5 26.03,58.5 23.09,55.56 23.09,53.27 22.73,52.91 20.9,52.91 20.4,53.42 17.35,53.42 17.12,53.65 17.12,53.95 31.98,68.81 31.98,84.43 33.99,86.44 46.47,86.44 47.34,85.57 47.34,82.02 49.01,80.35 55.75,80.35 56.23,79.86 56.23,73.97 55.75,73.49 52.19,73.49 51.41,72.7 51.41,68.94 52.32,68.03 57.27,68.03 58.77,66.52 58.77,50.78 66.96,42.59 66.96,29.74 58.1,29.74 57.02,28.66 ; 1 cut-out
+3VS_CAM on TOP (solid shape): 146.55,102.52 146.55,101.94 146.89,101.6 146.89,100.21 146.85,100.18 146.85,99.13 146.82,99.1 146.82,97.54 147.39,96.97 147.39,96.42 147.32,96.35 146.02,96.35 146.01,96.35 145.87,96.35 145.78,96.43 145.78,102.56 145.82,102.6 146.46,102.6
+3VS_CAM on BOTTOM (solid shape): 146.66,101.67 146.66,100.91 146.49,100.75 145.17,100.75 145.04,100.88 143.78,100.88 143.69,100.97 143.69,101.47 143.69,101.62 143.79,101.71 145.04,101.71 145.15,101.83 146.5,101.83
+3VS_CR on TOP (solid shape): 23.34,70.19 23.34,67.85 23.19,67.7 23.19,66.68 23.14,66.63 23.03,66.63 22.98,66.68 22.98,67.65 22.96,67.67 22.96,68.33 22.86,68.43 22.58,68.43 22.55,68.46 22.55,69.25 22.59,69.28 22.59,70.2 22.7,70.31 23.21,70.31
+3VS_CR on TOP (solid shape): 21.99,63.38 21.99,62.39 22.39,61.99 22.39,60.85 22.58,60.66 23.97,60.66 24.04,60.6 24.04,59.8 23.83,59.59 22.31,59.59 21.48,58.76 20.99,58.76 20.1,58.76 20.1,58.56 19.64,58.1 19.07,58.1 18.98,58.2 18.98,58.9 19.14,59.06 19.71,59.06 19.91,59.26 19.91,59.6 20.31,60 20.31,61.71 20.53,61.93 21.59,61.93 21.79,62.12 21.79,63.38 21.84,63.43 21.94,63.43
+3VS_CR on GND2 (solid shape): 23.5,70.38 23.56,70.38 23.58,70.38 23.71,70.25 23.71,69.79 23.63,69.61 23.71,69.44 23.71,69.06 23.53,68.88 23.03,68.88 22.8,69.11 22.8,69.22 22.86,69.4 22.8,69.58 22.8,70.22 22.98,70.4 23.44,70.4
+3VS_CR on IN2 (solid shape): 23.22,61.68 23.22,61.33 22.39,60.5 21.17,60.5 21.08,60.58 21.08,61.52 21.15,61.6 21.9,61.6 22.44,62.14 22.76,62.14
+3VS_CR on IN2 (solid shape): 23.87,70.06 23.87,67.76 23.68,67.57 23.03,67.57 22.82,67.77 22.82,68.64 22.87,68.8 22.82,68.96 22.82,69.97 23.18,70.33 23.61,70.33
+3VS_FP on BOTTOM (solid shape): 155.85,7.67 155.85,6.94 156.15,6.64 156.15,5.65 156.2,5.6 156.25,5.55 156.38,5.42 158.72,5.42 158.72,5.42 159.61,5.42 160.52,4.5 161.83,4.5 161.97,4.37 161.97,3.94 162.27,3.64 162.51,3.64 162.64,3.51 162.64,2.79 162.42,2.57 161.24,2.57 161.03,2.37 158.2,2.37 156.78,3.79 159.58,3.79 159.59,3.74 159.6,3.7 159.62,3.65 159.65,3.61 159.67,3.6 160.07,3.2 160.1,3.2 160.1,2.99 160.72,2.99 160.72,3.98 160.11,3.98 160.06,4.03 160.02,4.05 159.98,4.07 159.93,4.09 159.89,4.09 159.84,4.09 159.79,4.08 159.75,4.07 159.7,4.04 159.67,4.01 159.64,3.97 159.61,3.93 159.59,3.89 159.58,3.84 159.58,3.79 156.78,3.79 155.69,4.87 155.69,5.48 155.36,5.82 155.36,7.74 155.38,7.76 155.76,7.76
+3VS_SENSOR on BOTTOM (solid shape): 66.13,16.71 66.18,16.71 66.38,16.71 66.43,16.71 66.88,16.71 66.97,16.62 66.97,14.95 66.85,14.83 65.73,14.83 65.62,14.93 65.62,16.44 65.9,16.71
+3VS_TPM on TOP (solid shape): 25.96,19.81 25.96,17.56 25.88,17.48 24.29,17.48 24.19,17.58 24.19,19.78 24.27,19.86 25.9,19.86
+3VS_TS on TOP (solid shape): 55.98,99.08 55.98,98.38 55.72,98.13 55.72,97.62 55.6,97.49 55.6,94.87 55.5,94.76 54.9,94.76 54.84,94.82 54.84,95.41 54.96,95.53 54.96,97.52 54.86,97.62 53.57,97.62 53.31,97.87 53.31,98.95 53.82,99.46 55.6,99.46
+5V_VBUS1 on BOTTOM (solid shape): 21.91,74.45 21.91,73.94 21.84,73.87 21.15,73.87 21.12,73.84 21.12,72.45 21.09,72.41 20.14,72.41 19.66,71.93 19.42,71.93 19.3,71.81 19.3,71.51 19.18,71.39 16.42,71.39 16.39,71.42 16.39,73.58 16.49,73.68 18.36,73.68 19.27,74.59 21.77,74.59
+5V_VBUS2 on TOP (solid shape): 23.71,99.63 23.71,98.45 23.54,98.29 22.45,98.29 22.04,98.69 22.04,99.29 22.04,99.29 22.04,99.52 22.19,99.66 22.81,99.66 22.9,99.76 22.92,99.77 23.57,99.77
+5V_VBUS2 on BOTTOM (solid shape): 25.75,102.06 25.75,99.52 25.63,99.4 23.14,99.4 22.96,99.58 22.96,101.98 23.1,102.13 25.69,102.13
+5V_VBUS2 on IN1 (solid shape): 23.74,99.58 23.74,97.95 23.56,97.77 23,97.77 22.89,97.88 22.89,98.15 22.74,98.3 22.29,98.3 22.03,98.56 22.03,99.42 22.34,99.73 23.59,99.73
+5V_VBUS2 on GND2 (solid shape): 24.66,99.89 24.66,99.05 24.12,98.51 22.16,98.51 22.09,98.54 22.06,98.61 21.95,98.83 21.71,98.9 21.67,98.9 21.62,98.9 21.56,98.9 21.5,98.89 21.46,98.93 21.46,99.53 21.63,99.7 21.9,99.7 21.9,99.71 21.97,99.71 22.88,100.61 23.93,100.61
+5V_VBUS2 on IN2 (solid shape): 24.75,100.8 24.75,99.34 24.23,98.81 21.8,98.81 21.71,98.88 21.6,98.9 21.54,98.96 21.54,100.31 21.77,100.54 21.77,100.84 21.98,101.04 24.51,101.04
+5V_VBUS2 on GND3 (solid shape): 24.99,100.79 24.99,99.49 24.15,98.64 22.36,98.64 22.36,98.69 22.23,98.82 21.95,98.82 21.84,98.89 21.67,98.9 21.62,98.9 21.56,98.9 21.49,98.89 21.48,98.9 21.48,99.5 23.03,101.06 24.73,101.06
+5VALW on TOP (solid shape): 81.17,107.28 81.17,104.63 81.07,104.52 80.32,104.52 80.06,104.78 80.06,107.3 80.16,107.4 81.05,107.4
+5VALW on TOP (solid shape): 28.83,102.43 28.99,102.37 29.15,102.43 29.44,102.43 29.5,102.38 29.5,101.43 29.27,101.21 29.27,100.26 29.04,100.02 28.21,100.02 28.14,100.09 28.14,100.99 28.55,101.4 28.55,102.31 28.67,102.43
+5VALW on BOTTOM (solid shape): 24,75.61 24,74.68 23.93,74.6 22.07,74.6 22,74.67 22,75.61 22.12,75.72 23.88,75.72
+5VALW on BOTTOM (solid shape): 52.04,86.47 54.07,86.47 54.07,86.95 54.58,86.95 54.71,86.82 54.71,84.92 54.33,84.54 51.53,84.54 51.28,84.79 51.28,86.82 51.41,86.95 52.04,86.95
+5VALW on BOTTOM (solid shape): 29.82,101.21 29.82,96.88 29.93,96.77 29.93,96.19 29.87,96.14 29.61,96.14 29.44,95.97 29.44,95.73 29.2,95.5 28.39,95.5 28.23,95.66 28.23,101.24 28.41,101.43 29.6,101.43
+5VALW on BOTTOM (solid shape): 57.06,41.19 57.06,39.81 56.38,39.13 55.72,39.13 55.58,39.27 55.58,40.1 55.62,40.2 55.64,40.3 55.64,41.18 55.81,41.36 56.89,41.36
+5VALW on BOTTOM (solid shape): 24.31,67.06 24.31,66.27 24.18,66.14 24.18,64.55 24.11,64.48 21.51,64.48 21.24,64.74 21.24,66.64 21.42,66.82 23.21,66.82 23.55,67.15 24.22,67.15
