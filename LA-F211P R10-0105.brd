# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D61: length 31.8
  IN1 w0.064: v12(96.78,101.89) 96.61,101.73 94.85,101.73 93.15,100.03 93.15,99.89 93.22,99.83 93.42,99.83 93.48,99.76 93.48,99.64 93.42,99.57 93.22,99.57 93.15,99.51 93.15,99.38 93.22,99.32 93.42,99.32 93.48,99.26 93.48,99.13 93.42,99.07 93.22,99.07 93.15,99 93.15,94.72 95.36,92.52 95.36,92.43 94.81,91.89 94.81,91.8 94.89,91.71 94.98,91.71 95.53,92.26 95.62,92.26 95.71,92.17 95.71,92.08 95.16,91.53 95.16,91.45 95.25,91.36 95.34,91.36 95.89,91.9 95.98,91.9 96.07,91.81 96.07,91.72 95.52,91.18 95.52,91.09 95.62,90.98 95.71,90.98 96.16,91.43 96.25,91.43 96.35,91.33 96.35,91.23 95.9,90.77 95.9,90.68 96.04,90.54 96.13,90.54 96.4,90.81 96.49,90.81 96.58,90.72 96.58,90.63 96.31,90.36 96.31,90.27 96.58,90 96.58,88.39 98.2,86.76 98.2,82.85 98.38,82.68 98.38,82.12 v6(98.12,81.86)
DDR_B_D62: length 35.2
  IN1 w0.064: v12(97.58,101.89) 97.86,101.89 97.93,101.96 97.93,102.1 97.86,102.16 96.62,102.16 96.44,101.98 94.8,101.98 92.94,100.12 92.94,94.63 93.16,94.41 93.16,94.32 92.94,94.1 92.94,94.01 93.03,93.92 93.12,93.92 93.34,94.14 93.43,94.14 93.54,94.03 93.54,93.94 93,93.4 93,93.31 93.13,93.17 93.22,93.17 93.76,93.71 93.86,93.71 93.97,93.6 93.97,93.51 93.44,92.99 93.44,92.86 93.85,92.46 93.94,92.46 94.48,93 94.57,93 94.67,92.89 94.67,92.8 94.13,92.26 94.13,92.17 94.21,92.09 94.31,92.09 94.81,92.59 94.9,92.59 95.01,92.48 95.01,92.39 94.5,91.89 94.5,91.8 95.33,90.97 95.33,90.88 95.04,90.59 95.04,90.5 95.13,90.41 95.22,90.41 95.51,90.7 95.6,90.7 95.69,90.61 95.69,90.52 95.4,90.23 95.4,90.14 95.49,90.05 95.58,90.05 95.87,90.34 95.96,90.34 96.05,90.26 96.05,90.16 95.73,89.85 95.73,89.79 95.85,89.67 95.94,89.67 96.22,89.95 96.31,89.95 96.4,89.86 96.4,89.77 96.12,89.49 96.12,89.4 96.3,89.22 96.3,88.38 97.91,86.77 97.91,82.57 97.97,82.51 v6(98.12,82.51)
DDR_B_D63: length 31
  IN1 w0.064: v6(98.09,80.56) 98.09,80.71 97.76,81.04 97.76,86.62 95.82,88.56 95.82,89.38 94.8,90.4 94.8,91.2 92.72,93.27 92.72,100.21 94.71,102.2 96.31,102.2 96.49,102.38 98.06,102.38 98.11,102.33 100.38,102.33 100.74,102.69 v12(100.78,102.69)
DDR_B_DQS0: length 17.2
  IN3 w0.061: 106.6,88.98 106.6,88.83 106.09,88.33 106.09,86.7 105.81,86.42 105.81,85.73 106.02,85.53 106.69,85.53 106.83,85.39 106.83,84.87 106.7,84.74 106.3,84.74 106.19,84.85 106.19,84.97 106.09,85.07 106.09,85.21 106.16,85.27 106.38,85.27 v3(106.53,85.12)
  IN3 w0.086: 106.6,88.98 106.6,91.54 109.97,94.92 109.97,96.33 110.37,96.73 110.87,96.73 111.17,97.03 v14(111.17,97.09)
DDR_B_DQS1: length 24.2
  IN3 w0.061: v14(107.97,101.09) 108.15,100.91 108.15,100.75 108.09,100.69 105.89,100.69 105.76,100.56 ; 103.56,88.82 103.61,88.77 103.61,86.64 103.28,86.31 103.28,85.74 103.47,85.55 104.14,85.55 104.28,85.41 104.28,84.92 104.12,84.77 103.84,84.77 103.72,84.89 103.72,85.06 103.78,85.12 v3(104.01,85.12)
  IN3 w0.086: 105.76,100.56 105.22,100.01 104.7,100.01 104.29,99.6 104.29,99.02 104.56,98.76 104.71,98.76 104.79,98.67 104.79,98.34 104.71,98.25 104.56,98.25 104.29,97.99 104.29,97.35 104.56,97.09 104.82,97.09 104.86,97.05 104.86,96.64 104.78,96.55 104.56,96.55 104.29,96.28 104.29,95.71 104.56,95.44 104.78,95.44 104.86,95.35 104.86,94.89 104.78,94.8 104.56,94.8 104.29,94.53 104.29,93.59 103.52,92.82 103.52,90.47 103.23,90.18 103.23,89.15 103.56,88.82
DDR_B_DQS2: length 21.7
  IN1 w0.061: v6(107.23,81.21) 107.04,81.41 107.04,81.57 106.99,81.62 106.99,82.79 107.07,82.87 107.07,86.8 108.43,88.16 108.43,89.58 108.51,89.66 108.51,89.67
  IN1 w0.086: 108.51,89.67 108.51,91.39 108.24,91.66 107.66,91.66 107.58,91.74 107.58,92 107.66,92.09 108.24,92.09 108.51,92.36 108.51,92.91 108.24,93.18 107.64,93.18 107.55,93.27 107.55,93.53 107.64,93.61 108.25,93.61 108.52,93.88 108.52,94.48 108.25,94.75 107.66,94.75 107.58,94.83 107.58,95.2 107.7,95.33 108.38,95.33 108.71,95.66 108.71,96.51 108.44,96.78 108.12,96.78 107.97,96.93 v12(107.97,97.09)
DDR_B_DQS3: length 30.2
  IN1 w0.061: v6(103.58,81.21) 103.58,81.11 103.64,81.04 103.81,81.04 103.87,81.11 103.87,81.17 103.99,81.28 103.99,81.45 103.87,81.57 103.87,81.83 104.1,82.06 104.1,82.26 104.01,82.35 104.01,87.7 104.26,87.95 104.26,89.58 104.18,89.66
  IN1 w0.086: 104.18,89.66 104.18,94.58 104.1,94.66 103.84,94.66 103.58,94.93 103.58,95.45 103.84,95.71 104.1,95.71 104.18,95.8 104.18,96.73 104.1,96.82 103.84,96.82 103.58,97.09 103.58,97.72 103.84,97.99 104.01,97.99 104.09,98.08 104.09,98.36 104.01,98.45 103.84,98.45 103.58,98.72 103.58,99.31 103.84,99.58 104.19,99.58 104.27,99.67 104.27,100.05 105.64,101.41 108.5,101.41 108.88,101.79 109.58,101.79 109.85,101.52 109.85,101.48 110.45,100.88 110.96,100.88 v12(111.17,101.09)
DDR_B_DQS4: length 17.3
  IN3 w0.061: 99.65,89.56 101.04,88.17 101.04,86.62 100.73,86.31 100.73,85.71 100.94,85.5 101.55,85.5 101.78,85.27 101.78,84.86 101.66,84.74 101.32,84.74 101.21,84.86 101.21,85.06 101.27,85.12 v3(101.5,85.12) ; 100.55,96.85 100.54,96.85
  IN3 w0.086: 100.55,96.85 100.66,96.85 100.78,96.96 v14(100.78,97.09) ; 100.54,96.85 99.07,96.85 98.8,96.58 98.8,95.89 99.09,95.6 99.5,95.6 99.58,95.51 99.58,89.63 99.65,89.56
DDR_B_DQS5: length 24.9
  IN3 w0.061: 95.76,100.5 95.78,100.51 95.89,100.51 96.14,100.77 97.69,100.77 97.75,100.83 97.75,101.02 97.68,101.09 v14(97.58,101.09) ; 96.54,89.57 96.54,89.44 98.54,87.44 98.54,86.57 98.27,86.3 98.27,85.69 98.51,85.45 99.05,85.45 99.26,85.23 99.26,84.93 99.08,84.75 98.86,84.75 98.69,84.92 98.69,85.06 98.75,85.12 v3(98.98,85.12)
  IN3 w0.086: 95.76,100.5 94.58,99.31 94.58,95.82 94.84,95.55 95.09,95.55 95.18,95.47 95.18,95.21 95.09,95.12 94.84,95.12 94.58,94.85 94.58,94.3 94.91,93.97 95.22,93.97 95.3,93.88 95.3,92.66 95.67,92.29 96.05,92.29 96.25,92.5 96.37,92.5 96.54,92.33 96.54,91.56 96.46,91.47 96.07,91.47 95.91,91.31 95.91,90.61 96.14,90.38 96.46,90.38 96.54,90.29 96.54,89.57
DDR_B_DQS6: length 22
  IN1 w0.061: 100.32,90.92 100.32,90.91 100.24,90.83 100.24,88.15 101.15,87.24 101.27,87.12 101.27,84.8 101.47,84.6 101.47,82.24 101.85,81.86 101.85,81.3 101.58,81.03 100.92,81.03 100.45,81.51 v6(100.45,81.51)
  IN1 w0.086: 100.32,90.92 100.32,95.24 99.78,95.78 99.78,97.32 99.51,97.59 98.83,97.59 98.56,97.32 98.56,97.02 98.47,96.94 98.16,96.94 98.01,97.09 97.68,97.09 v12(97.58,97.09)
  BOTTOM w0.076: v6(100.45,81.51) 100.76,81.21 UC1.AW9
DDR_B_DQS7: length 31.6
  IN1 w0.061: 96.83,90.92 96.83,90.91 96.91,90.83 96.91,88.28 98.46,86.74 98.46,83.41 98.54,83.33 98.54,81.8 98.37,81.63 98.37,81.27 98.31,81.21 v6(98.09,81.21) ; v12(100.78,101.09) 100.6,100.91 99.27,100.91 99.15,101.04 99.15,101.38 98.94,101.58 95.59,101.58 95.27,101.26 95.16,101.26 95.14,101.25
  IN1 w0.086: 95.14,101.25 93.98,100.09 93.98,99.36 94.28,99.07 94.28,98.85 94.19,98.76 93.94,98.76 93.64,98.46 93.64,97.96 93.9,97.69 94.19,97.69 94.28,97.61 94.28,97.35 94.19,97.26 93.9,97.26 93.64,97 93.64,96.48 93.9,96.21 94.19,96.21 94.28,96.13 94.28,95.87 94.19,95.78 93.9,95.78 93.64,95.51 93.64,94.92 93.92,94.64 94.18,94.64 94.28,94.54 94.28,94.28 96.83,91.72 96.83,90.92
DDR_B_DQS#0: length 16.6
  IN3 w0.061: v3(105.79,85.12) 105.83,85.12 106.04,84.91 106.04,84.79 106.24,84.59 106.76,84.59 106.98,84.81 106.98,85.45 106.75,85.68 106.08,85.68 105.96,85.79 105.96,86.35 106.24,86.63 106.24,88.27 106.77,88.8
  IN3 w0.086: v14(111.17,96.29) 111.04,96.42 110.5,96.42 110.28,96.2 110.28,94.79 106.91,91.42 106.91,88.93 106.77,88.8
DDR_B_DQS#1: length 23.7
  IN3 w0.061: 103.76,89.06 103.76,86.58 103.43,86.25 103.43,85.8 103.53,85.7 104.2,85.7 104.43,85.47 104.43,84.86 104.19,84.62 103.78,84.62 103.57,84.83 103.57,85.06 103.51,85.12 v3(103.28,85.12) ; 105.98,100.34 105.99,100.35 105.99,100.46 106.07,100.54 107.72,100.54 v14(107.97,100.29)
  IN3 w0.086: 105.98,100.34 105.34,99.7 104.83,99.7 104.6,99.47 104.6,99.15 104.69,99.07 104.83,99.07 105.1,98.8 105.1,98.21 104.83,97.94 104.69,97.94 104.6,97.86 104.6,97.48 104.68,97.4 104.94,97.4 105.17,97.17 105.17,96.51 104.91,96.24 104.69,96.24 104.6,96.16 104.6,95.84 104.69,95.75 104.91,95.75 105.17,95.48 105.17,94.76 104.91,94.49 104.69,94.49 104.6,94.4 104.6,93.46 103.83,92.69 103.83,90.34 103.54,90.05 103.54,89.28 103.76,89.06
DDR_B_DQS#2: length 21.6
  IN1 w0.061: 108.2,89.67 108.2,89.66 108.22,89.64 108.28,89.58 108.28,88.23 106.92,86.86 106.92,82.93 106.84,82.85 106.84,81.56 106.89,81.51 106.89,81.21 106.79,81.11 106.42,81.11 v6(106.32,81.21)
  IN1 w0.086: 108.2,89.67 108.2,91.26 108.12,91.35 107.54,91.35 107.27,91.62 107.27,92.13 107.54,92.4 108.12,92.4 108.2,92.49 108.2,92.78 108.12,92.87 107.51,92.87 107.24,93.14 107.24,93.65 107.51,93.92 108.12,93.92 108.21,94.01 108.21,94.35 108.12,94.44 107.54,94.44 107.27,94.71 107.27,95.33 107.57,95.64 108.25,95.64 108.4,95.79 108.4,96.38 108.31,96.47 108.15,96.47 v12(107.97,96.29)
DDR_B_DQS#3: length 30.6
  IN1 w0.061: 104.49,89.67 104.49,89.66 104.41,89.58 104.41,87.89 104.16,87.64 104.16,82.42 104.25,82.32 104.25,82 104.02,81.77 104.02,81.63 104.14,81.51 104.14,81.22 104.02,81.11 104.02,80.89 104.08,80.83 104.63,80.83 104.7,80.89 104.7,81.08 104.56,81.21 v6(104.49,81.21)
  IN1 w0.086: v12(111.17,100.29) 110.9,100.57 110.32,100.57 109.54,101.35 109.54,101.39 109.46,101.48 109.01,101.48 108.63,101.1 105.76,101.1 104.58,99.92 104.58,99.54 104.31,99.27 103.97,99.27 103.89,99.19 103.89,98.85 103.97,98.76 104.14,98.76 104.4,98.49 104.4,97.95 104.14,97.68 103.97,97.68 103.89,97.6 103.89,97.21 103.97,97.13 104.22,97.13 104.49,96.86 104.49,95.67 104.22,95.4 103.97,95.4 103.89,95.32 103.89,95.06 103.97,94.97 104.22,94.97 104.49,94.7 104.49,89.67
DDR_B_DQS#4: length 17.1
  IN3 w0.061: v3(100.76,85.12) 100.99,85.12 101.06,85.06 101.06,84.8 101.26,84.59 101.72,84.59 101.93,84.8 101.93,85.33 101.61,85.65 101,85.65 100.88,85.77 100.88,86.25 101.19,86.55 101.19,88.24 99.89,89.53 99.89,89.68
  IN3 w0.086: v14(100.78,96.29) 100.78,96.37 100.61,96.54 99.2,96.54 99.11,96.45 99.11,96.02 99.22,95.91 99.62,95.91 99.89,95.64 99.89,89.68
DDR_B_DQS#5: length 24.7
  IN3 w0.061: 95.98,100.28 95.99,100.29 95.99,100.41 96.2,100.62 97.25,100.62 v14(97.58,100.29) ; v3(98.25,85.12) 98.48,85.12 98.54,85.06 98.54,84.85 98.8,84.6 99.14,84.6 99.41,84.87 99.41,85.29 99.11,85.6 98.58,85.6 98.42,85.75 98.42,86.24 98.69,86.51 98.69,87.5 96.77,89.42 96.77,89.54
  IN3 w0.086: 96.77,89.54 96.85,89.62 96.85,90.56 96.77,90.65 96.25,90.65 96.15,90.74 96.15,91.08 96.24,91.16 96.63,91.16 96.85,91.39 96.85,92.46 96.5,92.81 96.12,92.81 95.92,92.6 95.8,92.6 95.61,92.79 95.61,94.01 95.34,94.28 95.04,94.28 94.89,94.43 94.89,94.72 94.97,94.81 95.22,94.81 95.49,95.08 95.49,95.59 95.22,95.86 94.97,95.86 94.89,95.95 94.89,99.19 95.98,100.28
DDR_B_DQS#6: length 22.4
  IN1 w0.061: v14(101.42,81.54) 101.42,81.56 101.29,81.69 101.09,81.69 100.99,81.59 100.87,81.59 100.78,81.5 100.78,81.39 100.99,81.18 101.52,81.18 101.7,81.36 101.7,81.79 101.32,82.17 101.32,84.54 101.12,84.74 101.12,87.06 101.04,87.13 100.09,88.09 100.09,90.83 100.01,90.91 100.01,90.92
  IN1 w0.086: 100.01,90.92 100.01,95.12 99.47,95.65 99.47,97.2 99.38,97.28 98.95,97.28 98.87,97.2 98.87,96.89 98.6,96.63 98.03,96.63 97.88,96.78 97.5,96.78 97.34,96.63 97.34,96.44 97.49,96.29 v12(97.58,96.29)
  BOTTOM w0.076: UC1.AY9 v14(101.42,81.54)
DDR_B_DQS#7: length 32
  IN1 w0.061: v6(99.01,81.21) 98.85,81.06 98.66,81.06 98.52,81.2 98.52,81.57 98.69,81.74 98.69,83.39 98.61,83.47 98.61,86.8 97.06,88.35 97.06,90.83 97.14,90.91 97.14,90.92 ; v12(100.78,100.29) 100.78,100.7 100.72,100.76 99.21,100.76 99,100.98 99,101.32 98.88,101.43 95.65,101.43 95.37,101.16 95.37,101.04 95.36,101.03
  IN1 w0.086: 97.14,90.92 97.14,91.85 94.59,94.41 94.59,94.76 94.4,94.95 94.05,94.95 93.95,95.05 93.95,95.38 94.03,95.47 94.32,95.47 94.59,95.74 94.59,96.25 94.32,96.52 94.03,96.52 93.95,96.61 93.95,96.87 94.03,96.95 94.32,96.95 94.59,97.22 94.59,97.74 94.32,98 94.03,98 93.95,98.09 93.95,98.33 94.07,98.45 94.32,98.45 94.59,98.72 94.59,99.2 94.29,99.49 94.29,99.96 95.36,101.03
DDR_B_MA0: length 64.8
  TOP w0.127: UD5.P3 v8(111.57,107.09) ; UD6.P3 v8(101.18,107.09)
  IN3 w0.064: v3(93.19,107.5) 93.79,107.5 94.91,106.38 96.09,106.38 96.27,106.56 97.44,106.56 v14(97.58,106.69) 97.71,106.56 98.14,106.56 98.27,106.43 100.03,106.43 100.16,106.56 100.64,106.56 v8(101.18,107.09) 101.48,106.79 105.07,106.79 105.48,106.38 106.46,106.38 106.64,106.56 107.84,106.56 v14(107.97,106.69) 108.11,106.56 108.53,106.56 108.66,106.43 110.43,106.43 110.56,106.56 110.9,106.56 111.43,107.09 v8(111.57,107.09) 111.67,107.19 111.82,107.19 111.94,107.07 111.94,106.98 111.6,106.63 111.6,106.54 111.69,106.46 111.86,106.46 112.19,106.79 112.19,106.98 112.26,107.04 112.38,107.04 112.45,106.98 112.45,106.79 112.51,106.72 112.64,106.72 112.7,106.79 112.7,106.95 112.77,107.01 112.89,107.01 112.96,106.95 112.96,106.79 113.02,106.72 113.2,106.72 113.39,106.91 113.51,106.91 113.57,106.85 113.57,106.49
  IN3 w0.097: v13(112.72,81.21) 112.92,81.01 113.27,81.01 113.37,80.91 113.37,80.32 113.27,80.22 113.03,80.22 112.94,80.32 112.94,80.6 112.87,80.66 112.56,80.66 112.18,81.04 112.18,81.18 112.42,81.42 112.42,81.56 112.26,81.72 112.26,81.86 112.53,82.13 112.71,82.13 112.77,82.19 112.77,82.48 112.66,82.59 112.62,82.59 112.52,82.68 112.52,82.88 112.62,82.97 112.66,82.97 112.78,83.08 112.78,83.22 112.58,83.42 112.58,83.58 112.71,83.71 112.71,83.71 112.77,83.77 112.77,83.95 112.61,84.1 112.61,84.26 112.77,84.42 112.77,84.76 112.67,84.86 112.06,84.86 111.49,85.43 111.49,85.57 111.84,85.92 111.84,86.06 111.7,86.2 111.7,86.78 111.6,86.87 110.86,86.87 110.76,86.97 110.76,87.16 110.86,87.26 111.6,87.26 111.7,87.36 111.7,87.55 111.6,87.64 110.86,87.64 110.76,87.74 110.76,87.93 110.86,88.03 111.6,88.03 111.7,88.13 111.7,88.32 111.6,88.42 110.86,88.42 110.76,88.51 110.76,88.71 110.86,88.8 111.6,88.8 111.7,88.9 111.7,89.09 111.6,89.19 111.37,89.19 111.27,89.29 111.27,89.48 111.37,89.58 111.51,89.58 115.87,93.94 115.87,104.2 113.57,106.49
DDR_B_MA1: length 67.3
  TOP w0.127: UD5.P7 v12(110.37,106.69) ; UD6.P7 v12(99.98,106.69)
  IN1 w0.064: 113.57,106.53 113.48,106.53 113.47,106.55 112.23,106.55 112.09,106.41 111.35,106.41 111.06,106.69 v12(110.37,106.69) 110.31,106.63 109.59,106.63 109.53,106.69 v14(108.77,106.69) 108.15,106.69 108.02,106.56 101.83,106.56 101.64,106.37 100.77,106.37 100.58,106.56 100.11,106.56 v12(99.98,106.69) 99.91,106.63 98.86,106.63 98.8,106.69 v14(98.38,106.69) 98.24,106.83 94.18,106.83 94.07,106.94 v2(93.19,106.94)
  IN1 w0.097: v14(112.89,83.5) 113.17,83.77 113.34,83.77 113.45,83.88 113.45,84.14 113.38,84.21 113.13,84.21 113.04,84.3 113.04,84.63 113.33,84.92 113.83,84.92 114.04,85.13 114.04,91.46 115.21,92.63 115.21,93.18 116.44,94.41 116.44,103.45 116.02,103.87 116.02,104.1 115.92,104.2 115.69,104.2 115.59,104.3 115.59,104.49 115.69,104.59 115.92,104.59 116.02,104.68 116.02,104.88 115.92,104.97 115.36,104.97 115.26,105.07 115.26,105.26 115.36,105.36 115.92,105.36 116.02,105.46 116.02,105.65 115.92,105.75 115.36,105.75 115.26,105.84 115.26,106.04 115.36,106.13 115.92,106.13 116.02,106.23 116.02,107.74 115.92,107.84 115.7,107.84 115.6,107.75 115.6,106.63 115.51,106.53 115.29,106.53 115.2,106.63 115.2,107.76 115.1,107.85 114.91,107.85 114.81,107.76 114.81,106.63 114.71,106.53 113.57,106.53
  BOTTOM w0.127: UD8.P7 v14(98.38,106.69) ; UD7.P7 v14(108.77,106.69) ; UC1.BW6 v14(112.89,83.5)
DDR_B_MA2: length 61.7
  IN1 w0.064: v2(92.04,108.61) 92.32,108.33 93.44,108.33 93.58,108.46 95.43,108.46 95.87,108.03 97.04,108.03 v14(97.18,107.89) 97.92,107.89 98.05,107.76 100.09,107.76 100.35,107.49 v12(100.78,107.49) 100.91,107.63 105.58,107.63 105.85,107.89 v14(107.57,107.89) 108.05,107.89 108.19,107.76 109.4,107.76 109.46,107.82 109.46,107.97 109.52,108.03 109.65,108.03 109.71,107.97 109.71,107.82 109.78,107.76 109.9,107.76 109.97,107.82 109.97,107.97 110.03,108.03 110.16,108.03 110.22,107.97 110.22,107.82 110.28,107.76 110.48,107.76 110.75,107.49 v12(111.17,107.49) 111.31,107.63 111.68,107.63 112.23,108.18 112.23,108.67 112.17,108.73 111.88,108.73 111.81,108.79 111.81,108.98 111.86,109.03 112.43,109.03 112.49,108.96 112.49,108.67 112.56,108.6 112.68,108.6 112.75,108.67 112.75,108.96 112.81,109.03 113.57,109.03
  IN1 w0.097: v6(115.4,83.5) 115.29,83.61 115.29,84.74 115.19,84.83 114.79,84.83 114.7,84.93 114.7,85.39 114.79,85.49 115.14,85.49 115.24,85.59 115.24,85.96 115.14,86.06 114.76,86.06 114.7,86.12 114.7,86.53 114.78,86.62 114.78,91.15 115.96,92.32 115.96,92.86 117.18,94.09 117.18,104.23 117.13,104.29 116.89,104.29 116.77,104.41 116.77,105.51 116.86,105.6 117.09,105.6 117.18,105.7 117.18,105.89 117.09,105.99 116.86,105.99 116.77,106.09 116.77,106.28 116.86,106.38 117.09,106.38 117.18,106.47 117.18,106.66 117.09,106.76 116.86,106.76 116.77,106.86 116.77,108.05 116.11,108.71 115.64,108.71 115.55,108.8 115.55,108.93 115.45,109.03 115.26,109.03 115.16,108.93 115.16,108.8 115.06,108.71 114.61,108.71 114.53,108.79 114.53,108.92 114.42,109.03 113.57,109.03
  BOTTOM w0.127: UD8.R3 v14(97.18,107.89) ; UC1.BW5 113.66,83.5 v6(115.4,83.5) ; UD7.R3 v14(107.57,107.89)
DDR_B_MA3: length 66.9
  TOP w0.127: v2(110.37,105.89) UD5.N7 ; v2(99.98,105.89) UD6.N7
  IN1 w0.064: 113.57,105.37 113.45,105.37 113.38,105.43 113.38,106.11 113.32,106.17 112.89,106.17 112.75,106.03 112.26,106.03 112.13,106.16 111.05,106.16 110.92,106.03 110.51,106.03 v2(110.37,105.89) 110.37,105.89 108.78,105.89 v6(108.77,105.89) 107.91,105.89 107.55,106.26 102.32,106.26 102.09,106.03 101.87,106.03 101.73,106.16 100.66,106.16 100.52,106.03 100.11,106.03 v2(99.98,105.89) 99.97,105.89 98.38,105.89 v6(98.38,105.89) 97.88,106.39 v2(93.19,106.39)
  IN1 w0.097: v6(114.07,83.82) 113.68,83.82 113.05,83.18 112.81,83.18 112.59,83.4 112.59,83.59 112.75,83.74 112.75,84.73 113.47,85.45 113.47,85.6 113.56,85.69 113.69,85.69 113.79,85.79 113.79,85.98 113.69,86.08 113.56,86.08 113.47,86.18 113.47,86.37 113.56,86.47 113.69,86.47 113.79,86.56 113.79,86.75 113.69,86.85 113.56,86.85 113.47,86.95 113.47,87.14 113.56,87.24 113.69,87.24 113.79,87.33 113.79,87.53 113.69,87.62 113.56,87.62 113.47,87.72 113.47,87.91 113.56,88.01 113.69,88.01 113.79,88.11 113.79,88.3 113.69,88.4 113.56,88.4 113.47,88.49 113.47,88.69 113.56,88.78 113.69,88.78 113.79,88.88 113.79,89.07 113.69,89.17 113.56,89.17 113.47,89.26 113.47,89.46 113.56,89.55 113.69,89.55 113.79,89.65 113.79,89.84 113.69,89.94 113.56,89.94 113.47,90.04 113.47,90.23 113.56,90.33 113.69,90.33 113.79,90.42 113.79,90.62 113.69,90.71 113.56,90.71 113.47,90.81 113.47,91 113.56,91.1 113.69,91.1 113.79,91.19 113.79,91.39 113.69,91.48 113.56,91.48 113.47,91.58 113.47,91.79 113.6,91.93 113.74,91.93 113.88,91.79 114.02,91.79 114.17,91.94 114.17,92.07 114.02,92.21 114.02,92.35 114.14,92.47 114.28,92.47 114.42,92.33 114.56,92.33 114.69,92.46 114.69,92.6 114.55,92.74 114.55,92.88 116.19,94.52 116.19,103.35 115.01,104.53 115.01,106.19 114.92,106.28 114.72,106.28 114.63,106.19 114.63,105.3 114.53,105.21 114.33,105.21 114.24,105.3 114.24,106.19 114.14,106.28 113.95,106.28 113.85,106.19 113.85,105.46 113.75,105.37 113.57,105.37
  BOTTOM w0.127: UD7.N7 v6(108.77,105.89) ; UD8.N7 v6(98.38,105.89)
DDR_B_MA4: length 60.5
  IN1 w0.064: v2(93.19,105.83) 93.22,105.79 96.87,105.79 v6(97.18,105.49) 100,105.49 100.27,105.76 100.64,105.76 v2(100.78,105.89) 101.66,105.89 101.79,105.76 102.86,105.76 103.13,106.03 106.63,106.03 107.17,105.49 v6(107.57,105.49) 110.4,105.49 110.66,105.76 111.04,105.76 v2(111.17,105.89) 112.05,105.89 112.19,105.76 112.57,105.76 112.63,105.7 112.63,105.15 112.7,105.09 112.84,105.09 112.9,105.15 112.9,105.68 112.97,105.75 113.09,105.75 113.16,105.68 113.16,105.15 113.22,105.09 113.57,105.09
  IN1 w0.097: v6(114.07,83.17) 113.89,83.35 113.49,83.35 113,82.86 112.32,82.86 112.13,83.06 112.13,86.92 112.22,87.01 112.65,87.01 112.75,86.92 112.75,85.46 112.84,85.36 113.12,85.36 113.22,85.46 113.22,91.9 113.75,92.43 113.75,92.57 113.43,92.89 113.43,93.03 113.57,93.17 113.7,93.17 114.03,92.84 114.16,92.84 114.3,92.98 114.3,93.12 113.88,93.53 113.88,93.67 114.02,93.81 114.15,93.81 114.57,93.39 114.71,93.39 114.85,93.53 114.85,93.66 114.43,94.08 114.43,94.22 114.56,94.35 114.7,94.35 115.12,93.94 115.25,93.94 115.39,94.07 115.39,94.21 114.92,94.68 114.92,94.82 115.06,94.95 115.19,94.95 115.66,94.48 115.8,94.48 115.94,94.62 115.94,94.76 115.77,94.93 115.77,95.03 115.94,95.2 115.94,103.25 114.1,105.09 113.57,105.09
  BOTTOM w0.127: UD7.N3 v6(107.57,105.49) ; UD8.N3 v6(97.18,105.49)
DDR_B_MA5: length 72.6
  TOP w0.127: UD6.P8 97.18,106.29 v8(100.38,106.29) ; UD5.P8 107.57,106.29 v8(110.77,106.29)
  IN3 w0.064: v3(93.19,106.94) 93.91,106.94 94.69,106.16 96.13,106.16 96.27,106.03 96.53,106.03 96.8,106.29 v14(97.98,106.29) 98.11,106.16 100.24,106.16 v8(100.38,106.29) 101.6,106.29 101.87,106.56 105,106.56 105.42,106.14 106.37,106.14 106.48,106.03 106.93,106.03 107.2,106.29 v14(108.37,106.29) 108.51,106.16 110.39,106.16 110.52,106.29 v8(110.77,106.29) 110.77,106.23 110.84,106.17 111.08,106.17 111.14,106.23 111.14,106.57 111.21,106.63 111.33,106.63 111.4,106.57 111.4,106.23 111.46,106.17 111.6,106.17 111.69,106.25 111.79,106.25 111.88,106.17 112.01,106.17 112.1,106.25 112.1,106.39 112.26,106.56 112.61,106.56 112.68,106.49 112.68,106.23 112.75,106.17 112.94,106.17 113,106.23 113,106.49 113.07,106.56 113.19,106.56 113.25,106.49 113.25,106.25 113.32,106.19 113.52,106.19 113.57,106.14
  IN3 w0.097: v14(112.07,83.5) 112.09,83.52 112.09,83.66 112,83.76 111.76,83.76 111.67,83.85 111.67,84.06 111.76,84.16 112.09,84.16 112.18,84.25 112.18,84.5 112.09,84.6 111.7,84.6 111.6,84.7 111.6,84.99 111.48,85.11 111.17,85.11 111.03,85.24 111.03,85.38 111.51,85.86 111.51,86.59 111.42,86.69 111.13,86.69 111.03,86.59 111.03,85.97 110.94,85.87 110.67,85.87 110.58,85.97 110.58,88.37 110.36,88.6 110.36,88.89 110.45,88.99 110.99,88.99 111.09,89.08 111.09,89.56 115.62,94.09 115.62,104.09 113.57,106.14
  BOTTOM w0.127: UD7.P8 111.57,106.29 v14(108.37,106.29) ; UD8.P8 101.18,106.29 v14(97.98,106.29) ; UC1.CA6 114.65,82.86 112.2,82.86 112.07,82.99 v14(112.07,83.5)
DDR_B_MA6: length 62.3
  IN1 w0.064: v2(93.19,107.5) 94.09,107.5 94.37,107.23 96.67,107.23 96.8,107.09 v14(97.18,107.09) 99.2,107.09 99.47,106.83 99.71,106.83 99.84,106.96 100.86,106.96 101.13,106.69 v12(101.58,106.69) 101.71,106.83 107.31,106.83 v14(107.57,107.09) 109.6,107.09 109.86,106.83 110.1,106.83 110.23,106.96 111.26,106.96 111.52,106.69 v12(111.97,106.69) 111.97,107.4 112.04,107.46 112.24,107.46 112.3,107.4 112.3,106.78 112.37,106.72 112.59,106.72 112.66,106.78 112.66,107.57 112.72,107.63 113.27,107.63 113.32,107.58 113.32,107.42 113.26,107.35 112.98,107.35 112.91,107.29 112.91,106.88 112.98,106.81 113.57,106.81
  IN1 w0.097: 113.57,106.81 113.63,106.81 113.72,106.91 113.72,108.43 113.82,108.53 114.02,108.53 114.12,108.43 114.12,106.88 114.21,106.78 114.41,106.78 114.5,106.88 114.5,108.11 114.6,108.21 115.91,108.21 116.27,107.85 116.27,103.97 116.69,103.56 116.69,94.29 115.46,93.07 115.46,92.52 114.29,91.35 114.29,85.06 113.81,84.58 113.81,84.22 113.9,84.13 114.29,84.13 114.38,84.03 114.38,83.38 114.48,83.29 114.68,83.29 114.78,83.19 114.78,83 114.68,82.9 114.48,82.9 114.38,82.8 114.38,82.61 114.48,82.51 v6(115.46,82.51)
  BOTTOM w0.127: UD8.P2 v14(97.18,107.09) ; UD7.P2 v14(107.57,107.09)
DDR_B_MA7: length 74.9
  TOP w0.127: UD6.R8 97.18,107.89 v8(100.38,107.89) ; v8(110.77,107.89) 107.57,107.89 UD5.R8
  IN3 w0.064: 113.57,108.42 112.24,108.42 111.97,108.16 111.04,108.16 v8(110.77,107.89) 110.56,108.1 108.58,108.1 v14(108.37,107.89) 107.99,107.89 107.71,108.17 107.36,108.17 107.21,108.03 106.02,108.03 105.66,108.39 101.64,108.39 101.41,108.16 100.64,108.16 v8(100.38,107.89) 100.11,107.89 99.92,108.08 98.17,108.08 v14(97.98,107.89) 97.6,107.89 97.31,108.17 96.91,108.17 96.75,108.01 95.83,108.01 95.07,108.77 93.82,108.77 93.6,108.54 92.07,108.54 v3(92.04,108.57)
  IN3 w0.097: 113.57,108.42 114.22,108.42 116.37,106.28 116.37,93.73 112.13,89.5 112.13,86.29 112.36,86.06 112.57,86.06 112.78,85.85 112.78,85.49 113.71,84.56 113.71,84.19 113.62,84.1 113.48,84.1 113.38,84 113.38,83.81 113.48,83.71 113.71,83.71 113.81,83.62 113.81,83.36 113.71,83.27 113.54,83.27 113.44,83.17 113.44,82.92 113.54,82.82 113.94,82.82 114.04,82.73 114.04,82.54 113.79,82.29 113.79,82.08 114.01,81.85 114.18,81.85 114.38,81.66 114.38,81.41 114.16,81.19 113.99,81.19 113.76,80.96 113.76,80.81 113.95,80.62 114.31,80.62 114.4,80.54 114.4,80.28 114.35,80.23 v3(114.09,80.23)
  BOTTOM w0.127: UC1.CB10 115.14,80.23 v3(114.09,80.23) ; v14(97.98,107.89) 101.18,107.89 UD8.R8 ; v14(108.37,107.89) 111.57,107.89 UD7.R8
DDR_B_MA8: length 63.7
  TOP w0.127: UD6.R2 v8(101.18,107.89) ; UD5.R2 v8(111.57,107.89)
  IN3 w0.064: v3(93.19,108.25) 93.64,108.25 93.9,108.51 94.89,108.51 95.65,107.76 96.09,107.76 96.35,107.49 v14(96.78,107.49) 96.91,107.63 98.09,107.63 98.22,107.76 99.8,107.76 99.93,107.63 100.55,107.63 100.81,107.89 v8(101.18,107.89) 101.59,107.89 101.86,108.16 105.07,108.16 105.48,107.76 106.91,107.76 v14(107.17,107.49) 107.31,107.63 108.48,107.63 108.61,107.76 110.2,107.76 110.33,107.63 110.94,107.63 111.21,107.89 v8(111.57,107.89) 112.18,107.89 112.24,107.96 112.24,108.19 112.3,108.26 112.52,108.26 112.59,108.19 112.59,107.62 112.65,107.55 112.78,107.55 112.84,107.62 112.84,108.12 112.9,108.18 113.45,108.18 113.51,108.12 113.51,107.98 113.57,107.91
  IN3 w0.097: v3(114.09,81.54) 113.59,81.54 113.25,81.2 113.11,81.2 112.84,81.47 112.84,81.6 112.99,81.75 112.99,81.9 113.08,82 113.32,82 113.42,82.09 113.42,82.35 113.32,82.44 113.04,82.44 112.95,82.54 112.95,82.91 113.04,83.01 113.16,83.01 113.26,83.1 113.26,83.62 112.95,83.92 112.95,84.16 113.07,84.27 113.07,84.66 112.95,84.78 112.95,84.99 112.71,85.23 112.71,85.25 112.57,85.39 111.98,85.39 111.88,85.48 111.88,85.71 112.05,85.87 112.05,86.12 111.88,86.28 111.88,89.6 116.12,93.83 116.12,104.95 116.02,105.05 115.47,105.05 115.37,105.14 115.37,105.34 115.47,105.43 116.02,105.43 116.12,105.53 116.12,106.12 116.01,106.23 115.71,106.23 115.54,106.06 115.4,106.06 115.18,106.28 115.18,106.42 115.46,106.7 115.46,106.83 115.32,106.97 115.19,106.97 114.9,106.69 114.77,106.69 114.63,106.83 114.63,106.96 114.91,107.24 114.91,107.38 114.78,107.52 114.64,107.52 114.36,107.23 114.22,107.23 114.09,107.37 114.09,107.51 114.37,107.79 114.37,107.93 114.23,108.06 114.09,108.06 113.83,107.8 113.69,107.8 113.57,107.91
  BOTTOM w0.127: v3(114.09,81.54) 115.14,81.54 UC1.CB8
DDR_B_MA9: length 70.1
  TOP w0.127: UD6.R7 v12(99.98,107.49) ; UD5.R7 v12(110.37,107.49)
  IN1 w0.064: v2(93.19,108.06) 93.41,108.06 93.72,107.76 94.1,107.76 94.21,107.65 94.94,107.65 95.05,107.76 96.82,107.76 97.09,107.49 v14(98.38,107.49) v12(99.98,107.49) 100.24,107.23 100.92,107.23 101.06,107.37 101.53,107.37 101.77,107.13 102.43,107.13 102.67,107.36 103.06,107.36 103.19,107.23 107.32,107.23 107.46,107.36 108.64,107.36 v14(108.77,107.49) v12(110.37,107.49) 110.64,107.23 111.31,107.23 111.48,107.4 111.73,107.4 111.97,107.63 112.49,107.63 112.65,107.8 112.85,107.8 112.91,107.86 112.91,108.06 112.85,108.12 112.49,108.12 112.43,108.19 112.43,108.31 112.49,108.38 112.85,108.38 112.91,108.44 112.91,108.73 112.96,108.78 113.12,108.78 113.19,108.71 113.19,108.2 113.25,108.14 113.38,108.14 113.44,108.2 113.44,108.71 113.51,108.78 113.57,108.78
  IN1 w0.097: v6(116.84,82.19) 116.86,82.21 116.86,82.35 116.76,82.44 116.66,82.44 116.56,82.54 116.56,82.85 116.47,82.95 116.27,82.95 116.18,82.85 116.18,82.54 116.08,82.44 115.82,82.44 115.73,82.54 115.73,82.85 115.63,82.95 115.16,82.95 115.09,83.02 115.09,83.42 114.99,83.52 114.74,83.52 114.65,83.62 114.65,84.3 114.48,84.47 114.48,86.57 114.54,86.63 114.54,91.25 115.71,92.42 115.71,92.96 116.93,94.19 116.93,103.66 116.52,104.08 116.52,107.95 116.01,108.46 114.44,108.46 114.13,108.78 113.57,108.78
  BOTTOM w0.127: UC1.CE11 117.63,80.24 117.63,81.96 117.4,82.19 v6(116.84,82.19) ; UD8.R7 v14(98.38,107.49) ; UD7.R7 v14(108.77,107.49)
DDR_B_MA10: length 63.1
  TOP w0.127: UD6.M3 v8(101.18,105.49) ; UD5.M3 v8(111.57,105.49)
  IN3 w0.061: v3(111.81,82.51) 111.87,82.45 111.87,82.35 111.81,82.29 111.59,82.29 111.5,82.38 111.5,82.67 111.43,82.74 111.24,82.74 111.13,82.86 111.13,83.51 111.06,83.57 110.9,83.57 110.74,83.42 110.54,83.42 110.48,83.48 110.48,84.01 110.54,84.07 111.07,84.07 111.13,84.13 111.13,84.39 110.99,84.53 110.84,84.53 110.78,84.46 110.78,84.37 110.72,84.31 110.24,84.31 110.18,84.37 110.18,84.56 110.28,84.66 110.53,84.66 110.62,84.76 110.62,84.82 110.61,84.84 110.61,84.88
  IN3 w0.064: v3(93.19,105.83) 93.63,105.83 94.27,105.19 95.53,105.19 95.7,105.36 96.66,105.36 96.79,105.23 97.44,105.23 v14(97.58,105.09) 97.99,105.09 98.26,104.83 98.53,104.83 98.66,104.96 100.64,104.96 v8(101.18,105.49) 101.56,105.49 101.88,105.17 105.96,105.17 106.14,105.36 107.04,105.36 107.17,105.23 107.84,105.23 v14(107.97,105.09) 108.39,105.09 108.65,104.83 108.92,104.83 109.06,104.96 111.04,104.96 v8(111.57,105.49) 111.7,105.62 111.9,105.62 111.97,105.54 111.97,105.42 111.74,105.18 111.74,105.09 111.83,105 112.15,105 112.24,105.08 112.24,105.16 112.31,105.23 112.46,105.23 112.52,105.17 112.52,105.07 112.59,105.01 112.71,105.01 112.78,105.07 112.78,105.56 112.84,105.62 112.97,105.62 113.03,105.56 113.03,105.08 113.1,105.02 113.22,105.02 113.29,105.08 113.29,105.09 113.35,105.15 113.44,105.15 113.57,105.02
  IN3 w0.097: 110.61,84.88 110.41,85.08 110.27,85.08 110.04,84.86 109.94,84.86 109.61,84.52 109.47,84.52 109.17,84.82 109.17,85.27 109.27,85.37 109.6,85.37 109.69,85.47 109.69,85.66 109.6,85.76 109.27,85.76 109.17,85.85 109.17,86.05 109.27,86.14 109.57,86.14 109.67,86.24 109.67,86.47 109.57,86.56 109.27,86.56 109.17,86.66 109.17,86.85 109.27,86.95 109.93,86.95 110.02,87.05 110.02,87.24 109.93,87.34 109.27,87.34 109.17,87.43 109.17,87.63 109.27,87.72 109.93,87.72 110.02,87.82 110.02,88.05 109.93,88.14 109.84,88.14 109.75,88.24 109.75,89.27 114.87,94.4 114.87,101.39 114.78,101.49 114.32,101.49 114.22,101.59 114.22,101.78 114.32,101.88 114.78,101.88 114.87,101.97 114.87,102.17 114.78,102.26 114.32,102.26 114.22,102.36 114.22,102.55 114.32,102.65 114.45,102.65 114.55,102.74 114.55,102.94 114.45,103.03 114.32,103.03 114.22,103.13 114.22,103.32 114.32,103.42 114.78,103.42 114.87,103.52 114.87,103.71 114.56,104.03 114.33,104.03 114.22,104.14 114.22,104.36 113.57,105.02
DDR_B_MA11: length 64.3
  IN1 w0.064: 113.57,109.27 110.02,109.27 109.92,109.18 109.92,108.64 109.98,108.57 110.16,108.57 110.22,108.64 110.22,108.87 110.32,108.97 111.08,108.97 111.16,108.89 111.16,108.48 111.22,108.41 111.85,108.41 v2(111.97,108.29) 111.9,108.22 110.91,108.22 110.84,108.29 108.56,108.29 108.16,108.69 v6(107.57,108.69) 107.27,108.69 107.14,108.56 105.36,108.56 105.1,108.29 v2(101.58,108.29) 101.44,108.43 98.03,108.43 97.76,108.69 v6(97.18,108.69) 97.14,108.66 93.23,108.66 v2(93.19,108.62)
  IN1 w0.097: v6(116.84,81.54) 117.2,81.9 117.2,82.76 117.06,82.89 116.82,82.89 116.21,83.51 115.78,83.51 115.58,83.71 115.58,86.02 115.24,86.36 115.24,86.52 115.03,86.72 115.03,91.04 116.2,92.21 116.2,92.76 117.43,93.98 117.43,104.73 117.38,104.78 117.08,104.78 117.02,104.85 117.02,105.19 117.16,105.34 117.34,105.34 117.43,105.43 117.43,107.02 117.31,107.14 117.11,107.14 117.02,107.24 117.02,108.17 116.32,108.87 116.32,109.18 116.22,109.27 113.57,109.27
  BOTTOM w0.127: UC1.CB11 115.78,80.23 116.48,80.23 116.84,80.59 v6(116.84,81.54) ; UD7.T2 v6(107.57,108.69) ; UD8.T2 v6(97.18,108.69)
DDR_B_MA12: length 73.2
  TOP w0.127: UD6.M7 v12(99.98,105.09) ; UD5.M7 v12(110.37,105.09)
  IN1 w0.064: v2(92.04,105.92) 92.42,105.53 95.16,105.53 95.47,105.23 98.24,105.23 v14(98.38,105.09) v12(99.98,105.09) 100.11,105.23 101.34,105.23 101.47,105.36 101.69,105.36 101.82,105.23 102.7,105.23 103.25,105.77 106.11,105.77 106.66,105.23 108.64,105.23 v14(108.77,105.09) v12(110.37,105.09) 110.51,105.23 111.73,105.23 111.86,105.36 112.14,105.36 112.3,105.19 112.3,105 112.46,104.84 113.57,104.84
  IN1 w0.097: 113.57,104.84 113.99,104.84 115.68,103.15 115.68,95.3 115.59,95.2 114.63,95.2 114.54,95.1 114.54,94.68 113.18,93.32 113.18,92.77 112.97,92.56 112.97,88.13 111.67,86.83 111.67,83.43 111.82,83.28 111.82,82.86 112.07,82.61 113.2,82.61 113.46,82.87 113.65,82.87 114.29,82.23 116.41,82.23 116.69,81.95 116.69,81.78 116.5,81.6 116.5,81.46 116.64,81.32 116.64,81.08 116.74,80.98 116.93,80.98 117.03,81.08 117.03,81.35 117.5,81.82 117.5,82.83 117.57,82.91 118.76,82.91 118.86,82.81 118.86,81.93 118.76,81.83 118.56,81.83 118.46,81.93 118.46,82.35 118.37,82.44 118.04,82.44 117.94,82.35 117.94,81.61 117.69,81.35 117.69,80.49 117.59,80.39 117.39,80.39 117.29,80.49 v6(117.29,80.56)
  BOTTOM w0.127: UD8.M7 v14(98.38,105.09) ; UD7.M7 v14(108.77,105.09)
DDR_B_MA13: length 73.2
  TOP w0.127: v8(100.38,108.69) 97.18,108.69 UD6.T8 ; v8(110.77,108.69) 107.57,108.69 UD5.T8
  IN3 w0.064: v3(93.19,109.37) 93.39,109.18 95.37,109.18 95.58,108.96 97.4,108.96 97.67,108.69 v14(97.98,108.69) v8(100.38,108.69) 100.64,108.69 100.91,108.96 107.8,108.96 108.06,108.69 v14(108.37,108.69) v8(110.77,108.69) 111.04,108.69 111.3,108.95 113.57,108.95
  IN3 w0.097: 113.57,108.95 114.4,108.95 116.86,106.48 116.86,93.52 113.02,89.68 113.02,86.55 113.13,86.44 113.13,86.11 114.61,84.63 114.61,82.85 114.81,82.65 114.81,81.09 114.61,80.89 v3(114.09,80.89)
  BOTTOM w0.127: v14(97.98,108.69) 101.18,108.69 UD8.T8 ; v14(108.37,108.69) 111.57,108.69 UD7.T8 ; UC1.BP9 110.3,80.89 v3(114.09,80.89)
DDR_B_MA14: length 64
  TOP w0.127: UD6.L2 v8(101.18,104.69) ; UD5.L2 v8(111.57,104.69)
  IN3 w0.061: 112.05,80.71 112.05,80.53 112.11,80.47 112.69,80.47 112.75,80.41 112.75,80.28 112.69,80.22 111.35,80.22 111.29,80.16 111.29,79.97 111.35,79.91 v3(111.81,79.91)
  IN3 w0.064: v3(93.19,104.71) 93.33,104.57 96.5,104.57 v14(96.78,104.29) 96.91,104.43 97.39,104.43 97.62,104.2 98.09,104.2 98.26,104.03 98.27,104.03 98.86,104.03 99.24,104.41 100.9,104.41 v8(101.18,104.69) 101.45,104.42 107.04,104.42 v14(107.17,104.29) 107.31,104.43 107.79,104.43 108.01,104.2 108.49,104.2 108.66,104.03 110.52,104.03 110.91,104.41 111.29,104.41 v8(111.57,104.69) 111.57,104.69 112.07,104.69 112.13,104.63 112.13,103.08 112.2,103.02 112.32,103.02 112.39,103.08 112.39,104.63 112.45,104.69 112.58,104.69 112.64,104.63 112.64,103.84 112.71,103.78 112.83,103.78 112.9,103.84 112.9,104.64 112.96,104.7 113.09,104.7 113.14,104.65 113.14,104.27 113.26,104.16 113.54,104.16 113.57,104.12
  IN3 w0.097: 112.05,80.71 111.92,80.84 111.26,80.84 111.16,80.94 111.16,82 110.95,82.21 110.6,82.21 110.5,82.12 110.5,81.48 110.4,81.39 110.19,81.39 110.09,81.48 110.09,82.93 110.21,83.05 110.21,83.29 110.11,83.39 110.08,83.39 110.04,83.43 109.91,83.43 109.53,83.82 109.53,83.94 108.8,84.67 108.8,87.88 109.38,88.45 109.38,89.61 113.73,93.96 113.73,94.33 113.82,94.43 114.2,94.43 114.29,94.53 114.29,94.72 114.2,94.81 113.82,94.81 113.73,94.91 113.73,95.1 113.82,95.2 114.28,95.2 114.38,95.3 114.38,95.49 114.28,95.59 113.82,95.59 113.73,95.68 113.73,95.88 113.82,95.97 114.28,95.97 114.38,96.07 114.38,96.26 114.28,96.36 113.82,96.36 113.73,96.46 113.73,103.97 113.57,104.12
DDR_B_MA15: length 71.8
  TOP w0.127: UD5.M8 107.57,104.69 v8(110.77,104.69) ; UD6.M8 97.18,104.69 v8(100.38,104.69)
  IN3 w0.061: 110.27,83.9 110.27,83.51 110.34,83.44 110.34,83.42 110.36,83.4 110.36,83.39 110.46,83.29 110.46,83.18 110.82,82.82 110.95,82.82 111.35,82.42 v3(111.35,82.19)
  IN3 w0.064: 113.57,104.66 113.38,104.86 111.78,104.86 111.68,104.96 111.46,104.96 111.2,104.69 v8(110.77,104.69) 110.45,104.69 110.39,104.63 110.39,104.26 110.32,104.19 110.2,104.19 110.13,104.26 110.13,104.63 110.07,104.69 109.94,104.69 109.88,104.63 109.88,104.26 109.81,104.19 109.69,104.19 109.62,104.26 109.62,104.63 109.56,104.69 v14(109.17,104.69) 109.04,104.56 108.66,104.56 108.51,104.4 108.22,104.4 107.89,104.73 107.89,104.75 107.68,104.96 107.31,104.96 107.04,104.69 106.05,104.69 105.79,104.96 101.07,104.96 100.8,104.69 v8(100.38,104.69) v14(98.78,104.69) 98.64,104.56 98.27,104.56 98.11,104.4 97.88,104.4 97.32,104.96 97.07,104.96 96.94,104.83 93.98,104.83 93.54,105.27 v3(93.19,105.27)
  IN3 w0.097: 110.27,83.9 109.97,84.21 109.52,84.21 108.99,84.74 108.99,87.8 109.56,88.37 109.56,89.44 114.62,94.5 114.62,96.51 114.53,96.61 114.07,96.61 113.98,96.7 113.98,96.9 114.07,96.99 114.53,96.99 114.62,97.09 114.62,97.28 114.53,97.38 114.07,97.38 113.98,97.48 113.98,97.67 114.07,97.77 114.53,97.77 114.62,97.86 114.62,98.06 114.53,98.15 114.07,98.15 113.98,98.25 113.98,98.44 114.07,98.54 114.53,98.54 114.62,98.63 114.62,98.83 114.53,98.92 114.07,98.92 113.98,99.02 113.98,99.21 114.07,99.31 114.53,99.31 114.62,99.41 114.62,99.6 114.53,99.7 114.07,99.7 113.98,99.79 113.98,99.99 114.07,100.08 114.53,100.08 114.62,100.18 114.62,100.37 114.53,100.47 114.07,100.47 113.98,100.57 113.98,100.76 114.07,100.85 114.53,100.85 114.62,100.95 114.62,101.14 114.53,101.24 114.07,101.24 113.98,101.34 113.98,104.26 113.57,104.66
  BOTTOM w0.127: UC1.BP8 110.38,81.86 110.7,82.19 v3(111.35,82.19) ; UD8.M8 101.18,104.69 v14(98.78,104.69) ; v14(109.17,104.69) 111.57,104.69 UD7.M8
DDR_B_MA16: length 73.6
  TOP w0.127: UD5.L8 107.57,103.89 v8(110.77,103.89) ; v8(100.38,103.89) 97.18,103.89 UD6.L8
  IN3 w0.061: v3(111.81,80.56) 111.25,80.56 110.93,80.88 110.31,80.88
  IN3 w0.064: v3(93.19,104.15) 95.46,104.15 95.47,104.16 96.53,104.16 96.7,103.98 96.89,103.98 97.07,104.16 97.29,104.16 97.55,103.89 v14(97.98,103.89) 98.04,103.83 99.23,103.83 99.29,103.89 v8(100.38,103.89) 100.64,104.16 106.88,104.16 107.03,104.01 107.27,104.01 107.41,104.16 107.68,104.16 107.95,103.89 v14(108.37,103.89) 108.55,103.71 110.59,103.71 v8(110.77,103.89) 111.04,104.16 111.59,104.16 111.65,104.22 111.65,104.41 111.72,104.48 111.86,104.48 111.92,104.41 111.92,102.83 111.99,102.76 112.61,102.76 112.68,102.83 112.68,103.17 112.74,103.23 112.87,103.23 112.93,103.17 112.93,102.83 113,102.76 113.13,102.76 113.19,102.83 113.19,103.58 113.26,103.64 113.41,103.64 113.48,103.58 113.48,102.57
  IN3 w0.097: 113.48,102.57 113.48,101.15 113.38,101.05 112.65,101.05 112.55,100.95 112.55,100.76 112.65,100.66 113.38,100.66 113.48,100.57 113.48,100.38 113.38,100.28 112.65,100.28 112.55,100.18 112.55,99.99 112.65,99.89 113.38,99.89 113.48,99.8 113.48,99.18 113.38,99.08 112.65,99.08 112.55,98.98 112.55,98.79 112.65,98.69 113.38,98.69 113.48,98.6 113.48,94.06 109.19,89.77 109.19,88.53 108.61,87.95 108.61,84.84 108.51,84.73 108.21,84.73 108.11,84.63 108.11,84.37 108.21,84.27 108.86,84.27 108.96,84.17 108.96,83.99 108.86,83.89 108.64,83.89 108.56,83.81 108.56,83.56 108.63,83.5 109.29,83.5 109.38,83.4 109.38,82.92 109.48,82.82 109.65,82.82 109.81,82.66 109.81,81.37 110.31,80.88
  BOTTOM w0.127: UD7.L8 111.57,103.89 v14(108.37,103.89) ; v14(97.98,103.89) 101.18,103.89 UD8.L8
DDR_B_ODT0: length 55.7
  TOP w0.127: UD6.K3 v8(101.18,103.89) ; UD5.K3 v8(111.57,103.89)
  IN3 w0.064: v3(93.19,103.59) 93.53,103.26 96.87,103.26 97.11,103.49 v14(97.58,103.49) 98.3,103.49 98.37,103.43 98.37,103.21 98.43,103.14 98.56,103.14 98.62,103.21 98.62,103.43 98.69,103.49 98.81,103.49 98.88,103.43 98.88,103.21 98.94,103.14 99.07,103.14 99.13,103.21 99.13,103.43 99.19,103.49 100.4,103.49 100.8,103.89 v8(101.18,103.89) 101.31,103.76 102.49,103.76 102.89,103.36 103.71,103.36 103.78,103.42 103.78,103.84 103.84,103.9 103.97,103.9 104.03,103.84 104.03,103.42 104.09,103.36 105.77,103.36 106.02,103.6 107.66,103.6 107.77,103.49 v14(107.97,103.49) 110.8,103.49 111.2,103.89 v8(111.57,103.89) 111.72,103.75 111.72,103.57 111.65,103.51 111.46,103.51 111.4,103.45 111.4,103.32 111.46,103.25 111.65,103.25 111.72,103.19 111.72,102.63 111.78,102.57 113.16,102.57
  IN3 w0.097: v3(109.55,82.55) 109.55,82.04 109.45,81.95 109.24,81.95 109.14,82.04 109.14,82.72 109.04,82.82 108.72,82.82 108.62,82.91 108.62,83.23 108.42,83.43 107.95,83.43 107.86,83.53 107.86,84.9 107.95,85 108.33,85 108.43,85.09 108.43,85.29 108.33,85.38 107.88,85.38 107.78,85.48 107.78,85.67 107.88,85.77 108.33,85.77 108.43,85.87 108.43,86.06 108.33,86.16 107.88,86.16 107.78,86.25 107.78,86.44 107.88,86.54 108.33,86.54 108.43,86.64 108.43,86.83 108.33,86.93 107.89,86.93 107.79,87.02 107.79,87.22 107.89,87.32 108.33,87.32 108.43,87.41 108.43,88.03 108.76,88.36 108.94,88.54 108.94,89.89 113.23,94.18 113.23,98.15 113.06,98.32 112.56,98.32 112.3,98.57 112.3,101.21 112.71,101.61 113.13,101.61 113.23,101.71 113.23,102.51 113.16,102.57
  BOTTOM w0.076: UC1.BP7 v3(109.55,82.55)
DDR_B_PARITY: length 54.7
  TOP w0.127: UD6.T3 v8(101.18,108.69) ; UD5.T3 v8(111.57,108.69)
  IN3 w0.064: v3(93.19,108.81) 93.38,109 95.2,109 95.57,108.62 96.87,108.62 97.07,108.43 97.44,108.43 v14(97.58,108.29) 97.71,108.43 100.91,108.43 v8(101.18,108.69) 107.2,108.69 107.46,108.43 107.84,108.43 v14(107.97,108.29) 108.11,108.43 111.31,108.43 v8(111.57,108.69) 113.57,108.69
  IN3 w0.097: v3(114.09,82.19) 114.23,82.32 114.23,82.85 114.38,83 114.38,84.53 114.34,84.58 114.34,84.58 114.18,84.74 114.18,84.74 112.89,86.03 112.89,86.4 112.52,86.77 112.52,89.53 116.62,93.63 116.62,106.38 114.3,108.69 113.57,108.69
  BOTTOM w0.127: UC1.BV7 113.05,82.19 v3(114.09,82.19)
DDR_CHA_EN: length 9
  TOP w0.127: v7(25.13,54.03) v1(25.98,53.18) 28.25,53.18 29.88,51.56 RH66.1 30.86,51.55 RH68.1
  GND2 w0.102: v7(25.13,54.03) 25.13,54.34 v5(25.24,54.45)
  GND3 w0.102: v6(25.56,54.37) 25.48,54.45 v5(25.24,54.45)
  BOTTOM w0.076: UH4.BE39 25.78,54.37 v6(25.56,54.37)
DDR_CHB_EN: length 6.5
  TOP w0.127: v7(26.56,53.52) v1(27.72,53.52) 28.58,53.52 29.23,52.88 RH69.1 30.34,52.88 RH67.1
  GND2 w0.102: v7(26.56,53.52) 26.29,53.52 v5(25.8,54.01)
  GND3 w0.102: v5(25.8,54.01) 25.89,53.92 v6(26.16,53.92)
  BOTTOM w0.076: v6(26.16,53.92) 26.28,53.8 UH4.BD38
DDR_DRAMRST#: length 5.8
  TOP w0.127: v1(24.36,40.09) 24.36,41.05 RC33.1 v7(24.91,42.5)
  GND2 w0.102: v7(24.91,42.5) 24.69,42.5 v5(24.56,42.37)
  GND3 w0.102: v5(24.56,42.37) 24.56,42.31 v6(24.84,42.03)
  BOTTOM w0.076: UH4.BC14 26.86,41.72 26.59,41.99 26.42,41.99 26.4,41.97 26.13,41.97 26.02,42.08 24.89,42.08 v6(24.84,42.03)
DDR_DRAMRST#_R: length 181.8
  TOP w0.127: v2(27.07,41.82) 26.87,41.61 RC33.2 25.79,41.57 CC139.1 25.79,40.75 v1(26.58,39.96) ; UD2.P1 v7(128.67,107.09) ; UD6.P1 v7(102.78,107.09) ; CD111.2 140.74,109.54 140.27,109.07 140.27,108.29 v7(139.07,107.09) UD1.P1 ; v9(117.73,107.3) 117.52,107.3 116.53,106.3 CD112.2 114.06,107.09 v7(113.17,107.09) UD5.P1
  IN1 w0.064: v4(91.21,106.51) 90.83,106.89 79.9,106.89 78.3,105.29 78.3,98.75 76.47,96.92 73.08,96.92 71.23,95.07 69.56,95.07 69.13,94.65 67.87,94.65 67,95.52 63.23,95.52 62.32,96.43 56.49,96.43 56.49,96.42 53.46,96.42 50.24,93.2 50.24,92.56 49.22,91.55 48.33,91.55 46.35,89.56 46.35,87.68 46.6,87.43 46.6,85.14 45.94,84.48 45.94,71.86 43.06,68.98 43.06,64.22 41.22,62.38 41.22,61.86 37.65,58.29 37.36,58.29 33.74,54.67 32.83,54.67 31.4,53.24 31.4,52.72 31.05,52.37 30.43,52.37 29.92,51.86 29.92,51.05 29.56,50.69 29.29,50.69 28.86,50.27 28.86,49.52 28.35,49 28.35,48.03 27.91,47.59 27.91,47.1 28.34,46.67 28.34,45.37 27.84,44.87 27.84,43.67 27.5,43.33 27.5,42.7 27.3,42.5 27.3,42.14 27.07,41.91 v2(27.07,41.82)
  GND2 w0.102: v5(91.54,106.53) 91.51,106.51 v4(91.21,106.51) ; v7(102.78,107.09) v5(103.13,107.09) ; v7(113.17,107.09) 113.24,107.09 113.42,107.27 v5(113.42,107.33) ; v7(139.07,107.09) v5(138.71,107.09) ; v7(128.67,107.09) v5(129.02,107.09)
  GND3 w0.102: v8(138.34,107.09) v5(138.71,107.09) ; v8(91.82,106.76) 91.59,106.53 v5(91.54,106.53) ; v5(129.02,107.09) v8(128.67,107.09) ; v5(103.13,107.09) v8(102.78,107.09) ; v5(113.42,107.33) v8(113.18,107.09)
  IN3 w0.064: v14(121.87,106.69) 121.94,106.76 123.12,106.76 123.31,106.96 123.6,106.96 123.75,106.8 123.99,106.8 124.15,106.96 124.38,106.96 124.54,106.8 126.41,106.8 126.96,107.36 127.32,107.36 127.59,107.09 v8(128.67,107.09) 130.97,107.09 131.37,106.69 v14(132.27,106.69) 132.4,106.83 133.59,106.83 133.72,106.96 133.99,106.96 134.15,106.8 134.39,106.8 134.55,106.96 134.78,106.96 134.94,106.8 136.76,106.8 137.32,107.36 137.72,107.36 137.98,107.09 v8(138.34,107.09) ; v8(91.82,106.76) 91.82,106.79 91.97,106.94 92.1,106.94 92.95,107.79 93.94,107.79 95.04,106.69 v14(95.98,106.69) 96.08,106.8 97.29,106.8 97.45,106.96 97.7,106.96 97.86,106.8 98.1,106.8 98.25,106.96 98.49,106.96 98.64,106.8 100.51,106.8 101.07,107.36 101.43,107.36 101.69,107.09 v8(102.78,107.09) 105.07,107.09 105.48,106.69 v3(106.37,106.69) 106.51,106.83 107.69,106.83 107.82,106.96 108.09,106.96 108.25,106.8 108.49,106.8 108.65,106.96 109.72,106.96 109.88,106.8 110.91,106.8 111.46,107.36 112.02,107.36 112.14,107.24 113.03,107.24 v8(113.18,107.09)
  BOTTOM w0.127: v14(121.87,106.69) 121.56,106.38 CD113.2 119.38,106.94 118.08,106.94 v9(117.73,107.3) ; CD114.1 95.92,106.64 v14(95.98,106.69)
DDR_VTT_PG_CTRL: length 93.4
  TOP w0.127: v7(133.89,79.03) 133.68,79.24 133.68,80.73 128.72,85.68 v1(93.76,85.68) 79.93,85.68 v7(79.02,84.77)
  GND2 w0.102: v7(79.02,84.77) 78.86,84.77 v5(78.69,84.59) ; v5(133.89,78.61) v7(133.89,79.03)
  GND3 w0.102: v8(78.58,84.94) 78.69,84.84 v5(78.69,84.59) ; v6(134.03,78.21) 134.03,78.47 v5(133.89,78.61)
  IN3 w0.064: v8(78.58,84.94) 77.64,85.88 77.64,87.13 72.69,92.08 72.69,95.54 77.07,99.91 77.07,101.36 78.31,102.6 78.31,103.47 78.74,103.89 v3(78.74,105.37)
  BOTTOM w0.076: v6(134.03,78.21) 133.85,78.4 UC1.DH13
  BOTTOM w0.127: UC6.2 78.28,110.06 78,109.78 78,109 78.74,108.26 v3(78.74,105.37)
DEBUG_TX: length 2.6
  TOP w0.127: v7(48.83,5.35) RE203.2 48.08,4.62 v1(47.93,4.46)
  GND2 w0.102: v5(48.39,5.04) 48.7,5.35 v7(48.83,5.35)
  GND3 w0.102: v6(48.39,4.71) v5(48.39,5.04)
DGPU_HOLD_RST#: length 66.9
  TOP w0.127: v7(32.38,57.92) 32.38,58.67 31.93,59.12 RH657.1 RH658.1 ; v2(51.89,29.35) 51.91,29.32 51.91,28.38 51.71,28.17 51.71,25.36 52.28,24.78 52.28,23.4 v1(52.42,23.26) 52.61,23.07 UV14.2
  IN1 w0.064: v7(32.38,57.92) 32.15,58.15 31.02,58.15 30.4,57.52 30.4,55.56 29.03,54.19 29.03,53.16 26.35,50.48 26.35,48.53 26.56,48.31 26.56,47.41 26.09,46.94 26.09,42.39 25.21,41.52 25.21,38.24 26.03,37.42 26.03,37.2 27.54,35.7 28.61,35.7 31.82,32.48 38.05,32.48 41.04,29.49 47.11,29.49 47.45,29.83 51.4,29.83 v2(51.89,29.35)
  GND2 w0.102: v7(32.38,57.92) 32.38,58.03 32.18,58.23 v5(32.18,58.35)
  GND3 w0.102: v5(32.18,58.35) 32.46,58.35 v6(32.54,58.43)
  BOTTOM w0.076: UH4.AL44 32.55,58.43 v6(32.54,58.43)
DGPU_PWR_EN: length 133.1
  TOP w0.127: v7(66.01,83.99) 66.37,83.64 R5840.1 67.38,82.96 DV14.2 ; UZ22.2 61.19,21.74 61.06,21.61 61.06,19.96 61.7,19.31 DV15.1 61.7,18.29 61.76,18.24 61.76,17.74 61.54,17.52 59.5,17.52 v2(59.34,17.67) ; v7(34.59,53.27) 34.26,52.94 34.26,51.8 RH179.1 RH181.1 34.6,50.72 34.92,50.4 v2(35.58,50.4) ; v2(43.78,61.04) 43.49,61.34 43.49,68.64 43.96,69.11 43.96,71.59 47.61,75.24 v1(48.42,75.24) 49.03,75.24 50.96,77.17 v9(50.96,77.98)
  IN1 w0.064: v4(32.87,34.69) 32.43,34.69 29.89,37.23 29.89,37.8 29.47,38.22 29.47,38.94 29.71,39.18 29.71,42.47 30.74,43.5 30.74,45.83 31.9,46.98 31.9,48.3 32.17,48.57 32.78,48.57 33.11,48.9 33.42,48.9 33.89,49.37 33.89,49.53 34.23,49.86 35.04,49.86 v2(35.58,50.4) 35.66,50.48 35.66,50.81 36.04,51.19 36.55,51.19 37.59,52.23 37.59,52.66 38.1,53.17 38.1,53.8 40.24,55.95 40.24,57.1 43.79,60.64 43.79,61.04 v2(43.78,61.04) ; v2(59.34,17.67) 59.09,17.42 56.83,17.42 55.68,18.57 55.51,18.57 54.92,19.15 46.82,19.15 46.56,18.88 43.54,18.88 43.3,19.13 40.1,19.13 39.6,19.64 38.02,19.64 37.18,20.48 v4(37.18,21.55)
  GND2 w0.102: v7(66.01,83.99) v5(66.01,83.62) ; v7(34.59,53.27) 34.34,53.27 v5(34.22,53.16) ; v4(37.18,21.55) 36.93,21.8 v5(36.74,21.8) ; v4(32.87,34.69) 32.64,34.45 v5(32.52,34.45)
  GND3 w0.102: v8(36.53,22.22) 36.53,22.01 v5(36.74,21.8) ; v6(34.21,52.74) 34.21,53.02 34.22,53.03 v5(34.22,53.16) ; v5(66.01,83.62) v8(66.01,83.29) ; v8(32.52,34.09) v5(32.52,34.45)
  IN3 w0.064: v9(50.96,77.98) 51.36,77.98 54.53,74.81 55.44,74.81 63.93,83.29 v8(66.01,83.29) ; v8(32.52,34.09) 32.52,33.88 33.62,32.78 33.62,30.89 36.44,28.07 36.44,22.31 v8(36.53,22.22)
  BOTTOM w0.076: v6(34.21,52.74) 34.18,52.71 33.22,52.71 32.95,52.99 UH4.AL36
DGPU_PWROK: length 100.8
  TOP w0.127: 41.35,31.26 v1(42.48,32.39) 45.14,32.39 46.51,33.77 47.6,33.77 48.01,33.36 48.6,33.36 48.86,33.1 PR1823.1 PR1856.1 ; 41.35,31.26 39.3,33.3 39.3,35.77 39.96,36.43 39.96,37.71 40.22,37.97 42.59,37.97 42.81,38.18 42.81,44.35 42.66,44.51 PU78.2 ; 41.35,31.26 v2(40.7,30.61) ; v9(33.1,53.75) 33.1,53.71 32.81,53.42 RH148.2
  IN1 w0.064: v2(40.7,30.61) 38.23,33.09 v4(32.2,33.09) 31.85,33.09 28.81,36.13 27.71,36.13 26.45,37.38 26.45,37.6 26.15,37.9 26.15,38.67 25.93,38.89 25.93,40.48 26.82,41.38 27.31,41.38 27.58,41.65 27.58,42.38 27.78,42.58 27.78,43.21 28.15,43.58 28.15,44.78 28.66,45.29 28.66,48.32 29.18,48.84 29.18,49.54 30.37,50.72 30.37,51.22 30.96,51.81 31.04,51.81 32.77,53.53 32.88,53.53 v9(33.1,53.75)
  GND2 w0.102: v5(32.56,32.78) 32.5,32.78 v4(32.2,33.09)
  GND3 w0.102: v8(32.87,32.5) 32.84,32.5 v5(32.56,32.78)
  IN3 w0.064: v8(32.87,32.5) 33.03,32.34 33.03,30.68 34.92,28.8 34.92,24.78 35.12,24.58 35.12,22.18 35.61,21.69 35.61,19.79 38.08,17.32 46.57,17.32 47.99,15.91 48.11,15.91 48.48,15.53 48.48,15.13 49.12,14.49 49.12,12.96 48.99,12.83 v3(48.99,12.66)
  BOTTOM w0.076: v9(33.1,53.75) 33.17,53.82 33.7,53.82 UH4.AJ38
  BOTTOM w0.127: QC125.3 48.99,12.78 v3(48.99,12.66)
DGPU_PWROK_EC: length 9.3
  BOTTOM w0.127: RE433.2 42.67,11.89 42.92,11.63 44.12,11.63 44.39,11.9 RE437.1 RE438.1 47.69,12 RH659.2 48.35,13.77 QC125.1 47.11,14.23 v1(46.81,14.53)
DISPOFF#: length 4.1
  TOP w0.127: v1(61.88,91.19) 61.88,91.39 DV5.1 61.25,93.58 RV783.1 v7(61.46,93.81)
  GND2 w0.102: v7(61.46,93.81) v5(61.46,94.57)
  GND3 w0.102: v6(61.41,94.24) 61.41,94.52 v5(61.46,94.57)
DMI_CRX_PTX_N0: length 86.6
  IN1 w0.076: 93.76,80.87 93.77,80.85 93.77,80.75 94.06,80.46 94.18,80.46 v6(94.28,80.56)
  IN1 w0.086: v4(53.46,48.28) 53.07,48.28 52.45,48.9 52.45,51.52 51.1,52.87 51.1,64.24 61.69,74.83 67.7,74.83 69.86,76.99 69.86,79.65 73.86,83.64 73.86,85.78 75.81,87.73 88.76,87.73 90.66,85.83 90.66,82.72 91.18,82.2 91.73,82.2 92.7,81.23 93.39,81.23 93.76,80.87
  GND2 w0.102: v4(53.46,48.28) 53.17,48.28 v5(53.13,48.24) ; v6(94.28,80.56) v5(93.91,80.56)
  GND3 w0.102: v5(93.91,80.56) v6(94.28,80.56) ; v5(53.13,48.24) 53.18,48.29 v6(53.46,48.29)
  BOTTOM w0.076: UH4.C27 46.95,47.84 49.44,47.84 49.66,47.62 51.09,47.62
  BOTTOM w0.145: 51.09,47.62 51.16,47.55 52.33,47.55 53.08,48.29 v6(53.46,48.29)
