# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_GPIO_19_CTF#: length 74.6
  TOP w0.127: DV10.1 64.22,18.68 v1(64.68,19.13) 65.48,19.93 65.48,23.28 v7(65.49,23.29)
  GND2 w0.102: v7(65.49,23.29) 65.49,23.17 v5(65.2,22.87)
  IN2 w0.074: v5(52.35,66.86) 52.35,66.38 50.16,64.19 49.25,64.19 47.83,62.77 47.83,57.34 47.41,56.91 46.13,56.91 45.97,56.76 45.97,54.47 49.88,50.56 49.88,46.45 50.34,46 50.34,33.15 50.52,32.97 50.52,27.17 53.47,24.22 57.26,24.22 58.27,23.21 64.86,23.21 v5(65.2,22.87)
  GND3 w0.102: v6(52.85,66.83) 52.83,66.86 v5(52.35,66.86)
  BOTTOM w0.127: DV12.1 54.05,67.68 RH614.2 53.7,67.68 v6(52.85,66.83) 52.85,66.82 54.05,65.63 QC1.6
GPU_GPIO_22_ROMCS_N: length 15.7
  TOP w0.127: v7(89.4,90.91) 89.43,90.94 v1(89.95,90.94) 90.46,90.94 v7(90.47,90.93)
  GND2 w0.102: v5(89.07,91.24) 89.13,91.24 89.4,90.96 v7(89.4,90.91) ; v5(91.11,91.33) 91.08,91.29 90.9,91.29 90.54,90.93 v7(90.47,90.93)
  GND3 w0.102: v5(89.07,91.24) 89.03,91.2 v8(88.57,91.2) ; v6(91.47,91.29) 91.14,91.29 v5(91.11,91.33)
  IN3 w0.064: v3(88.44,92.74) 88.44,91.57 88.57,91.45 v8(88.57,91.2) 88.57,90.34 88.49,90.26 88.49,89.33 86.08,86.91 86.08,85.43 v3(86.39,85.12)
  BOTTOM w0.127: v3(88.44,92.74) 88.96,93.26 89.16,93.26 90.61,94.71 RP88.1
GPU_HSYNC: length 6.9
  BOTTOM w0.127: RH524.2 RH494.2 84.72,89.99 84.27,89.54 v1(82.83,89.54) 80.87,87.59 UC1.J1
GPU_I2C_SCL_R: length 77.4
  TOP w0.254: RH553.2 81.76,82.28 81.71,82.33 81.71,83.62 81.1,84.23 v7(80.95,84.23) 80.63,84.23 79.92,83.52 78.76,83.52 77.38,82.14 77.38,81.2 75.23,79.05 73.89,79.05 69.42,74.58 68.91,74.58 v9(68.81,74.68) ; v7(52.45,57.23) 49.47,57.23 v1(48.94,56.71) 46.45,54.22 46.45,36.34 47.33,35.46 49.56,35.46 PR1877.1
  GND2 w0.254: v5(80.52,84.56) 80.64,84.56 80.95,84.26 v7(80.95,84.23) ; v7(52.45,57.23) 52.71,57.23 v5(52.8,57.14)
  IN2 w0.254: v9(68.81,74.68) 68.71,74.58 65.58,74.58 61.87,70.87 60.68,70.87 57.62,67.81 57.62,64.59 54.91,61.88 53.62,61.88 52.37,60.64 52.37,57.44 52.67,57.14 v5(52.8,57.14)
  GND3 w0.254: v5(80.52,84.56) 80.61,84.47 v6(80.87,84.47)
GPU_I2C_SDA_R: length 76.6
  TOP w0.254: RH554.2 81.33,82.24 81.33,83.43 80.98,83.78 v7(80.9,83.78) 80.71,83.78 80.07,83.14 78.92,83.14 77.76,81.98 77.76,81.04 75.39,78.67 74.04,78.67 69.57,74.2 68.91,74.2 v9(68.81,74.1) ; v7(52.45,57.61) 49.31,57.61 v1(47.31,55.61) 46.07,54.38 46.07,36.19 47.17,35.08 49.35,35.08 PR1878.1
  GND2 w0.254: v5(52.8,57.67) 52.75,57.61 v7(52.45,57.61) ; v7(80.9,83.78) 80.82,83.85 80.62,83.85 v5(80.52,83.95)
  IN2 w0.254: v9(68.81,74.1) 68.71,74.2 65.74,74.2 62.03,70.49 60.84,70.49 58,67.66 58,64.44 55.06,61.5 53.77,61.5 52.75,60.48 52.75,57.72 v5(52.8,57.67)
  GND3 w0.254: v5(80.52,83.95) 80.52,83.91 80.79,83.91 v6(80.87,83.82)
GPU_JTAG_TCK: length 225.9
  IN2 w0.074: v5(24.38,27.07) 24.38,27.37 17.67,34.08 17.67,38.44 15.85,40.25 15.85,46.43 14.82,47.46 14.82,48.65 10.78,52.69 10.78,68.48 12.86,70.56 15.91,70.56 18.43,73.07 18.43,77.87 17.39,78.91 17.39,88.62 19.54,90.77 19.54,94.95 22.48,97.89 24.64,97.89 25.71,98.96 25.71,100.56 31.7,106.56 36.32,106.56 37,105.88 38.47,105.88 38.57,105.98 42.3,105.98 42.82,105.46 44.74,105.46 45.25,105.97 52.85,105.97 53.91,104.92 54.79,104.92 55.54,104.16 55.54,103.08 58.18,100.45 58.78,100.45 59.3,99.93 59.3,99.05 60.4,97.95 61.56,97.95 65.03,94.47 65.38,94.47 66.64,93.21 66.64,88.75 72.83,82.56 73.39,82.56 74.83,81.12 76.74,81.12 76.97,80.89 77.88,80.89 78.55,81.57 78.55,82.35 v5(78.26,82.64)
  GND3 w0.102: v8(78.62,82.47) 78.46,82.64 v5(78.26,82.64) ; v5(24.38,27.07) 24.38,26.85 24.36,26.83 v6(24.36,26.57)
  IN3 w0.064: v3(86.53,81.86) 86.39,81.86 86.08,82.17 85.18,82.17 84.6,82.75 83.9,82.75 83.88,82.77 78.92,82.77 v8(78.62,82.47)
  BOTTOM w0.127: JDGPU1.3 71.77,8.04 71.43,8.38 70.86,8.38 70.45,8.79 69.59,8.79 v1(68.1,10.29) 67.77,10.61 62.37,10.61 55.09,17.89 47.83,17.89 47.09,18.64 36.98,18.64 29.05,26.57 25.66,26.57 25.53,26.43 24.49,26.43 v6(24.36,26.57)
GPU_JTAG_TDI: length 222.9
  IN2 w0.074: v5(77.22,82.01) 77.17,81.96 76.06,81.96 75.1,82.91 72.97,82.91 66.94,88.94 66.94,93.33 65.5,94.77 65.16,94.77 61.66,98.27 61.66,98.55 60.05,100.16 59.5,100.16 58.91,100.74 58.3,100.74 55.84,103.21 55.84,104.29 54.91,105.22 54.03,105.22 52.74,106.51 42.66,106.51 42.56,106.61 38.31,106.61 38.21,106.51 37.26,106.51 36.58,107.19 31.44,107.19 25.08,100.83 25.08,99.22 24.38,98.52 22.22,98.52 18.91,95.21 18.91,91.32 17.09,89.5 17.09,78.79 18.13,77.74 18.13,73.19 15.79,70.86 12.74,70.86 10.46,68.58 10.46,52.52 14.5,48.48 14.5,47.32 15.5,46.32 15.5,40.16 17.34,38.31 17.34,33.98 23.39,27.93 v5(23.39,26.78)
  GND3 w0.102: v8(77.58,81.99) 77.24,81.99 v5(77.22,82.01) ; v5(23.39,26.78) 23.57,26.6 v6(23.57,26.37)
  IN3 w0.064: v3(85.62,81.86) 85.54,81.94 84.44,81.94 84.15,82.23 79.18,82.23 78.75,81.79 77.78,81.79 v8(77.58,81.99)
  BOTTOM w0.127: v6(23.57,26.37) 23.91,26.03 25.75,26.03 25.89,26.16 28.81,26.16 36.74,18.23 39.89,18.23 v16(40.12,18) 40.22,17.9 42.01,17.9 42.34,18.23 46.92,18.23 47.67,17.48 54.92,17.48 62.2,10.2 67.38,10.2 69.2,8.38 70.29,8.38 70.77,7.9 JDGPU1.5
GPU_JTAG_TDO: length 225.8
  IN2 w0.074: v5(77.74,81.27) 77.72,81.29 77.72,82.31 77.31,82.73 75.97,82.73 75.61,83.09 73.05,83.09 67.09,89.04 67.09,94.44 65.63,95.9 65.63,96.35 63.37,98.61 61.81,98.61 60.12,100.31 59.56,100.31 58.97,100.89 58.37,100.89 55.99,103.27 55.99,104.35 54.97,105.37 54.09,105.37 52.8,106.66 42.72,106.66 42.62,106.76 38.25,106.76 38.15,106.66 37.33,106.66 36.65,107.34 31.38,107.34 24.93,100.89 24.93,99.28 24.32,98.67 22.16,98.67 18.76,95.27 18.76,91.38 16.94,89.56 16.94,78.71 17.98,77.67 17.98,73.26 15.73,71.01 12.66,71.01 10.28,68.63 10.28,52.45 14.32,48.41 14.32,47.25 15.32,46.25 15.32,40.12 17.19,38.25 17.19,33.92 22.78,28.33 v5(22.78,26.57)
  GND3 w0.102: v5(22.78,26.57) 22.96,26.4 v6(22.96,26.22) ; v8(77.75,80.94) 77.72,80.98 77.72,81.26 v5(77.74,81.27)
  IN3 w0.064: v8(77.75,80.94) 77.95,81.13 79.92,81.13 80.87,82.09 84.09,82.09 84.38,81.8 85.13,81.8 85.59,81.33 v3(85.59,81.21)
  BOTTOM w0.127: v6(22.96,26.22) 23.19,26.22 v16(23.73,25.67) 24.01,25.67 24.16,25.82 25.84,25.82 25.97,25.96 28.73,25.96 36.71,17.98 39.62,17.98 39.96,17.63 42.03,17.63 42.43,18.03 46.83,18.03 47.61,17.25 54.86,17.25 62.11,10 67.3,10 69.12,8.18 70.11,8.18 70.27,8.02 JDGPU1.6
GPU_JTAG_TESTEN: length 226.8
  IN2 w0.074: v5(25.12,26.65) 25.12,26.84 17.82,34.14 17.82,38.5 16.02,40.29 16.02,46.47 14.97,47.52 14.97,48.75 10.96,52.77 10.96,68.44 12.92,70.41 15.98,70.41 18.58,73.01 18.58,77.93 17.54,78.97 17.54,88.55 19.69,90.71 19.69,94.89 22.54,97.74 24.7,97.74 25.86,98.89 25.86,100.5 31.77,106.41 36.26,106.41 37.49,105.18 44.67,105.18 45.31,105.82 52.79,105.82 53.84,104.77 54.72,104.77 55.39,104.1 55.39,103.02 58.12,100.3 58.72,100.3 59.15,99.87 59.15,98.99 60.33,97.8 61.49,97.8 64.97,94.32 65.32,94.32 66.49,93.15 66.49,87.37 69.07,84.79 69.97,84.79 72.38,82.39 73.35,82.39 74.85,80.89 75.17,80.89 v5(75.36,80.7)
  GND3 w0.102: v8(75.86,80.85) 75.82,80.89 75.54,80.89 v5(75.36,80.7) ; v6(24.75,26.8) 24.9,26.65 v5(25.12,26.65)
  IN3 w0.064: v3(87.42,81.21) 87.37,81.21 87.11,80.95 85.48,80.95 84.77,81.66 80.64,81.66 79.98,80.99 78.43,80.99 78.09,80.66 77.45,80.66 77.26,80.85 v8(75.86,80.85)
  BOTTOM w0.127: v6(24.75,26.8) v16(25.27,26.8) 25.98,26.8 26.01,26.77 29.13,26.77 37.07,18.84 47.17,18.84 47.92,18.09 55.17,18.09 62.45,10.81 68.15,10.81 69.8,9.16 RH530.2 RH531.1 70.42,9.11 70.94,8.58 71.81,8.58 72.27,8.12 JDGPU1.2
GPU_JTAG_TMS: length 224.7
  IN2 w0.074: v5(23.95,26.78) 23.95,27.58 17.49,34.04 17.49,38.4 15.67,40.22 15.67,46.39 14.67,47.4 14.67,48.56 10.61,52.62 10.61,68.52 12.8,70.71 15.85,70.71 18.28,73.13 18.28,77.8 17.24,78.85 17.24,89.43 19.06,91.26 19.06,95.15 22.29,98.37 24.44,98.37 25.23,99.16 25.23,100.76 31.5,107.04 36.52,107.04 37.2,106.36 38.27,106.36 38.37,106.46 42.49,106.46 42.59,106.36 52.67,106.36 53.97,105.07 54.85,105.07 55.69,104.22 55.69,103.15 58.24,100.59 58.84,100.59 59.43,100.01 59.99,100.01 61.51,98.49 61.51,98.21 65.09,94.62 65.44,94.62 66.79,93.27 66.79,88.85 72.9,82.74 73.76,82.74 74.13,82.37 74.98,82.37 v5(75.38,81.97)
  GND3 w0.102: v5(23.95,26.78) 24.02,26.7 v6(24.02,26.37) ; v5(75.38,81.97) 75.56,82.15 v8(75.67,82.15)
  IN3 w0.064: v3(86.53,82.51) 86.5,82.51 86.13,82.89 84.01,82.89 83.98,82.91 79.05,82.91 78.63,83.32 75.91,83.32 75.6,83.02 75.6,82.22 v8(75.67,82.15)
  BOTTOM w0.127: v6(24.02,26.37) 24.16,26.23 25.67,26.23 25.8,26.37 28.92,26.37 36.85,18.43 41.67,18.43 v16(41.84,18.27) 42.09,18.27 42.26,18.43 47,18.43 47.75,17.68 55,17.68 62.28,10.41 67.46,10.41 69.29,8.58 70.37,8.58 70.78,8.18 71.12,8.18 71.27,8.03 JDGPU1.4
GPU_JTAG_TRST#: length 236.4
  GND2 w0.102: v7(90.49,89.43) 90.14,89.43 v5(90.08,89.36)
  IN2 w0.074: v5(75.64,80.28) 75.59,80.32 74.23,80.32 71.21,83.34 70.31,83.34 66.34,87.31 66.34,93.08 65.25,94.17 64.89,94.17 61.42,97.65 60.21,97.65 59,98.86 59,99.81 58.66,100.15 58.06,100.15 55.24,102.96 55.24,104.04 54.66,104.62 53.78,104.62 52.73,105.67 45.37,105.67 44.73,105.03 37.28,105.03 36.06,106.26 31.83,106.26 26.01,100.44 26.01,98.83 24.77,97.59 22.61,97.59 19.87,94.85 19.87,90.68 19.64,90.45 17.69,88.49 17.69,79.03 18.73,77.99 18.73,72.94 16.04,70.26 12.98,70.26 11.11,68.38 11.11,52.83 14.55,49.39 15.31,49.39 15.55,49.15 15.55,47.33 16.17,46.71 16.17,40.35 17.96,38.56 17.96,34.33 25.38,26.91 25.46,26.83 25.46,26.24 24.93,25.71 v5(24.93,25.48)
  GND3 w0.102: v5(75.64,80.28) v8(76.04,80.28) ; v6(24.51,25.53) 24.88,25.53 v5(24.93,25.48) ; v5(90.08,89.36) 89.89,89.17 v6(89.89,89.02)
  IN3 w0.064: v3(87.45,81.86) 87.74,81.57 87.74,80.97 87.59,80.82 87.26,80.82 87.25,80.81 85.42,80.81 84.71,81.52 80.7,81.52 80.04,80.85 78.49,80.85 78.15,80.52 77.26,80.52 77.02,80.28 v8(76.04,80.28)
  BOTTOM w0.127: v6(24.51,25.53) 24.6,25.62 25.92,25.62 26.06,25.76 28.64,25.76 36.62,17.78 39.53,17.78 39.88,17.43 42.12,17.43 42.51,17.82 46.75,17.82 47.52,17.05 54.78,17.05 62.03,9.8 67.21,9.8 68.27,8.74 JDGPU1.10 ; RH532.2 89.89,89.2 v6(89.89,89.02) 89.75,89.02 89.53,88.8 89.53,88.19 88.49,87.15 88.49,83.14 87.88,82.53 87.88,82.12 87.62,81.86 v3(87.45,81.86)
GPU_MACO_EN: length 1.2
  GND2 w0.102: v5(84.5,59.37) 84.2,59.07 v7(84.2,58.74)
  GND3 w0.102: v6(84.14,59.24) 84.26,59.37 v5(84.5,59.37)
GPU_MTESTA: length 1.1
  GND2 w0.102: v5(84.48,59.89) 84.39,59.98 v7(83.75,59.98)
  GND3 w0.102: v6(84.14,59.89) v5(84.48,59.89)
GPU_OSC_XTAL_OUT: length 4.2
  BOTTOM w0.127: RH567.1 CH240.1 83.92,53.18 83.8,53.07 83.8,51.36 YC1.3
GPU_PCIE_ZVSS: length 5.3
  TOP w0.127: v7(82.47,61.37) 81.94,60.84 RH480.1
  GND2 w0.102: v5(82.32,60.94) 82.32,61.22 v7(82.47,61.37)
  GND3 w0.102: v6(82.19,61.3) 82.19,61.07 v5(82.32,60.94)
  BOTTOM w0.127: v6(82.19,61.3) 82.19,59.85 82.14,59.8 82.14,58.27 82.47,57.94 UC1.M44
GPU_PLLCHARZ_H: length 1.6
  TOP w0.127: T778.1 v7(79.28,61.45)
  GND2 w0.102: v7(79.28,61.45) 78.94,61.45 v5(78.91,61.42)
  GND3 w0.102: v6(79.17,61.63) 78.99,61.45 78.94,61.45 v5(78.91,61.42)
GPU_PLLCHARZ_L: length 1.4
  TOP w0.127: v7(80.17,62.06) CH224.1
  GND2 w0.102: v7(80.17,62.06) 80.11,62.06 79.98,61.93 79.88,61.93 v5(79.85,61.91)
  GND3 w0.102: v6(80.2,61.9) 79.96,61.9 79.93,61.93 79.88,61.93 v5(79.85,61.91)
GPU_PX_EN: length 39
  IN1 w0.064: v4(59.92,66.05) 61.79,64.17 72.18,64.17 77.19,59.16 77.19,57.97 79.12,56.04 81.81,56.04 82.61,56.84 82.61,57.74 82.81,57.94 83.33,57.94 v4(83.34,57.93)
  GND2 w0.102: v5(83.8,58.12) 83.62,57.93 v4(83.34,57.93) ; v5(60.07,65.74) 60.07,65.89 v4(59.92,66.05)
  GND3 w0.102: v6(60.36,66) 60.32,66 v5(60.07,65.74)
  GND3 w0.127: v5(83.8,58.12) 83.97,58.12 v6(84.14,57.94)
  BOTTOM w0.127: RH628.1 54.95,65.11 55.08,64.98 55.64,64.98 57.06,63.56 58.49,63.56 v1(60.36,65.42) v6(60.36,66)
GPU_PX_EN#: length 6.1
  BOTTOM w0.127: DV11.1 56.51,67.68 RH613.2 57.35,67.68 57.67,67.36 v1(57.67,67.18) 57.67,66.86 56.68,65.87 56.68,64.86 57.21,64.33 QC1.3
GPU_SMBCLK_Q: length 80.8
  TOP w0.127: 46.44,22.61 QE27.1 ; 46.44,22.61 46.52,22.69 v7(46.52,23.82) ; 46.44,22.61 46.55,22.49 RE289.2 RH646.2 ; v2(59.21,47.46) 58.77,47.01 55.54,47.01 54.04,48.52 v1(50.5,48.52) 50.14,48.16 v7(48.2,48.16)
  IN1 w0.064: v2(59.21,47.46) 58.84,47.84 58.84,48.63 59.23,49.03 59.23,51.54 63.16,55.47 70.76,55.47 71.32,56.02 73.73,56.02 74.63,55.11 77.79,55.11 78.46,55.79 82.37,55.79 83.77,57.19 83.77,57.89 82.9,58.77 81.94,58.77 v4(81.77,58.6)
  GND2 w0.102: v4(81.77,58.6) 81.65,58.72 v5(81.45,58.72) ; v7(48.2,48.16) 48.14,48.23 48.02,48.23 v5(47.87,48.07) ; v7(46.52,23.82) v5(46.2,24.13)
  IN2 w0.074: v5(46.2,24.13) 45.61,24.13 43.84,25.9 43.84,26.07 43.65,26.27 43.65,30.45 45.37,32.18 46.49,32.18 47.41,33.1 47.41,34.83 46.98,35.26 46.98,40.03 47.75,40.8 47.75,47.96 v5(47.87,48.07)
  GND3 w0.102: v5(81.45,58.72) 81.58,58.59 v6(81.78,58.59)
GPU_SMBDAT_Q: length 77.8
  TOP w0.127: v7(42.89,25.61) 41.94,24.67 RE290.2 41.96,24.57 42.55,23.98 RH647.2 43.21,23.98 43.29,23.91 QE27.4 ; v2(59.32,47.94) 59.19,47.94 58.47,47.22 55.63,47.22 54.01,48.84 50.11,48.84 49.82,48.54 v1(48.74,48.54) v7(48.2,48.54)
  IN1 w0.064: v2(59.32,47.94) 59.31,47.95 59.31,48.91 59.37,48.97 59.37,51.48 63.21,55.33 70.82,55.33 71.38,55.88 73.67,55.88 74.58,54.97 77.84,54.97 78.52,55.65 82.43,55.65 83.91,57.13 83.91,57.95 82.94,58.92 82.09,58.92 v4(81.79,59.22)
  GND2 w0.102: v5(43.5,25.93) 43.2,25.93 v7(42.89,25.61) ; v5(47.84,48.62) 47.91,48.54 v7(48.2,48.54) ; v5(81.43,59.24) 81.76,59.24 v4(81.79,59.22)
  IN2 w0.074: v5(47.84,48.62) 47.52,48.3 47.52,40.78 46.83,40.09 46.83,35.19 47.18,34.85 47.18,33.08 46.43,32.33 45.31,32.33 43.5,30.51 v5(43.5,25.93)
  GND3 w0.102: v6(81.78,59.24) v5(81.43,59.24)
GPU_SMCLK: length 12.8
  TOP w0.076: UE3.D7 45.55,14.75 45.63,14.67 45.74,14.67 45.86,14.8 45.86,16.8 45.77,16.9 45.31,16.9 45.08,17.13 45.08,18.03 44.69,18.42 44.69,18.55
  TOP w0.127: 44.69,18.55 44.69,19.4 v2(44.55,19.54) ; RH646.1 44.23,20.59 v2(43.79,21.04) 44.55,21.8 44.55,22.42 44.36,22.61 QE27.6
  IN1 w0.064: v2(43.79,21.04) 44.55,20.28 v2(44.55,19.54)
GPU_SMDAT: length 15.9
  TOP w0.076: UE3.E7 45.55,14.43 45.63,14.51 45.8,14.51 46.03,14.73 46.03,16.87 45.84,17.06 45.38,17.06 45.25,17.19 45.25,18.1 44.9,18.44 44.9,18.65
  TOP w0.127: 44.9,18.65 44.9,19.32 v2(45.12,19.54) ; RH647.1 43.94,24.57 44.12,24.39 45.69,24.39 45.82,24.27 QE27.3 45.13,23.91 44.75,23.53 44.75,21.32 v2(45.08,21)
  IN1 w0.064: v2(45.12,19.54) 44.69,19.97 44.69,20.6 v2(45.08,21)
GPU_SPI_CLK_R1: length 12.4
  BOTTOM w0.127: RP88.6 92.98,95.71 93.89,94.8 93.89,94.13 v1(93.95,94.06) 94.15,93.86 100.43,93.86 101.04,93.25 101.04,92 101.27,91.78 UC8.6
GPU_SPI_CS_R_N: length 8.9
  BOTTOM w0.127: UC8.1 93.86,89.24 RH570.2 92.69,90.33 92.69,91.19 92.88,91.38 92.88,92.59 93.09,92.8 93.09,94.39 92.77,94.71 RP88.8
GPU_SPI_HOLD_N: length 2.3
  BOTTOM w0.127: UC8.7 RH569.2
GPU_SPI_MISO_R1: length 8.8
  BOTTOM w0.127: RP88.7 92.77,95.21 93.44,94.54 93.44,92.65 93.24,92.45 93.24,91.23 93.05,91.04 v1(93.05,90.52) 93.37,90.2 93.39,90.2 93.85,90.2 94.15,90.51 UC8.2
GPU_SPI_MOSI_R1: length 10.9
  BOTTOM w0.127: RP88.5 93.11,96.21 v1(93.94,95.38) 95.1,94.21 100.58,94.21 101.75,93.05 UC8.5
GPU_SPI_WP_N: length 2.3
  BOTTOM w0.127: UC8.3 93.86,91.78 RH607.2
GPU_TEMPIN_RET: length 6
  IN3 w0.064: v3(86.2,54.39) 86.2,55.09 85.2,56.09 85.2,59.62 v3(84.93,59.89)
GPU_TEST_PG: length 4.2
  TOP w0.127: v7(86.1,82.53) 85.23,82.53 84.81,82.11 RH538.2 84.83,82.04 85.19,81.68 85.19,81.11 v1(84.62,80.54)
  GND2 w0.102: v5(86.1,82.89) v7(86.1,82.53)
  GND3 w0.102: v5(86.1,82.89) 86.38,83.17 v6(86.39,83.17)
GPU_TEST_PG_BACO: length 6.9
  BOTTOM w0.127: v1(79.6,54.51) RH539.2 78.65,55.29 79.65,56.29 79.65,56.52 79.8,56.67 79.8,58.07 80,58.27 80.46,58.27 80.65,58.46 80.65,58.91 UC1.K42
GPU_VSYNC: length 18.4
  TOP w0.127: v7(84.89,91.55) v1(86.14,91.55) 89.45,91.55 90.52,92.61 v7(90.88,92.61)
  GND2 w0.102: v5(84.73,91.87) 84.81,91.8 84.81,91.63 v7(84.89,91.55) ; v5(91.28,92.77) 91.04,92.77 v7(90.88,92.61)
  GND3 w0.102: v5(91.28,92.77) 91.36,92.69 v6(91.36,92.33) ; v5(84.73,91.87) 84.59,91.72 v8(84.59,91.57)
  IN3 w0.064: v8(84.59,91.57) 84.51,91.5 84.51,90.75 80.87,87.11 v3(80.87,85.77)
  BOTTOM w0.127: v6(91.36,92.33) 92.29,92.33 92.48,92.14 92.48,91.53 92.24,91.29 RH523.2 RH493.2
GPU_XTAL_IN: length 2.9
  BOTTOM w0.127: UC1.N46 83.84,56.15 83.84,54.95 83.28,54.39 RH567.2
H_CATERR#: length 7
  BOTTOM w0.127: v1(138.38,69.76) 138.17,69.55 136.67,69.55 136.42,69.81 RH48.2 135.91,70.82 132.7,70.82 UC1.DH25
H_CPUPWRGD: length 208.6
  TOP w0.127: v7(53.44,58.98) v1(52.57,59.85) 52.56,59.85 52.55,59.86 46.53,59.86 44.35,62.04 44.35,68.28 44.82,68.76 44.82,71.23 47.97,74.38 50.02,74.38 51.84,76.2 51.84,81.05 53.23,82.44 60.27,82.44 61.15,81.57 68.64,81.57 68.97,81.9 72.83,81.9 78.34,87.41 130.6,87.41 135.14,82.86 136.55,82.86 137.83,81.58 T834.1 137.83,78.48 v2(135.68,76.33)
  IN1 w0.064: v4(132.43,73.06) 135.68,76.31 v2(135.68,76.33)
  GND2 w0.102: v4(132.43,73.06) v5(132.43,72.56) ; v7(53.44,58.98) 53.73,58.69 v5(54.03,58.69)
  GND3 w0.102: v6(132.4,72.1) 132.41,72.1 132.43,72.12 v5(132.43,72.56) ; v5(54.03,58.69) v6(54.45,59.11)
  BOTTOM w0.076: 33.3,33.36 33.3,33.61 32.48,34.42 32.48,36.05 32.56,36.12 32.56,36.28 32.26,36.58 UH4.AM3
  BOTTOM w0.127: 33.3,33.36 33.3,33.03 33.8,32.52 33.8,30.73 37.76,26.78 41.37,26.78 44.48,23.67 50.93,23.67 54.31,27.04 55,27.04 58.62,30.66 58.62,33.22 58.95,33.56 58.95,37.66 60.78,39.49 60.78,54.34 60.33,54.78 58.86,54.78 54.53,59.11 v6(54.45,59.11)
H_PECI_CPU: length 3.1
  BOTTOM w0.076: 132.67,71.58 132.05,71.58 131.78,71.31 UC1.DG24
  BOTTOM w0.127: RH55.2 134.45,71.35 132.9,71.35 132.67,71.58
H_PM_DOWN: length 204.4
  TOP w0.127: v7(58.02,48.84) 57.65,48.84 57.07,49.42 56.52,49.42 53.55,52.38 53.55,58.25 52.37,59.43 v1(48.93,59.43) 46.36,59.43 43.92,61.87 43.92,68.46 44.39,68.94 44.39,71.41 47.79,74.81 49.84,74.81 51.41,76.38 51.41,81.23 53.05,82.87 60.45,82.87 61.32,82 68.46,82 68.79,82.33 72.65,82.33 78.19,87.86 130.97,87.86 135.46,83.37 136.7,83.37 138.27,81.8 138.27,77.7 138.4,77.58 142.55,77.58 143.66,76.47 146.7,76.47 RH54.1
  GND2 w0.102: v7(58.02,48.84) 58.02,48.52 v5(58.15,48.39)
  GND3 w0.102: v5(58.15,48.39) 58.35,48.19 v6(58.57,48.19)
  BOTTOM w0.076: 36.02,33.36 36.02,33.78 35.18,34.63 34.43,34.63 33.98,35.08 33.98,35.87 UH4.AH2
  BOTTOM w0.127: 36.02,33.36 36.02,33.16 36.86,32.32 36.86,30.94 38.41,29.39 41.8,29.39 45.37,25.82 50.04,25.82 51.21,27 51.21,32.39 53.03,34.21 55.91,34.21 56.8,35.1 56.8,38.31 58.49,40 58.49,42.28 59.48,43.27 59.48,47.35 58.65,48.19 v6(58.57,48.19)
H_PM_DOWN_R: length 21.4
  TOP w0.127: v9(144.7,74.99) 145.06,74.63 v1(146.72,74.63) 147.1,75.01 RH54.2
  IN3 w0.064: v9(144.7,74.99) 144.7,74.72 142.2,72.22 139.61,72.22 138.08,73.74 137.09,73.74 136.3,72.95 135.34,72.95 134.92,72.54 133.71,72.54 132.91,73.34 131.89,73.34 131.23,72.68 130.81,72.68 130.58,72.45 130.25,72.45 129.9,72.1 v3(129.8,72.1)
H_PM_SYNC_R: length 186.7
  TOP w0.127: v7(57.12,50.58) 56.58,50.58 54.42,52.74 54.42,59.63 53.83,60.22 53.83,60.92 53.58,61.17 47.06,61.17 45.65,62.58 45.65,67.74 46.12,68.22 46.12,68.9 46.12,68.9 46.12,70.69 48.51,73.08 50.56,73.08 51.38,73.91 54.14,73.91 56.86,76.63 56.86,77.25 57.59,77.98 57.59,78.21 58.39,79.01 60.23,79.01 v1(60.93,79.71) 61.49,80.27 69.18,80.27 69.51,80.6 73.8,80.6 79.31,86.11 128.9,86.11 134.21,80.8 134.21,78.92 135.11,78.02 v2(135.11,77.84)
  IN1 w0.061: v2(135.11,77.84) 134.21,76.94 134.21,76.82
  IN1 w0.064: 134.21,76.82 134.21,76.41 131.26,73.46 v4(131.26,73.08)
  GND2 w0.102: v5(130.86,73.08) v4(131.26,73.08) ; v5(57.67,50.53) 57.6,50.53 57.55,50.58 v7(57.12,50.58)
  GND3 w0.102: v5(130.86,73.08) 130.73,73.08 130.53,72.88 v6(130.45,72.88) ; v5(57.67,50.53) 57.69,50.55 v6(58.11,50.55)
  BOTTOM w0.127: v6(58.11,50.55) 58.49,50.55 59.92,49.13 59.92,43.09 59.17,42.35 59.17,39.71 57.65,38.2 57.65,35.34 56.09,33.78 53.21,33.78 51.71,32.28 51.71,26.89 50.22,25.39 45.19,25.39 41.78,28.81 38.17,28.81 36.42,30.56 RH96.2
H_PROCHOT#: length 373.7
  TOP w0.127: v2(56.6,2.95) v1(56.6,3.38) 56.6,5.75 58.29,7.44 v2(58.29,8.12) 60.93,8.12 64.87,12.06 v2(64.87,12.06) ; v2(144.38,82.52) 143.53,83.36 143.53,88.88 141.96,90.46 136.42,90.46 135.76,89.79 92.05,89.79 91.69,90.15 89.19,90.15 88.83,89.79 84.93,89.79 83.41,91.32 83.41,93.02 83.79,93.4 84.07,93.4 84.43,93.76 84.43,95.56 v9(84.02,95.97) ; RH51.2 RH50.1 146.76,72.61 v7(146.67,72.52) ; RE158.2 53.35,10.78 v2(53,10.43)
  TOP w0.203: v9(137.39,50.22) 137.39,50.15 137.99,49.55 140.01,49.55 140.22,49.34 140.22,48.62 140.37,48.47 PR1120.1
  IN1 w0.064: v2(64.87,12.06) 64.19,12.06 61.69,14.56 60.88,14.56 v2(58.85,16.59) ; v2(53,10.43) 53,10.3 54.34,8.96 54.34,8.82 54.56,8.6 57.81,8.6 58.13,8.28 v2(58.29,8.12) ; v9(137.39,50.22) 140.07,50.22 140.58,50.73 144.4,50.73 150.36,44.77 150.36,38.85 151.11,38.09 151.11,34.85 149.6,33.33 149.6,30.62 151.5,28.72 154.25,28.72 155.9,27.07 155.9,26.49 156.37,26.01 156.37,22.55 160.69,18.23 160.69,17.57 162.84,15.42 162.84,13.9 165.81,10.92 166.55,10.92 166.91,10.56 166.91,10.2 167.23,9.89 167.89,9.89 169.11,8.67 169.83,8.67 171.01,7.48 171.01,6.93 171.54,6.4 171.54,2.55 170.19,1.2 167.57,1.2 166.73,2.04 v2(165.96,2.04) 165.81,2.04 164.4,3.45 154.18,3.45 153.19,2.46 149.41,2.46 147.57,4.29 130.7,4.29 128.01,6.98 126.8,6.98 124.68,4.86 109.85,4.86 107.81,4.02 107.72,3.92 107.16,3.36 107.16,2.4 106.54,1.78 101.27,1.78 99.81,3.24 96.88,3.24 95.42,1.78 73.24,1.78 73.14,1.89 58.9,1.89 57.83,2.95 v2(56.6,2.95) ; v2(63.61,83.79) 64.06,84.23 64.06,85.73 67.21,88.89 69.13,88.89 72.85,92.61 75.49,92.61 77.71,94.82 79.47,94.82 79.65,95 81.11,95 81.7,95.59 83.64,95.59 v9(84.02,95.97) ; v2(144.38,82.52) 144.38,82.52 146.39,80.51 146.39,77.64 146.02,77.27 v7(145.96,77.27)
  GND2 w0.102: v5(146.34,72.35) 146.5,72.35 v7(146.67,72.52) ; v7(145.96,77.27) 145.96,77.12 v5(145.77,76.93)
  GND3 w0.102: v8(145.89,72.35) v5(146.34,72.35) ; v8(145.77,76.59) v5(145.77,76.93)
  IN3 w0.064: v8(145.77,76.59) 145.77,72.47 v8(145.89,72.35) 145.89,71.62 144.9,70.63 144.9,69.89 144.06,69.05 141.62,69.05 140.9,68.33 138.25,68.33 137.77,67.84 137.77,67.36 137.55,67.13 137.19,67.13 137.05,66.99 137.05,62.21 137.23,62.03 137.61,62.03 137.8,61.84 137.8,57.29 137.57,57.06 137.02,57.06 136.31,56.35 136.31,54.11 136.37,54.05 136.37,51.33 136.94,50.76 136.94,50.67 v9(137.39,50.22)
  BOTTOM w0.127: v9(84.02,95.97) 83.73,95.97 83.58,96.12 PR802.1
H_PROCHOT#_R: length 17.2
  TOP w0.127: v9(145.07,72.22) 145.89,73.04 RH50.2
  IN3 w0.064: v9(145.07,72.22) 143.76,72.22 142.87,71.33 138.84,71.33 137.63,72.54 137.12,72.54 136.6,72.01 135.85,72.01 134.95,71.11 133.33,71.11 132.79,71.66 131.45,71.66 v3(131.1,71.31)
H_PROCHOT#_R1: length 2.8
  TOP w0.127: RE158.1 52.38,11.26 v1(51.96,11.26) 51.48,11.26 50.91,11.83 50.39,11.83 UE3.H13
H_PROCHOT_N_FET: length 4.4
  TOP w0.127: QC7.3 54.98,19.45 RH605.2 54.96,20.08 55.28,20.4 v1(56.3,20.4) 56.4,20.4 56.74,20.06 QC7.2
H_PROCHOT_N_R: length 2.5
  TOP w0.127: QC7.6 57.39,17.14 RH589.1 58.15,16.81 58.15,16.86 58.71,17.42 v1(58.71,17.54)
H_THERMTRIP#: length 6.9
  BOTTOM w0.076: UH4.AJ3 33.95,36.41 34.29,36.07 34.29,35.77 34.17,35.65 34.17,35.12 34.49,34.81 35.3,34.81 35.66,34.45 36.16,34.45 36.39,34.22
  BOTTOM w0.127: 36.39,34.22 36.8,33.81 v1(36.8,33.29) 36.8,33.23 37.61,32.42 RH94.1
H_THERMTRIP#_R: length 228
  TOP w0.127: QE16.3 30.91,14.93 30.5,15.33 30.5,15.93 31.26,16.7 31.26,17.36 30.67,17.96 30.67,18.43 v2(31.44,19.21) ; v2(135.25,76.74) 136.56,78.05 136.56,82.07 136.36,82.28 134.9,82.28 133.94,83.24 133.42,83.24 129.69,86.98 78.74,86.98 73.23,81.46 69.15,81.46 68.82,81.13 60.97,81.13 60.09,82.01 53.41,82.01 52.28,80.87 52.28,76.02 v1(52.26,76.01) 50.2,73.95 48.15,73.95 45.26,71.05 45.26,68.58 44.78,68.1 44.78,62.22 46.71,60.29 53.15,60.29 53.98,59.45 53.98,52.56 56.7,49.85 v7(57.16,49.85)
  IN1 w0.064: v2(135.25,76.74) 135.1,76.59 135.1,76.25 134.42,75.57 v4(134.39,75.57) ; v4(36.98,30.71) 36.88,30.61 35.12,30.61 32.51,28 32.51,21.24 31.44,20.17 v2(31.44,19.21)
  GND2 w0.102: v5(37.46,30.74) 37.33,30.74 37.31,30.71 v4(36.98,30.71) ; v5(57.38,49.33) 57.16,49.55 v7(57.16,49.85) ; v5(134.36,75.22) 134.36,75.55 v4(134.39,75.57)
  GND3 w0.102: v5(57.38,49.33) 57.87,49.83 v6(58.14,49.83) ; v6(134.72,75.22) v5(134.36,75.22) ; v5(37.46,30.74) 37.89,30.74 v6(38.07,30.56)
  BOTTOM w0.127: RH94.2 v6(38.07,30.56) 38.66,29.98 41.83,29.98 45.55,26.26 49.86,26.26 50.78,27.18 50.78,32.57 52.85,34.64 55.73,34.64 56.37,35.28 56.37,38.6 58.06,40.29 58.06,42.46 59.05,43.45 59.05,47.15 58.15,48.05 58.15,48.56 58.58,48.99 58.58,49.64 58.39,49.83 v6(58.14,49.83) ; v6(134.72,75.22) 135.66,75.22 136.62,74.25 138.15,74.25 139.62,72.78 139.62,70.39 138.35,69.12 136.49,69.12 135.81,69.81 134.97,69.81 134.59,70.19 RH42.2 133.58,70.31 133.45,70.19 132.09,70.19 UC1.DG25
H_VCCST_PWRGD_P: length 62.2
  TOP w0.127: v7(48.15,31.34) 48.01,31.2 v1(47.28,31.2) 47.11,31.2 46.96,31.35 44.9,31.35 44.55,30.99 44.55,29.75 44.89,29.4 UE7.4
  IN1 w0.064: v4(49.4,35.63) 53.01,35.63 53.72,34.92 58.38,34.92 59.56,36.1 59.56,40.35 57.4,42.51 57.4,44.41 59.36,46.37 60.51,46.37 61.11,46.97 61.11,48.89 62.63,50.42 62.63,50.75 65.38,53.5 68.6,53.5 68.96,53.14 69.77,53.14 69.95,53.32 79,53.32 79.66,53.98 v4(81.1,53.98)
  GND2 w0.102: v5(81.1,53.55) v4(81.1,53.98) ; v5(48.94,35.21) 49.36,35.63 v4(49.4,35.63) ; v7(48.15,31.34) 48.34,31.53 v5(48.46,31.53)
  IN2 w0.074: v5(48.94,35.21) 48.94,32 48.46,31.51 v5(48.46,31.53)
  GND3 w0.102: v6(81.51,53.55) v5(81.1,53.55)
  BOTTOM w0.127: RH45.2 81.59,53.64 v6(81.51,53.55)
HDA_BIT_CLK: length 33
  IN1 w0.064: v7(27.67,39.26) 28.33,38.6 28.33,37.86 32.2,33.99 38.59,33.99 42.04,30.54 46.67,30.54 47.02,30.89 52.79,30.89 v4(52.82,30.92)
  GND2 w0.102: v5(53.13,30.69) 53.06,30.69 v4(52.82,30.92) ; v7(27.67,39.26) 27.67,39.18 v5(27.86,38.98)
  GND3 w0.102: v6(27.67,39.27) 27.86,39.08 v5(27.86,38.98) ; v6(53.21,31.1) 53.13,31.02 v5(53.13,30.69)
  BOTTOM w0.127: RP6.8 53.77,32.4 53.22,31.85 53.22,31.11 v6(53.21,31.1)
HDA_BIT_CLK_R: length 69.8
  IN1 w0.064: v9(80.67,21.39) 80.3,21.75 77.65,21.75 76.73,22.68 75.72,22.68 74.61,23.8 69.19,23.8 65.53,27.46 62.33,27.46 61.24,28.54 58.31,28.54 57.61,29.24 v4(55.47,29.24)
  GND2 w0.102: v5(55.22,29.46) 55.44,29.23 55.47,29.23 v4(55.47,29.24)
  GND3 w0.102: v6(55.65,29.65) 55.4,29.65 v5(55.22,29.46)
  IN3 w0.064: v3(83.79,13.94) 83.83,13.9 89.19,13.9 89.25,13.96 97.36,13.96 97.74,14.33 101.03,14.33 101.7,15.01 105.58,15.01 105.73,15.16 107.22,15.16 107.36,15.03 107.74,15.03 108,15.29 v3(108.61,15.29)
  BOTTOM w0.102: JIO1.E6 109.06,15.74 v3(108.61,15.29)
  BOTTOM w0.127: v3(83.79,13.94) CH116.1 83.31,15.22 83.31,17.07 83.55,17.32 83.55,19.95 83.37,20.13 81.19,20.13 80.86,20.46 80.86,21.19 v9(80.67,21.39) ; v6(55.65,29.65) 55.66,29.65 56.55,30.53 56.55,31.9 56.04,32.4 RP6.1
HDA_RST#: length 2.7
  BOTTOM w0.076: UH4.BD8 26.06,38.72 25.28,38.72 25.19,38.63 T810.1 CH119.1
HDA_SDIN0: length 121.8
  IN3 w0.064: v3(90.63,1.44) 90.09,1.99 88.23,1.99 88.01,2.21 84.64,2.21 84.34,2.51 82.64,2.51 81.51,3.64 78.22,3.64 77.67,4.19 61.27,4.19 59.69,5.76 56.8,5.76 55.84,6.72 54.5,6.72 53.51,7.71 50.28,7.71 49.55,8.44 49.55,9.94 47.22,12.28 47.22,13.19 46.96,13.45 46.74,13.45 45.7,14.49 41.51,14.49 40.57,15.42 38.08,15.42 34.12,19.38 34.12,21 33.56,21.56 33.56,26.77 32.11,28.22 32.11,29.7 29.31,32.51 27.06,32.51 26.39,33.18 25.63,33.18 24.22,34.59 24.22,35.95 24.63,36.36 v3(24.63,37.47) ; v3(93.32,7.77) 93.38,7.7 99.94,7.7 101.43,9.19 103.5,9.19 v3(103.62,9.31)
  BOTTOM w0.076: v3(24.63,37.47) 23.92,37.47 23.4,36.95 23.4,36.71 22.9,36.21 CH120.1 22.83,36.62 22.83,36.98 24.04,38.18 25.19,38.18 25.48,38.47 25.9,38.47 UH4.BE7
  BOTTOM w0.127: v3(103.62,9.31) 103.71,9.39 103.85,9.39 103.86,9.4 104.27,9.4 104.27,9.39 104.34,9.39 104.56,9.61 104.56,11.2 104.75,11.4 106.36,11.4 106.56,11.59 106.56,12.36 107.06,12.86 JIO1.H8 ; v3(93.32,7.77) 93.32,7.08 93.39,7 93.39,4.35 v1(91.32,2.27) 90.63,1.58 v3(90.63,1.44)
HDA_SDOUT: length 94
  TOP w0.127: RH156.2 v1(5.99,8.06) 6.58,8.64 v2(6.58,9.99) ; CH82.2 28.71,37.6 CH121.1 28.25,37.76 v9(27.85,38.17)
  IN1 w0.064: v2(6.58,9.99) 7.87,8.69 12.2,8.69 13.48,7.42 17.84,7.42 20.14,9.71 22.58,9.71 22.95,10.08 22.95,11.54 27.04,15.63 27.04,16.12 30.1,19.18 30.93,19.18 31.2,18.92 31.77,18.92 32.94,20.09 32.94,21.04 33.74,21.84 33.74,23.59 32.97,24.36 32.97,26.5 33.32,26.85 v4(33.32,28.28) ; v9(27.85,38.17) 27.85,37.71 32.02,33.54 38.41,33.54 41.85,30.1 46.85,30.1 47.2,30.44 53.16,30.44 v4(53.6,30)
  GND2 w0.102: v4(33.32,28.28) 33.58,28.53 v5(33.6,28.53) ; v5(53.97,30.02) 53.95,30 v4(53.6,30)
  GND3 w0.102: v5(33.6,28.53) 33.84,28.77 v8(33.84,28.79) ; v6(53.68,30.31) v5(53.97,30.02)
  IN3 w0.064: v8(33.84,28.79) 33.84,29.61 32.7,30.75 32.7,32.22 29.54,35.39 29.54,36.61 28.9,37.24 28.9,37.8 28.54,38.17 v9(27.85,38.17)
  BOTTOM w0.076: v9(27.85,38.17) UH4.BB7
  BOTTOM w0.127: v6(53.68,30.31) 54.11,30.31 54.26,30.46 RP6.5
HDA_SDOUT_R: length 75
  TOP w0.127: v2(74.77,12.88) 74.77,12.95 77.7,15.88 v1(77.7,17.93) v2(77.7,21.29)
  IN1 w0.064: v2(77.7,21.29) 77.49,21.29 76.54,22.24 75.54,22.24 74.42,23.35 69,23.35 65.35,27.01 62.14,27.01 61.06,28.1 58.12,28.1 57.42,28.8 55.27,28.8 54.78,29.28 v4(54.78,30.18) ; v2(74.77,12.88) 75.01,12.64 78,12.64 78.76,11.88 81.93,11.88 82.36,11.45 83.23,11.45 84.2,10.48 88.82,10.48 89.03,10.27 92.84,10.27 93.54,10.97 98.07,10.97 99.07,11.97 103.53,11.97 104.24,12.68 104.52,12.68 104.87,13.04 105.5,13.04 105.74,13.28 107.3,13.28 107.58,13.55 v4(107.59,13.55)
  GND2 w0.102: v4(54.78,30.18) 55.08,30.48 v5(55.08,30.64) ; v5(107.59,14.28) v4(107.59,13.55)
  GND3 w0.102: v6(108.06,13.9) 107.98,13.9 v5(107.59,14.28) ; v6(55.09,30.31) 55.09,30.63 v5(55.08,30.64)
  BOTTOM w0.127: v6(55.09,30.31) 55.41,30.63 RP6.4
HDA_SYNC: length 34.6
  IN1 w0.064: v4(53.35,31.31) 52.65,32.01 48.45,32.01 47.77,31.33 46.83,31.33 46.49,30.99 42.22,30.99 38.78,34.43 32.39,34.43 28.77,38.04 28.77,38.79 28.04,39.52 v4(28.03,39.52)
  GND2 w0.102: v5(53.68,31.13) 53.5,31.31 v4(53.35,31.31) ; v4(28.03,39.52) 27.8,39.74 v5(27.64,39.74)
  GND3 w0.102: v6(53.63,30.69) 53.68,30.74 v5(53.68,31.13) ; v6(27.19,39.12) 27.19,39.29 v5(27.64,39.74)
  BOTTOM w0.076: UH4.BD9 26.71,39.21 27.1,39.21 v6(27.19,39.12)
  BOTTOM w0.127: v6(53.63,30.69) 53.74,30.8 53.74,31.65 53.99,31.9 RP6.7
HDA_SYNC_R: length 74.6
  TOP w0.127: v2(85.58,10.22) 85.65,10.28 85.65,19.44 v1(85.47,19.61) 85.18,19.91 v2(85.18,21.46)
  IN1 w0.064: v2(85.58,10.22) 85.72,10.08 92.92,10.08 93.62,10.78 98.15,10.78 99.15,11.78 103.61,11.78 104.32,12.49 104.6,12.49 104.95,12.85 105.58,12.85 105.82,13.09 107.38,13.09 107.48,13.19 108.07,13.19 108.23,13.34 v4(108.23,13.55) ; v4(55.1,29.9) 55.32,29.69 57.79,29.69 58.49,28.99 61.42,28.99 62.51,27.9 65.72,27.9 69.37,24.24 74.79,24.24 75.91,23.13 76.91,23.13 77.84,22.2 80.72,22.2 81.09,21.84 84.59,21.84 84.97,21.46 v2(85.18,21.46)
  GND2 w0.102: v4(108.23,13.55) 108.23,13.98 v5(108.53,14.28) ; v4(55.1,29.9) 55.52,30.32 v5(55.52,30.38)
  GND3 w0.102: v5(108.53,14.28) 108.06,14.76 v6(108.06,14.9) ; v5(55.52,30.38) 55.36,30.22 v6(55.36,30.06)
  BOTTOM w0.127: RP6.2 55.79,31.9 56.04,31.65 56.04,30.74 v6(55.36,30.06)
HDD_DET#: length 5.5
  BOTTOM w0.076: UH4.AG39 34.59,54.88 34.59,54.97 34.45,55.11 34.45,55.6 34.55,55.7 34.55,55.97 34.64,56.06 34.64,56.57 34.59,56.62 34.59,56.72 34.4,56.91 34.2,56.91 33.94,57.17 33.94,58.35 33.66,58.63 33.66,58.76
  BOTTOM w0.127: RH93.1 33.66,58.76
HOST_DEBUG_TX: length 15.7
  TOP w0.127: v7(48.52,11.31) 48.52,11.55 48.41,11.65 48.41,12.03 48.75,12.37 UE3.G11 ; RE202.2 RE206.2 48.23,4.05 v7(48.56,4.38)
  IN1 w0.064: v9(45.98,6.77) 45.98,7.34 45.93,7.38 45.93,8.62 46.64,9.32 46.64,9.81 47.29,10.46 47.29,10.79 47.81,11.31 v7(48.52,11.31)
  GND2 w0.102: v7(48.56,4.38) 48.88,4.38 v5(48.89,4.38)
  GND3 w0.102: v6(48.89,4.71) v5(48.89,4.38)
  BOTTOM w0.127: v9(45.98,6.77) 45.98,6.46 v1(46.26,6.18) 46.61,5.83 47.12,5.83 47.45,6.16 47.45,6.54 47.72,6.81 48.55,6.81 48.89,6.48 v6(48.89,4.71)
HOST_SD_WP#: length 21.1
  TOP w0.127: RH180.2 18.86,57.2 v7(18.89,57.24) ; RH180.2 17.94,56.28 17.04,57.18 QR1.2 ; RH180.2 v1(18.86,55.2)
  GND2 w0.102: v5(19.21,57.32) 18.98,57.32 v7(18.89,57.24)
  GND3 w0.102: v8(19.97,57.36) 19.94,57.32 v5(19.21,57.32)
  IN3 w0.064: v3(29.97,55.73) 29.97,55.43 29,54.46 29,54.11 28.44,53.55 28.44,53.21 27.88,52.65 25.51,52.65 20.49,57.66 20.28,57.66 v8(19.97,57.36)
  BOTTOM w0.076: v3(29.97,55.73) 29.77,55.73 29.56,55.94 29.56,56.36 UH4.AU44
HUB1_LP_CTL: length 67
  TOP w0.127: UE3.A12 49.79,17.39 50.19,17.79 50.47,17.79 50.82,17.43 51.47,17.43 52.08,18.03 53.98,18.03 54.11,17.9 54.11,16.42 53.71,16.02 53.71,14.64 53.97,14.37 v2(54.24,14.37) ; v2(90.62,9.35) 90.62,7.69 v1(90.32,7.38) 90.32,7.11 89.23,6.02 v2(89.23,5.13) ; v2(100.75,10.94) 100.91,11.11 R5831.2
  IN1 w0.064: v2(54.24,14.37) 54.69,14.37 57.02,12.04 59.77,12.04 62.11,9.7 64.91,9.7 65.51,9.11 67.91,9.11 69.79,7.23 76.26,7.23 76.94,6.55 78.17,6.55 78.48,6.25 80.13,6.25 80.38,6 84.16,6 84.24,5.92 86.85,5.92 87.64,5.13 v2(89.23,5.13) ; v2(100.75,10.94) 100.51,11.17 99.76,11.17 98.52,9.93 97.1,9.93 96.86,10.17 93.87,10.17 93.05,9.35 v2(90.62,9.35)
HUB1_LP_CTL_PCH: length 118.7
  TOP w0.127: v9(98.92,15.77) v1(99.35,15.33) 99.73,14.95 R5832.2
  IN1 w0.064: v9(98.92,15.77) 98.52,16.16 91.93,16.16 90.66,17.44 89.53,17.44 87.83,19.14 86.2,19.14 84.95,20.4 81.64,20.4 80.58,19.34 77.8,19.34 76.57,20.57 75,20.57 74.02,21.56 70.13,21.56 65.15,26.54 58.2,26.54 57.49,27.25 56.09,27.25 55.12,28.21 54.09,28.21 52.33,29.97 47.4,29.97 47.05,29.63 41.1,29.63 38.11,32.62 31.88,32.62 28.67,35.84 27.59,35.84 26.17,37.26 26.17,37.48 25.35,38.3 25.35,41.46 26.23,42.33 26.23,46.88 26.7,47.36 26.7,48.37 26.49,48.58 26.49,50.42 29.17,53.1 29.17,53.86 29.5,54.18 29.82,54.18 29.96,54.33 29.96,54.9 30.68,55.62 30.68,57.6 30.96,57.89 v4(31.28,57.89)
  GND2 w0.102: v5(31.29,58.3) 31.29,57.89 v4(31.28,57.89)
  GND3 w0.102: v6(31.53,58.55) v5(31.29,58.3)
  BOTTOM w0.076: UH4.AJ43 33.83,56.24 34.18,55.88 34.18,55.25 33.94,55.01 32.74,55.01 32.72,54.99 32.51,54.99 32.49,55.01 32.17,55.01 31.85,55.33 31.85,55.58 31.91,55.64 31.91,55.88 31.85,55.94 31.85,55.96 31.84,55.97 31.84,56.21 31.85,56.22 31.85,56.46 31.84,56.47 31.84,56.71 31.85,56.72 31.85,58.23 v6(31.53,58.55)
  BOTTOM w0.127: RH640.1 31.56,60.84 RH639.1 31.52,60.24 31.52,58.56 v6(31.53,58.55)
HUB1_LP_CTL_R: length 13.3
  TOP w0.127: R5832.1 100.29,13.9 R5831.1 v1(100.33,11.89) 100.33,11.13 v2(100.11,10.91)
  IN1 w0.064: v4(107.67,12.74) 107.63,12.74 107.61,12.76 105.96,12.76 104.37,11.17 103.66,11.17 103.02,10.53 100.5,10.53 v2(100.11,10.91)
  GND2 w0.102: v5(107.69,12.36) 107.69,12.72 v4(107.67,12.74)
  GND3 w0.102: v5(107.69,12.36) 108.06,11.99 v6(108.06,11.9)
HUB1_RST#: length 87.8
  TOP w0.127: v2(86.59,3.89) 86.31,4.17 86.31,7.54 86.2,7.64 v1(86.2,7.83) 86.2,9.06 v2(86.31,9.16) ; v2(41.69,1.87) 41.69,4.02 41.06,4.65 41.06,5.29 41.4,5.63 42.24,5.63 42.74,6.14 42.74,8.16 43.15,8.57 UE3.M4
  IN1 w0.064: v2(86.59,3.89) 86.42,3.72 84.77,3.72 84.61,3.57 83.91,3.57 83.73,3.75 82.18,3.75 81.52,3.09 79.13,3.09 78.26,3.96 73.74,3.96 73.12,3.33 70.55,3.33 70.37,3.51 60.54,3.51 59.87,4.18 57.64,4.18 57.17,4.66 53.57,4.66 53.27,4.36 51.13,4.36 50.96,4.53 50.14,4.53 49.25,3.64 49.25,3.48 47.64,1.87 v2(41.69,1.87) ; v2(86.31,9.16) 86.59,8.88 88.02,8.88 88.09,8.81 93.11,8.81 94.05,9.75 96.69,9.75 96.93,9.51 99.27,9.51 99.87,10.11 103.27,10.11 103.64,10.47 104.26,10.47 105.89,12.1 106.84,12.1 107.08,12.34 108.85,12.34 109.31,12.8 v4(109.31,12.85)
  GND2 w0.102: v5(109.31,12.4) v4(109.31,12.85)
  GND3 w0.102: v6(109.06,12.9) 109.06,12.65 v5(109.31,12.4)
I2C0_SCK_TS: length 64.6
  TOP w0.127: v1(52.68,97.75) 53.2,97.22 v2(53.63,97.22) 54.11,96.75 RR16.1
  IN1 w0.064: v2(53.63,97.22) 52.87,97.22 52.64,97 43.37,97 42.83,96.46 42.83,92.06 43.63,91.26 43.63,86.44 44.68,85.4 44.68,71.78 42.19,69.29 42.19,64.53 40.38,62.73 40.38,62.21 38.51,60.34 37.63,60.34 35.7,58.41 34.93,58.41 33.49,56.97 32.48,56.97 30.21,54.7 v4(30.21,54.13)
  GND2 w0.102: v5(30.3,53.8) 30.3,54.04 v4(30.21,54.13)
  GND3 w0.102: v6(30.64,53.76) 30.35,53.76 v5(30.3,53.8)
I2C0_SDA_TS: length 64.1
  TOP w0.127: RR15.1 54.52,96.61 v2(54.52,97.22)
  IN1 w0.064: v2(54.52,97.22) 54.25,97.49 52.85,97.49 52.5,97.14 43.31,97.14 42.66,96.49 42.66,92.02 43.48,91.19 43.48,86.39 44.54,85.34 44.54,71.84 42.05,69.35 42.05,64.61 40.24,62.8 40.24,62.27 38.46,60.49 37.58,60.49 35.66,58.57 34.88,58.57 33.46,57.14 v4(31.1,57.14)
  GND2 w0.102: v4(31.1,57.14) 30.98,57.26 v5(30.98,57.46)
  GND3 w0.102: v6(30.71,57.74) v5(30.98,57.46)
  BOTTOM w0.076: v6(30.71,57.74) 30.71,57.41 30.69,57.39 30.69,56.41 30.61,56.33 30.61,56.1 30.4,55.89 UH4.AT42
I2C1_SCK_TP: length 119.8
  IN3 w0.064: v3(28.58,4.47) 28.48,4.37 25.28,4.37 24.31,5.34 18.27,5.34 14.32,9.29 13.3,9.29 11,6.99 6.8,6.99 3.45,10.34 3.45,16.5 5.26,18.31 5.26,20.71 4.48,21.49 v9(4.48,22.91) 4.48,26.75 5.3,27.57 5.3,33.01 5.93,33.64 5.93,37.22 5.31,37.84 5.31,47.5 5.64,47.83 5.64,53.28 2.72,56.19 2.72,58.44 3.04,58.76 4.82,58.76 7.01,60.95 15.68,60.95 16.97,62.24 24.18,62.24 25.19,61.22 28.85,61.22 29.16,60.92 29.16,59.73 29.31,59.58 30.09,59.58 30.3,59.37 30.3,59.37 30.3,57.66 30.77,57.18 30.77,56.71 30.64,56.58 v3(30.64,55.28)
  BOTTOM w0.127: v3(28.58,4.47) 28.58,6.97 28.42,7.14 JKB1.20
I2C1_SDA_TP: length 75.6
  TOP w0.127: v9(29.59,60.74) 29.85,60.48 v1(29.85,60.11)
  IN1 w0.064: v9(29.59,60.74) 29.12,60.27 29.12,59.54 23.69,54.12 23.69,45.25 22.89,44.45 22.89,36.96 23.76,36.09 23.76,34.46 25.98,32.24 28.62,32.24 29.01,31.86 29.01,28.26 31.1,26.17 31.1,21.88 29.92,20.7 29.3,20.7 v4(22.06,13.46)
  GND2 w0.102: v4(22.06,13.46) 21.77,13.17 v5(21.76,13.17)
  GND3 w0.102: v5(21.76,13.17) v8(21.76,12.78)
  IN3 w0.064: v3(26.84,8.63) 26.84,8.95 25.8,9.99 24.59,9.99 21.8,12.78 v8(21.76,12.78)
  BOTTOM w0.076: 30.92,58.76 30.92,58.41 31.17,58.16 31.17,57.02 30.94,56.79 UH4.AR44
  BOTTOM w0.127: v3(26.84,8.63) 28.64,8.63 28.92,8.36 JKB1.19 ; v9(29.59,60.74) 30.11,60.22 30.8,60.22 30.82,60.19 30.82,60.19 30.92,60.09 30.92,60.09 30.92,58.76
I2C2_IRQ_TS: length 67.6
  TOP w0.127: v7(35.82,54.89) 36.02,55.09 RH654.1 ; v1(54.07,93.3) 54.07,93.49 53.68,93.88 v2(53.67,93.88) 53.67,94.37 53.18,94.86 53.18,96 53,96.18 51.55,96.18 51.25,96.48 51.25,98.3 54.59,101.63 54.59,102.9 54.98,103.29 QV11.3
  IN1 w0.064: v4(38.96,55.12) 38.97,55.12 40.1,56.25 40.1,57.16 43.52,60.57 43.52,61.52 45.08,63.08 45.08,68.16 47.95,71.02 47.95,84.44 48.9,85.39 48.9,88.33 51.77,91.2 51.77,91.73 53.67,93.63 v2(53.67,93.88)
  GND2 w0.102: v7(35.82,54.89) 35.73,54.89 v5(35.51,55.11) ; v5(38.71,54.87) v4(38.96,55.12)
  GND3 w0.102: v5(35.51,55.11) 35.3,54.91 v6(35.23,54.91) ; v5(38.71,54.87) v6(39.01,54.57)
  BOTTOM w0.076: v6(39.01,54.57) 38.61,54.17 36.98,54.17 36.24,54.91 v6(35.23,54.91) 34.88,54.91 34.62,55.17 34.62,55.53 34.72,55.63 34.72,55.9 34.92,56.1 UH4.AG43
I2C2_IRQ_TS_Q: length 7.5
  TOP w0.127: RR17.1 53.3,96.55 52.28,97.57 52.28,99.04 54.34,101.1 RR44.2 54.98,101.11 QV11.4
I_ADP: length 34.8
  TOP w0.127: v7(49.15,16.99) UE3.B11
  TOP w0.254: PR537.2 54.01,2.14 54.07,2.2 54.07,3.33 v2(54.64,3.9) ; v2(57.1,4.36) 57.1,5.55 59.18,7.63 61.13,7.63 v1(63.58,10.07) v2(64.53,11.02)
  IN1 w0.254: v7(49.15,16.99) 49.41,17.25 53.97,17.25 54.39,16.83 54.77,16.83 55.13,16.47 55.13,15.45 57.44,13.14 61.67,13.14 63.79,11.02 v2(64.53,11.02) ; v2(54.64,3.9) 55.1,4.36 v2(57.1,4.36)
I_BATT: length 21.3
  TOP w0.254: v7(37.18,7.03) 36.76,7.45 RE125.2 ; v9(39.14,3.25) 39.33,3.25 41.27,1.31 43.02,1.31 v1(43.09,1.38) 43.15,1.31 52.32,1.31 53.13,2.13 PR536.2
  GND2 w0.254: v5(37.82,6.86) 37.62,7.06 37.21,7.06 v7(37.18,7.03)
  GND3 w0.254: v6(38.17,6.69) 37.99,6.86 v5(37.82,6.86)
  BOTTOM w0.254: v9(39.14,3.25) 38.65,3.25 38.17,3.73 v6(38.17,6.69)
I_BATT_R: length 8.8
  TOP w0.254: v2(37.77,9.16) 37.77,8.46 CE60.1 RE125.1 ; v7(42.76,10.42) 42.76,10.66 43.09,10.99 UE3.J4
  IN1 w0.254: v7(42.76,10.42) 42.38,10.42 42.12,10.17 41.86,10.17 41.63,9.94 41.63,9.53 40.69,8.59 39.88,8.59 39.31,9.16 v2(37.77,9.16)
I_LIM_SEL_P1#: length 10.1
  TOP w0.127: QP3.2 37.63,68.44 37.41,68.66 v2(37.33,68.66)
  IN1 w0.064: v2(37.33,68.66) 37.33,68.66 37.33,68.84 37.07,69.09 37.07,69.52 36.29,70.3 35.96,70.3 35.85,70.19 35.85,69.81 35.93,69.72 35.93,66.16 35.46,65.69 v4(34.54,65.69)
  GND2 w0.102: v4(34.54,65.69) 34.19,65.69 v5(34.12,65.61)
  GND3 w0.102: v5(34.12,65.61) 34.18,65.68 v6(34.18,66.03)
I_LIM_SEL_P2#: length 9.7
  TOP w0.127: v2(37.33,69.3) 37.73,69.3 37.79,69.24 QP4.2
  IN1 w0.064: v4(34.38,66.25) 34.66,65.97 35.55,65.97 35.79,66.22 35.79,69.66 35.71,69.75 35.71,70.24 35.9,70.44 36.35,70.44 37.33,69.46 v2(37.33,69.3)
  GND2 w0.102: v5(34.68,66.39) 34.54,66.25 v4(34.38,66.25)
  GND3 w0.102: v6(34.68,66.03) v5(34.68,66.39)
I_SYS: length 211.9
  TOP w0.127: RE126.2 34.43,11.27 v9(34.43,11.43) ; v1(134.08,36.91) 134.4,37.23 v9(134.54,37.23)
  TOP w0.203: PR526.2 169.1,7.89 v2(169.08,7.88)
  TOP w0.254: v9(134.54,37.23) 134.66,37.23 135.03,36.85 PR1136.1
  IN1 w0.064: v4(161.92,14.66) 161.92,14.05 162.68,13.29 162.92,13.29 166.23,9.99 166.23,9.15 167.5,7.88 v2(169.08,7.88) 169.4,7.88 171.17,6.11 171.17,2.7 170.56,2.09 167.25,2.09 166.67,2.67 165.91,2.67 164.77,3.82 154.02,3.82 153.03,2.83 149.56,2.83 147.57,4.81 130.7,4.81 128.16,7.35 126.66,7.35 124.53,5.23 109.77,5.23 107.61,4.33 106.79,3.51 106.79,2.55 106.39,2.15 101.43,2.15 99.96,3.61 96.73,3.61 95.27,2.15 91.75,2.15 91.48,2.43 89.97,2.43 89.7,2.15 83.99,2.15 83.83,2.3 82.86,2.3 82.7,2.15 73.39,2.15 73.29,2.25 60.2,2.25 v4(60,2.45)
  GND2 w0.102: v5(59.75,2.71) v4(60,2.45) ; v4(161.92,14.66) 161.46,14.66 v5(161.29,14.84)
  GND3 w0.102: v8(59.46,2.99) v5(59.75,2.71) ; v8(161.46,15.2) 161.29,15.02 v5(161.29,14.84)
  IN3 w0.064: v8(59.46,2.99) 58.89,3.56 57.25,3.56 56.72,4.1 56.15,4.1 55.16,5.08 53.82,5.08 52.83,6.08 51.01,6.08 50.52,5.58 46.67,5.58 46.08,6.17 45.87,6.17 45.36,6.67 45.36,9.43 45.6,9.67 45.6,9.67 45.6,10.11 44.24,11.47 40.01,11.47 39.87,11.33 34.52,11.33 v9(34.43,11.43) ; v8(161.46,15.2) 160.91,15.75 160.91,17.91 159.21,20.45 159.06,20.73 158.66,21.4 157.09,24.33 156.74,25.18 156.62,25.41 155.71,27.6 154.59,28.72 150.73,28.72 148.88,30.56 v3(148.88,30.73) ; v9(134.54,37.23) 139.2,37.23 141.25,35.18 142.85,35.18 144.31,33.72 144.31,32.73 145.33,31.71 v3(146.59,31.71)
  BOTTOM w0.127: v3(148.88,30.73) 147.71,31.91 146.8,31.91 v3(146.59,31.71)
I_SYS_R: length 10.8
  TOP w0.127: CE61.1 35.99,10.88 RE126.1 35.82,10.71 35.82,10.05 RE159.1 36.01,9.99 36.25,10.22 v2(36.42,10.22) ; UE3.J5 43.91,10.95 v7(43.58,10.95)
  IN1 w0.064: v2(36.42,10.22) 36.6,10.41 39.47,10.41 39.54,10.33 40.26,10.33 41.48,11.55 43,11.55 43.58,10.96 v7(43.58,10.95)
ILMT_1VALWP: length 4.8
  BOTTOM w0.203: PR706.2 PR707.1 13.27,53.22 12.77,52.72 12.77,50.74 12.33,50.3 PU700.13
ILMT_+0.95VSP: length 4.6
  TOP w0.254: PR1010.1 PR1008.2 v1(106.27,25.61) 105.58,26.29 105.58,27.08 105.28,27.39 PU1000.13
ILMT_VDD08: length 1.9
  BOTTOM w0.254: PR2332.1 151.53,91.06 PR2333.2 151.27,90.22 PU2304.13
IMVP_VR_ON_EC: length 64.5
  TOP w0.127: v2(22.35,10.14) 22.35,9.05 v1(23.07,8.32) 24.29,7.11 v2(24.29,2.81) ; v7(45.29,7.26) 45.55,7.52 UE3.N7 ; UZ11.1 38.14,31.22 RE293.2 32.48,31.45 31.68,30.65 v2(31.68,28.58)
  IN1 w0.064: v2(22.35,10.14) 22.35,11.36 25.93,14.95 25.93,16.44 26.69,17.2 27.66,17.2 30.16,19.71 30.26,19.71 31.99,21.44 31.99,28.28 v2(31.68,28.58) ; v7(45.29,7.26) 44.61,6.58 43.85,6.58 42.34,5.07 37.95,5.07 35.94,3.06 24.54,3.06 v2(24.29,2.81)
IMVP_VR_PG: length 171.6
  TOP w0.127: v9(73.43,9.43) 73.43,11.26 73.63,11.46 74.14,11.46 74.77,12.09 75.58,12.09 78.88,15.39 v1(78.88,16.59) 78.88,17.86 81.29,20.27 81.29,22.52 v2(81.35,22.59) ; PR1122.1 141.95,47.97 142.31,47.61 v2(142.31,47.53)
  IN1 w0.064: v2(81.35,22.59) 81.37,22.6 85.42,22.6 85.87,22.14 87.8,22.14 90.4,19.55 94.15,19.55 94.57,19.13 98.85,19.13 99.64,18.34 102.96,18.34 105.94,21.32 108.69,21.32 110.81,19.2 113.93,19.2 114.16,18.96 115.29,18.96 115.86,18.4 120.41,18.4 120.69,18.68 123.7,18.68 125.1,17.28 128.78,17.28 133.42,21.92 133.42,22.36 134.73,23.67 135.33,23.67 135.85,24.19 135.85,26.28 139.97,30.39 144.85,30.39 147.68,33.22 147.68,33.61 149.02,34.94 149.02,38 148.64,38.37 148.64,41.82 142.93,47.53 v2(142.31,47.53)
  BOTTOM w0.127: v9(73.43,9.43) 72.56,9.43 69.94,12.05 61.51,12.05 55.23,18.32 47.98,18.32 47.25,19.04 37.15,19.04 29.22,26.98 26.92,26.98 26.77,27.13 26.77,28.45 26.03,29.19 UH7.1
INTRUDER#: length 10
  IN3 w0.064: v3(22.98,41.13) 22.82,40.96 22.15,40.96 21.85,41.27 20.15,41.27 19.9,41.52 19.09,41.52 v3(18.83,41.25)
  BOTTOM w0.076: UH4.BE11 25.85,40.54 24,40.54 23.86,40.68 v1(23.4,40.68) 22.98,41.1 v3(22.98,41.13)
  BOTTOM w0.127: v3(18.83,41.25) 18.34,41.74 18.34,42.37 17.83,42.88 17.82,42.87 RH115.1
INV_PWM: length 3.2
  TOP w0.127: DV6.1 61.93,92.69 v1(61.93,92.91) 61.93,93.28 v7(62.43,93.77)
  GND2 w0.102: v5(62.33,94.27) 62.43,94.16 v7(62.43,93.77)
  GND3 w0.102: v6(61.91,94.24) 62.3,94.24 v5(62.33,94.27)
IRCAM_EN: length 286.6
  TOP w0.127: v7(43.17,33.99) 43.2,33.99 43.57,34.36 43.92,34.36 44.99,35.43 44.99,54.79 44.39,55.38 43.83,55.38 41.91,57.31 v2(38.76,57.31)
  IN1 w0.064: v2(38.76,57.31) 38.78,57.29 39.19,57.29 39.79,57.88 39.79,58.48 40.61,59.3 41.25,59.3 42.08,60.13 42.82,60.88 42.82,61.81 44.38,63.36 44.38,68.45 47.25,71.31 47.25,87.28 47.51,87.54 47.51,88.91 48.42,89.82 49.28,89.82 51.13,91.68 51.13,91.88 52.99,93.74 52.99,94.17 53.6,94.78 54.03,94.78 54.8,95.55 55.45,95.55 56.06,96.16 62.35,96.16 63.14,95.38 66.74,95.38 67.61,94.51 69.48,94.51 v4(69.63,94.66)
  GND2 w0.102: v5(69.78,94.32) 69.78,94.5 v4(69.63,94.66) ; v7(43.17,33.99) v5(43.17,33.46) ; v5(139.11,82.81) 139.11,82.63 v7(138.86,82.38)
  IN2 w0.074: v5(139.11,82.81) 139.11,84.67 139.4,84.97 139.4,86.7 138.52,87.58 122.74,87.58 122.08,88.25 121.02,88.25 120.36,87.58 119.62,87.58 119.15,88.05 116.91,88.05 116.51,87.65 110.27,87.65 109.76,88.16 92.88,88.16 92.46,88.57 84.02,88.57 83.31,89.29 82.33,89.29 81.62,90 79.09,90 79.04,90.05 79.04,91.33 78.58,91.79 78.58,92.57 78.82,92.8 78.82,93.77 78.65,93.94 72.56,93.94 72.07,93.45 70.65,93.45 v5(69.78,94.32) ; v5(43.17,33.46) 43.17,31.36 42.57,30.75 42.57,25.53 43.57,24.53 44.15,24.53 45.52,23.16 47.33,23.16 47.71,23.55 52.41,23.55 52.84,23.11 56.57,23.11 57.36,22.32 60.97,22.32 61.37,22.71 61.67,22.71 61.92,22.97 64.04,22.97 64.47,22.53 73.52,22.53 73.94,22.95 74.63,22.95 v5(74.7,22.89)
  GND3 w0.102: v5(74.7,22.89) 74.7,22.55 v6(74.76,22.49)
  BOTTOM w0.127: RE430.1 RE431.1 46.8,10.74 47.06,10.99 47.56,10.99 47.84,10.71 47.84,10.07 48.91,9.01 50.13,9.01 51.4,10.27 51.4,13.41 51.82,13.84 v1(52.81,13.84) 53.27,13.37 53.27,12.98 53.71,12.54 59,12.54 61.95,9.59 65.31,9.59 69,5.9 77.8,5.9 78.21,5.49 78.21,2.53 78.51,2.23 79.96,2.23 80.2,2.48 80.2,4.91 82.29,7 82.29,8 80.39,9.9 80.39,11.15 76.09,15.45 76.09,17.98 76.53,18.42 76.53,19.35 74.76,21.12 v6(74.76,22.49)
ISH_I2C0_SCK: length 13
  IN3 w0.064: v3(20.1,61.32) 20.31,61.53 23.48,61.53 23.64,61.38 23.64,61.11 v3(23.44,60.92) 23.63,60.72 23.63,57.24 25.12,55.76 25.12,55.18 26.12,54.18 26.41,54.18 v3(26.6,53.98)
  BOTTOM w0.076: UH4.BC38 26.78,53.8 v3(26.6,53.98)
ISH_I2C0_SCK_R: length 136.6
  GND2 w0.102: v7(12.93,21.16) v5(12.93,21.57)
  IN2 w0.074: v5(12.93,21.57) 12.93,21.66 12.67,21.92 12.21,21.92 11.84,22.29 11.84,23.79 12.52,24.48 16.89,24.48 19.34,22.03 25.43,22.03 27.67,19.78 30.94,19.78 31.16,19.57 31.16,18.81 v5(31.41,18.56) 31.15,18.3 31.15,18.18 31.22,18.11 34.4,18.11 35.89,16.62 49.83,16.62 50.19,16.26 53.46,16.26 54.16,15.56 57.11,15.56 57.59,15.08 65.77,15.08 67.22,16.53 67.22,17.61 66.53,18.3 v5(64.74,18.3)
  GND3 w0.102: v5(12.93,21.57) 12.93,21.75 v8(12.7,21.98) ; v5(31.41,18.56) 31.23,18.56 31.04,18.37 v6(31.02,18.37) ; v6(64.55,18.62) 64.55,18.49 v5(64.74,18.3)
  IN3 w0.064: v8(12.7,21.98) 12.61,21.89 11.85,21.89 10.69,23.04 7.4,23.04 6.47,23.98 6.47,31.77 7.16,32.47 7.16,35.09 6.44,35.81 6.44,37.43 6.31,37.56 6.31,55.53 8.36,57.58 12.91,57.58 15.14,55.35 18.04,55.35 18.76,56.07 18.76,58.71 19.2,59.15 19.2,61.46 19.27,61.53 19.42,61.53 19.52,61.44 v3(19.52,61.32)
  BOTTOM w0.127: v6(31.02,18.37) 31.09,18.43 31.28,18.43 31.53,18.18 v10(31.53,17.23) 31.53,15.28 32.63,14.19 32.63,13.57 R5838.1 ; v6(64.55,18.62) 64.55,18.7 R373.1
ISH_I2C0_SDA: length 13.7
  IN3 w0.064: v3(27.48,53.68) 27.29,53.68 26.6,54.37 26.2,54.37 25.31,55.26 25.31,55.84 23.82,57.32 23.82,60.71 v3(24.02,60.92) 23.83,61.11 23.83,61.45 23.56,61.72 20.31,61.72 v3(20.1,61.93)
ISH_I2C0_SDA_R: length 137.8
  GND2 w0.102: v7(12.93,23.07) 12.93,22.79 v5(12.81,22.68)
  IN2 w0.074: v5(69.26,16.35) 69.28,16.35 69.09,16.54 69.05,16.54 67.98,17.61 67.61,17.61 67.42,17.42 67.42,16.45 65.85,14.88 57.5,14.88 57.02,15.36 54.08,15.36 53.37,16.06 50.11,16.06 49.75,16.42 35.81,16.42 34.32,17.91 31.14,17.91 30.95,18.1 30.95,18.25 v5(30.63,18.56) 30.96,18.88 30.96,19.48 30.86,19.58 27.59,19.58 25.34,21.83 19.25,21.83 16.81,24.28 12.61,24.28 12.04,23.7 12.04,22.37 12.29,22.12 12.67,22.12 12.81,22.26 v5(12.81,22.68)
  GND3 w0.102: v8(13.03,22.31) 12.81,22.52 v5(12.81,22.68) ; v5(30.63,18.56) 30.82,18.56 31.01,18.75 v6(31.02,18.75) ; v5(69.26,16.35) 69,16.62 v6(69,16.66)
  IN3 w0.064: v8(13.03,22.31) 13.03,21.85 12.87,21.7 11.77,21.7 10.61,22.85 7.32,22.85 6.28,23.9 6.28,31.85 6.97,32.55 6.97,35.01 6.25,35.73 6.25,37.35 6.12,37.48 6.12,55.61 8.28,57.77 12.99,57.77 15.22,55.54 17.96,55.54 18.57,56.15 18.57,58.79 19.01,59.23 19.01,61.54 19.19,61.72 19.42,61.72 19.52,61.82 v3(19.52,61.93)
  BOTTOM w0.127: v6(31.02,18.75) 31.09,18.69 31.38,18.69 31.78,18.28 v10(31.78,15.77) 31.78,15.39 32.88,14.29 32.88,13.61 R5839.1 ; R370.1 68.93,16.72 v6(69,16.66)
JTAG_CLK: length 17.8
  GND2 w0.102: v5(46.63,16) 46.43,15.79 v7(46.35,15.79)
  GND3 w0.102: v5(46.63,16) 46.57,16 46.21,15.64 v8(46.17,15.64)
  IN3 w0.064: v8(46.17,15.64) 46.18,15.64 48.72,13.1 48.72,12.46 51.96,9.21 51.96,9.11 v3(52.16,8.92)
  BOTTOM w0.127: RPE7.3 52.41,9.16 v3(52.16,8.92) 51.98,8.92 51.18,8.11 51.18,7.86 50.89,7.56 v16(50.89,6.37) JDEG1.4
JTAG_RST#: length 6.2
  TOP w0.127: UE3.G13 50.76,12.59 51.56,11.79 RE164.1 53.21,11.79 53.23,11.82 CE63.1 53.77,12.02 JTAG2.1 54.73,11.61 54.03,10.92 RE156.1
JTAG_TDI: length 16.4
  GND2 w0.102: v7(47.15,14.19) 47.33,14.37 47.33,14.5 v5(47.28,14.55) ; v5(52.42,8.1) 52.41,8.1 v7(52.04,8.46)
  GND3 w0.102: v6(52.04,8.1) v5(52.42,8.1) ; v8(47.11,14.2) 47.28,14.37 v5(47.28,14.55)
  IN3 w0.064: v6(52.04,8.1) 51.7,8.43 51.7,9.28 48.58,12.41 48.58,13.05 47.42,14.2 v8(47.11,14.2)
  BOTTOM w0.127: JDEG1.2 51.89,7.95 52.03,8.1 v6(52.04,8.1) 54.14,8.1 54.2,8.16 RPE7.1
