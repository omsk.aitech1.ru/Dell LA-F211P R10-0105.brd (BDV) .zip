# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_SLP_S4#: length 147.1
  TOP w0.127: v2(73.83,20.79) 73.07,20.03 73.07,16.36 72.6,15.9 72.6,14.34 69.31,11.06 v1(69.31,6.62) 69.31,5.22 v2(69.34,5.19) ; UZ16.2 49.95,25.86 50.07,25.99 50.07,27.25 v2(50.26,27.44) ; UE3.N12 49.64,7.71 v9(49.64,6.42) ; JAPS1.5 v2(75.83,5.07)
  IN1 w0.064: v2(73.83,20.79) 73.62,21 69.91,21 64.92,25.98 57.96,25.98 57.32,26.63 55.92,26.63 55.23,27.32 50.38,27.32 v2(50.26,27.44) ; v2(75.83,5.07) 75.4,5.5 72.32,5.5 72.14,5.31 69.71,5.31 69.59,5.19 v2(69.34,5.19) 69.04,5.19 68.79,4.95 61.4,4.95 60.25,6.1 56.2,6.1 56.1,6.19 53.6,6.19 52.83,6.97 50.18,6.97 v9(49.64,6.42)
  IN3 w0.064: v3(23.01,42.8) 22.88,42.68 22.41,42.68 21.55,43.54 19.51,43.54 18.44,42.47 18.44,41.65 18.14,41.36 18.14,40.35 19.16,39.33 19.16,35.84 19.9,35.1 19.9,34.6 24.76,29.75 24.76,29.55 26.82,27.48 26.82,27.1 27.19,26.74 27.53,26.74 29.31,24.96 29.31,23.29 28.22,22.2 28.22,19.61 28.54,19.28 28.54,18.02 32.01,14.55 32.01,13.45 33.64,11.82 35.4,11.82 35.7,11.51 39.85,11.51 39.96,11.61 42.54,11.61 43.31,12.38 44.6,12.38 46.4,10.58 46.4,9.68 45.92,9.19 45.92,7.75 46.92,6.75 49.31,6.75 v9(49.64,6.42)
  BOTTOM w0.076: v3(23.01,42.8) 23.01,42.6 23.19,42.42 25.06,42.42 25.22,42.27 26.1,42.27 26.17,42.2 UH4.BD15
SIO_SLP_S5#: length 96.4
  TOP w0.127: JAPS1.4 75.33,4.58 74.86,4.11 v9(74.86,3.56) ; v7(32.84,21.85) 34.26,23.27 35.35,23.27 36.54,24.47 v1(37.82,24.47) 39.96,24.47 RZ42.1 40.03,24.63 DZ1.3
  GND2 w0.102: v7(46.35,7.79) v5(46.78,7.79) ; v7(32.84,21.85) 32.64,22.05 v5(32.55,22.05)
  GND3 w0.102: v5(46.78,7.79) 47.05,7.79 47.18,7.92 v8(47.2,7.92) ; v8(32.55,22.39) v5(32.55,22.05)
  IN3 w0.064: v9(74.86,3.56) 74.56,3.86 61.13,3.86 59.56,5.43 56.67,5.43 55.71,6.39 54.37,6.39 53.37,7.38 50.14,7.38 49.7,7.83 47.3,7.83 v8(47.2,7.92) 47.2,7.93 47.2,8.5 47.57,8.87 47.57,11.06 45.71,12.92 45.71,13.62 45.51,13.82 41.26,13.82 40.39,14.69 37.95,14.69 33.51,19.13 33.51,20.75 32.55,21.72 v8(32.55,22.39) 32.55,26.63 27.14,32.04 26.87,32.04 26.2,32.71 25.44,32.71 23.75,34.39 23.75,35.43 23.43,35.75 23.43,38.02 26.44,41.03 27.71,41.03 v6(27.95,41.27)
SIO_SLP_SUS#: length 208.3
  TOP w0.127: v2(42.39,4.2) v1(42.39,2.5) ; QE25.2 68.81,94.21 69.29,94.7 69.72,94.7 70,94.98 70,95.48 69.67,95.81 v7(69.31,95.81)
  IN1 w0.064: v7(69.31,95.81) 69.03,95.81 66.81,98.04 59.43,98.04 59.1,98.37 52.94,98.37 52.27,97.7 43.08,97.7 42.06,96.68 42.06,91.81 42.88,90.98 42.88,86.15 43.95,85.08 43.95,73.7 42.39,72.13 42.39,71.02 41.34,69.97 41.34,66.12 39.54,64.32 39.54,62.6 38.13,61.19 37.24,61.19 36.05,60 33.06,60 32.25,59.2 29.95,59.2 27.74,56.99 27.74,55.47 27.28,55.02 27.28,53.86 25.6,52.18 v4(25.07,52.18) 24.16,51.28 24.16,44.9 23.55,44.29 v4(23.55,41.8) ; v4(46.37,8.15) 46.21,8.15 46.07,8.01 46.07,7.56 46.34,7.29 46.34,6.57 46.01,6.24 45.14,6.24 43.1,4.2 v2(42.39,4.2)
  GND2 w0.102: v4(23.55,41.8) 23.89,41.8 v5(24.06,41.63) ; v5(25.43,52.34) 25.27,52.18 v4(25.07,52.18) ; v7(69.31,95.81) v5(68.96,95.81) ; v4(46.37,8.15) 46.43,8.15 v5(46.64,8.36)
  IN2 w0.074: v5(73.61,83.65) 72.7,83.65 67.87,88.48 67.87,89.72 67.43,90.15 67.43,95.05 68.2,95.81 v5(68.96,95.81)
  GND3 w0.102: v5(25.43,52.34) v8(25.07,52.34) ; v8(46.92,8.63) 46.9,8.63 46.64,8.38 v5(46.64,8.36) ; v5(24.06,41.63) 24.12,41.57 v6(24.5,41.57) ; v6(73.61,83.22) v5(73.61,83.65)
  IN3 w0.064: v8(46.92,8.63) 47.43,9.14 47.43,11.01 45.57,12.87 45.57,13.56 45.46,13.68 41.2,13.68 40.4,14.48 39.24,14.48 38.74,13.98 36.38,13.98 35.83,14.53 35.83,16.02 32.95,18.9 32.95,20.52 31.84,21.63 31.84,26.3 30.84,27.3 30.48,27.3 29.38,28.4 29.38,28.81 26.55,31.64 26.28,31.64 25.92,32 25.55,32 22.99,34.56 22.7,34.56 v3(22.39,34.88) 22.39,35.9 23.02,36.53 23.02,38.2 24.71,39.89 24.71,41.36 v6(24.5,41.57) ; v3(14.08,55.91) 14.96,55.03 16.86,55.03 19.56,52.34 21.18,52.34 22.45,53.61 23.8,53.61 v8(25.07,52.34)
  BOTTOM w0.076: UH4.BB13 27.15,41.33 27.04,41.44 26.17,41.44 26.1,41.37 24.7,41.37 v6(24.5,41.57)
  BOTTOM w0.127: PR703.1 v3(14.08,55.91) ; PR1500.1 71.56,84.16 72.4,83.32 73.5,83.32 v6(73.61,83.22) ; RZ58.1 18.41,30.69 18.07,31.03 18.07,32.66 18.92,33.51 18.92,33.88 19.16,34.12 20.63,34.12 20.76,34.25 20.87,34.35 20.92,34.35 21.76,34.35 22.3,34.88 v3(22.39,34.88)
SIO_SLP_WLAN#: length 84.5
  IN3 w0.064: v3(82.87,2.87) 82.55,2.87 81.59,3.83 78.3,3.83 77.75,4.38 61.37,4.38 59.8,5.95 56.88,5.95 55.48,7.35 54.19,7.35 49.98,11.56 49.98,14.82 49.18,15.63 48.59,15.63 48.17,16.05 48.05,16.05 46.57,17.52 38.08,17.52 35.75,19.85 35.75,21.74 35.26,22.23 35.26,24.64 35.05,24.84 35.05,28.86 33.17,30.74 33.17,32.6 29.82,35.95 29.82,37.9 29.38,38.33 29.38,39.43 29.69,39.73 29.69,40.42 29.48,40.63 v6(29.48,41.27)
  BOTTOM w0.127: v3(82.87,2.87) v1(84.74,2.87) 85.69,3.82 Q5.1
SLP_WLAN#_GATE: length 46.3
  TOP w0.127: UE3.K10 v2(48.35,9.8)
  IN1 w0.064: v4(86.56,5.02) 86.3,4.76 85.46,4.76 85,5.23 83.95,5.23 83.87,5.3 80.09,5.3 79.84,5.55 78.19,5.55 77.89,5.85 76.65,5.85 76.31,6.2 72.03,6.2 71.85,6.01 68.41,6.01 67.29,7.14 62.5,7.14 62.2,7.44 57.42,7.44 57.04,7.82 53.37,7.82 52.09,9.1 51.17,9.1 50.9,9.37 48.73,9.37 48.35,9.75 v2(48.35,9.8)
  GND2 w0.102: v5(86.94,5.02) v4(86.56,5.02)
  GND3 w0.102: v6(86.94,5.42) v5(86.94,5.02)
  BOTTOM w0.127: Q5.2 v6(86.94,5.42) 86.44,5.42 85.58,6.28 R1194.2 85.6,6.43 85.93,6.76 85.93,7.69 v1(85.62,8)
SLP_WLAN#_M: length 2.2
  BOTTOM w0.127: Q5.3 87.58,4.11 R5828.1 86.86,2.95 v1(86.65,2.75)
SLP_WLAN#_M_R: length 30.6
  IN3 w0.064: v3(84.96,8.61) 85.22,8.35 86.45,8.35 86.87,8.78 94.47,8.78 94.65,8.6 98.42,8.6 99.76,9.94 102.34,9.94 102.86,10.47 103.52,10.47 v6(103.57,10.51)
  BOTTOM w0.127: R5829.2 R5828.2 86.59,2.37 86.33,2.62 86.33,4.95 85.73,5.55 84.99,5.55 v1(84.55,5.99) 84.55,6.94 84.86,7.25 84.86,8.52 v3(84.96,8.61) ; v6(103.57,10.51) 103.56,10.52 103.56,11.26 104.06,11.77 JIO1.J11
SM_PG_CTRL: length 27.4
  TOP w0.127: v2(76.68,94.95) 76.93,94.7 v1(77.25,94.7) PR805.1
  IN1 w0.064: v2(76.68,94.95) v4(73.73,94.95)
  GND2 w0.102: v4(73.73,94.95) v5(73.35,94.95)
  GND3 w0.102: v8(73,94.9) 73.05,94.95 v5(73.35,94.95)
  IN3 w0.064: v8(73,94.9) 73,95.61 77.21,99.82 77.21,101.25 78.45,102.5 78.45,103.41 80.25,105.21 80.25,107.04 82.7,109.49 82.7,110.01 v3(82.95,110.27)
  BOTTOM w0.127: RH59.2 82.44,110.78 v3(82.95,110.27)
  BOTTOM w0.254: RH59.2 80.81,110.78 UC6.4
SM_RCOMP0: length 4.4
  BOTTOM w0.305: RC20.1 92.62,88.03 91.54,86.95 90.73,86.95 90.37,86.59 90.37,86.19 89.95,85.77 UC1.AC2
SM_RCOMP1: length 3.2
  BOTTOM w0.305: RC26.1 91.73,88.21 91.11,87.59 90.57,87.59 89.89,86.9 UC1.AC1
SM_RCOMP2: length 4.4
  BOTTOM w0.305: RC14.1 90.75,88.52 89.33,87.1 89.33,85.53 89.73,85.12 UC1.AC3
SMBCLK: length 4.3
  BOTTOM w0.076: 28.04,58.31 28.57,57.78 28.57,56.86 UH4.AW44
  BOTTOM w0.127: 28.04,58.31 27.09,59.26 RH139.2
SMBDAT: length 3.4
  TOP w0.127: RH140.2 27.28,58.27 v1(28.08,57.47) 28.27,57.28 v7(28.27,56.9)
  GND2 w0.102: v5(27.99,56.72) 28.09,56.72 v7(28.27,56.9)
  GND3 w0.102: v5(27.99,56.72) 27.94,56.72 v6(27.68,56.47)
  BOTTOM w0.076: v6(27.68,56.47) 27.67,56.47 UH4.BB43
SML1_SMBCLK: length 73.4
  IN1 w0.064: v4(23.42,35.97) 22.51,36.87 22.51,42.31 22.1,42.72 22.1,45.06 23.24,46.2 23.24,54.12 23.76,54.64 23.76,55.54 28.2,59.98 28.5,59.98 v6(28.8,60.28)
  GND2 w0.102: v5(24.55,36.04) 24.47,35.97 v4(23.42,35.97) ; v5(28.74,59.9) 28.74,60.22 v6(28.8,60.28) ; v7(46.35,14.99) 46.35,15.21 46.54,15.4 v5(46.54,15.4)
  GND3 w0.102: v5(46.54,15.4) 46.55,15.4 v8(47,15.4) ; v8(24.83,35.76) v5(24.55,36.04) ; v6(28.8,60.28) 28.74,60.22 v5(28.74,59.9)
  IN3 w0.064: v8(24.83,35.76) 24.72,35.76 24.54,35.57 24.54,34.72 25.74,33.52 29.21,33.52 33.25,29.48 33.25,28.53 34.36,27.42 34.36,22.21 35.1,21.48 35.1,19.5 37.78,16.81 46.36,16.81 47.34,15.83 47.34,15.65 47.09,15.4 v8(47,15.4)
  BOTTOM w0.076: UH4.AW42 28.89,56.31 29.04,56.46 29.04,57.39 29.03,57.41 29.03,58.06 28.6,58.49 28.6,58.69 28.64,58.74 28.64,58.76
  BOTTOM w0.127: v6(28.8,60.28) 28.8,60.04 28.64,59.88 28.64,58.76
SML1_SMBDAT: length 72.5
  TOP w0.127: v7(49.15,14.59) UE3.E11
  IN1 w0.064: v4(23.42,35.6) 22.32,36.69 22.32,42.2 21.91,42.61 21.91,45.13 23.05,46.28 23.05,54.2 23.57,54.72 23.57,55.62 28.12,60.17 28.13,60.17 28.23,60.27 v6(28.23,60.28)
  GND2 w0.102: v5(24.54,35.42) 24.37,35.6 v4(23.42,35.6) ; v5(28.17,59.9) 28.23,59.96 v6(28.23,60.28) ; v5(48.82,14.58) 48.83,14.58 48.84,14.59 v7(49.15,14.59)
  GND3 w0.102: v5(28.17,59.9) 28.23,59.96 v6(28.23,60.28) ; v8(24.8,35.2) 24.77,35.2 v5(24.54,35.42) ; v5(48.82,14.58) 48.72,14.58 48.6,14.69 v8(48.5,14.69)
  IN3 w0.064: v8(48.5,14.69) 48.23,14.69 47.54,15.39 47.54,15.91 46.44,17 37.86,17 35.29,19.58 35.29,21.55 34.55,22.29 34.55,27.49 33.44,28.61 33.44,29.56 29.29,33.71 25.82,33.71 24.8,34.73 v8(24.8,35.2)
  BOTTOM w0.076: 28.39,58.76 28.39,58.74 28.43,58.69 28.43,58.43 28.86,57.99 28.86,57.22 UH4.AW45
  BOTTOM w0.127: 28.39,58.76 28.39,59.88 28.23,60.04 v6(28.23,60.28)
SNUB_1VALWP: length 2.8
  TOP w0.127: PR700.2 v1(12.96,49.64)
  TOP w0.508: PR700.2 11.27,50.55 PC700.1
SNUB_+0.95VSP:
  vias: v1(98.21,31.13)
SNUB_CHG1: length 4.2
  TOP w0.127: PC536.1 159.05,18.24 v1(159.05,20.4)
  TOP w0.254: PR519.2 157.97,17.79 PC536.1
SNUB_CHG2: length 2.9
  TOP w0.127: PC537.1 v1(137.08,19.53)
  TOP w0.508: PR520.2 PC537.1
SNUB_VDD08: length 3.8
  TOP w0.127: PR2328.2 v1(149.63,83.22)
  TOP w0.508: PR2328.2 150.9,84.4 v9(151.05,84.55)
  BOTTOM w0.508: PC3270.1 151.57,85.07 v9(151.05,84.55)
SOC_XDP_TDI: length 203.9
  IN1 w0.064: v4(75.1,27.29) 75.59,27.77 77.95,27.77 78.75,26.97 79.34,26.97 79.93,26.38 94.47,26.38 97.27,23.57 103.46,23.57 104.47,24.58 104.89,24.58 108.48,28.18 113.27,28.18 114.31,29.22 133.57,29.22 134.14,29.78 135.2,29.78 136.98,31.56 136.98,32.29 138.17,33.48 139.92,33.48 140.56,34.12 140.56,34.77 141.27,35.48 143.67,35.48 145.03,36.84 145.03,42.08 142.65,44.46 137.37,44.46 135.33,46.5 135.33,47.74 132.49,50.58 131.81,50.58 129.27,53.11 129.27,55.38 129.8,55.91 129.8,59.68 129.19,60.3 129.12,60.3 128.7,60.71 128.7,63.14 128.41,63.43 128.01,63.43 127.83,63.61 127.83,66.11 128.25,66.53 128.25,69.67 129.69,71.1 132.36,71.1 134.77,73.51 v4(135.51,73.51) 136.5,74.5 136.5,74.63 137.09,75.23 137.09,76.58 138.4,77.89 138.4,80.19 v2(138.63,80.42)
  GND2 w0.102: v5(74.72,27.06) 74.95,27.29 v4(75.1,27.29) ; v4(135.51,73.51) 135.43,73.51 v5(135.21,73.73)
  GND3 w0.102: v5(135.21,73.73) v8(134.82,73.73) ; v5(74.72,27.06) 74.72,27.36 v6(74.62,27.46)
  IN3 w0.064: v8(134.82,73.73) 132.72,73.73 132.66,73.67 131.75,73.67 131.2,73.12 130.85,73.12 130.65,73.32 130.05,73.32 129.96,73.23 129.54,73.23 129.19,72.88 v3(129.15,72.88)
  BOTTOM w0.076: 31.39,33.36 31.39,35.64 31.11,35.92
  BOTTOM w0.089: UH4.AP2 31.11,35.92
  BOTTOM w0.127: v6(74.62,27.46) 73.43,28.66 58.88,28.66 55.29,25.06 54.09,25.06 51.35,22.32 44.06,22.32 40.98,25.41 34.77,25.41 33.03,27.15 v16(33.03,27.71) 32.72,28.02 32.72,28.98 32.39,29.32 RC13.2 31.39,30.3 31.39,33.36
SOC_XDP_TDO: length 194.4
  IN1 w0.064: v4(74.32,27.77) 74.61,28.06 77.86,28.06 78.81,27.11 79.4,27.11 79.99,26.51 94.58,26.51 97.38,23.71 103.4,23.71 104.41,24.72 104.83,24.72 108.43,28.32 113.21,28.32 114.25,29.36 133.52,29.36 134.08,29.92 135.14,29.92 136.83,31.6 136.83,32.37 138.07,33.62 139.84,33.62 140.42,34.2 140.42,34.82 141.24,35.64 143.6,35.64 144.87,36.91 144.87,42.05 142.62,44.29 137.31,44.29 135.16,46.43 135.16,47.71 132.43,50.44 131.75,50.44 129.14,53.05 129.14,55.44 129.66,55.97 129.66,59.62 129.13,60.16 129.06,60.16 128.56,60.65 128.56,63.08 128.35,63.29 127.95,63.29 127.17,64.07 127.17,65.65 128.11,66.58 128.11,69.73 129.64,71.25 132.32,71.25 135.38,74.32 v4(135.85,74.32)
  GND2 w0.102: v4(74.32,27.77) 74.32,27.21 v5(74.22,27.11) ; v5(135.54,74.45) 135.54,74.32 v4(135.85,74.32)
  GND3 w0.102: v5(74.22,27.11) 74.22,27.31 v6(73.99,27.54) ; v6(135.2,74.38) 135.28,74.45 v5(135.54,74.45)
  BOTTOM w0.076: 31.16,33.36 31.16,35.5 UH4.AP1
  BOTTOM w0.127: v6(135.2,74.38) v1(134.39,74.38) 133.04,74.38 132.74,74.07 132.25,74.07 131.85,73.67 UC1.DG20 ; 31.16,33.36 31.16,29.85 RC16.2 31.7,29.33 32.03,29.01 32.03,27.42 34.65,24.8 35.53,24.8 36.76,23.57 42.52,23.57 43.98,22.12 51.43,22.12 54.18,24.86 55.37,24.86 58.72,28.21 73.31,28.21 v6(73.99,27.54)
SOC_XDP_TMS: length 207.7
  IN1 w0.064: v4(73.15,26.75) 73.38,26.98 75.18,26.98 75.83,27.63 77.9,27.63 78.7,26.83 79.28,26.83 79.87,26.24 94.36,26.24 97.16,23.43 103.52,23.43 104.53,24.44 105,24.44 108.6,28.04 113.33,28.04 114.37,29.08 133.63,29.08 134.2,29.64 135.26,29.64 137.12,31.5 137.12,32.2 138.26,33.34 140.26,33.34 142.24,35.31 143.73,35.31 145.17,36.75 145.17,42.14 142.69,44.62 137.44,44.62 135.49,46.57 135.49,47.77 129.41,53.85 129.41,55.33 129.94,55.86 129.94,60.42 129.55,60.81 129.18,60.81 128.9,61.09 128.9,63.45 128.43,63.92 128.43,69.65 129.75,70.96 132.42,70.96 134.61,73.15 135.54,73.15 136.39,74 136.39,74.15 v4(136.78,74.53) 137.26,75.01 137.26,76.55 138.92,78.21 138.92,80.06 v2(139.28,80.43)
  GND2 w0.102: v4(136.78,74.53) 136.72,74.58 v5(136.72,74.89) ; v5(73.15,27.11) v4(73.15,26.75)
  GND3 w0.102: v6(73.05,27.51) 73.05,27.21 v5(73.15,27.11) ; v5(136.72,74.89) 136.65,74.89 v8(136.45,74.68)
  IN3 w0.064: v3(129.15,73.67) 129.15,73.72 129.43,74.01 131.92,74.01 132.32,74.42 132.68,74.42 132.94,74.68 v8(136.45,74.68)
  BOTTOM w0.076: UH4.AR2 30.71,35.76 30.71,33.36
  BOTTOM w0.127: 30.71,33.36 30.71,31.24 30.43,30.96 RC11.2 30.29,29.33 30.07,29.11 30.07,28.5 34.18,24.39 35.37,24.39 37,22.75 37,21.88 38.11,20.77 43.05,20.77 43.97,21.68 51.58,21.68 54.35,24.45 55.54,24.45 58.6,27.51 v16(69.76,27.51) v6(73.05,27.51)
SOC_XDP_TRST#: length 216
  TOP w0.127: v2(81.57,17.88) 81.44,18.01 81.44,19.7 81.71,19.97 81.71,21.37 82.29,21.95 v16(82.29,23.26) v2(82.29,24.46)
  IN1 w0.064: v4(28.42,34.09) 29.22,34.09 31.61,31.71 37.83,31.71 40.98,28.56 43.67,28.56 45.32,26.9 54.74,26.9 56.12,25.52 60.31,25.52 60.54,25.3 64.83,25.3 69.64,20.49 73.36,20.49 75.85,18 81.45,18 v2(81.57,17.88) ; v4(138.43,74.55) 137.98,74.55 135.85,72.43 134.68,72.43 132.65,70.4 129.98,70.4 129.46,69.89 129.46,62.81 130.01,62.26 130.01,61.15 130.5,60.65 130.5,56.31 131.65,55.17 131.65,52.41 136.43,47.63 139.29,47.63 141.54,45.38 142.91,45.38 146.92,41.38 146.92,35.67 144.24,32.99 144.1,32.99 142.68,31.57 142.11,31.57 141.7,31.98 139.89,31.98 135.8,27.9 131.01,27.9 129.95,26.83 129.95,21.73 128.47,20.25 125.33,20.25 124.7,20.88 123.21,20.88 122.92,21.16 115.07,21.16 113.2,23.03 113.2,23.59 112.62,24.17 109.99,24.17 109.33,23.52 104.79,23.52 103.77,22.49 96.34,22.49 95.47,23.37 88.94,23.37 87.98,24.33 85.48,24.33 85.35,24.46 v2(82.29,24.46)
  GND2 w0.102: v4(138.43,74.55) v5(138.05,74.55) ; v4(28.42,34.09) v5(28.09,34.09)
  GND3 w0.102: v5(28.09,34.09) 28.11,34.12 v6(28.55,34.12) ; v5(138.05,74.55) v8(137.66,74.55)
  IN3 w0.064: v3(27.89,37.27) 28.14,37.27 28.7,36.71 28.7,34.27 v6(28.55,34.12) ; v8(137.66,74.55) 137.38,74.55 136.15,73.32 133.71,73.32 133.54,73.5 131.82,73.5 131.27,72.95 130.78,72.95 130.58,73.16 130.12,73.16 129.85,72.88 v3(129.8,72.88)
  BOTTOM w0.076: UH4.AY5 v3(27.89,37.27) ; 28.17,33.36 28.17,33.74 v6(28.55,34.12)
  BOTTOM w0.127: TP_PROC_TRSTN.1 28.16,33.35 28.17,33.36
SP7_SDWP: length 13
  TOP w0.127: UR1.29 22.69,62.45 v2(22.89,62.25) ; v1(15.85,56.09) 16.1,56.34 16.1,58.06 17.56,59.52 QR1.1 17.69,59.96 18.03,60.31 v2(18.97,60.31) 19.34,59.94 RR41.2
  IN1 w0.064: v2(22.89,62.25) 22.89,61.54 21.95,60.59 19.26,60.59 v2(18.97,60.31)
SPK_DET#: length 123.7
  TOP w0.127: v2(85.32,12.01) 85.34,12.03 85.34,17.96 v1(85.25,18.05) 84.83,18.47 v2(84.83,19.67)
  IN1 w0.064: v4(106.65,13.55) 105.74,13.55 105.42,13.23 104.67,13.23 104.63,13.18 103.91,13.18 103.17,12.44 99.07,12.44 97.93,11.3 90.73,11.3 90.15,11.89 86.18,11.89 86.06,12.01 v2(85.32,12.01) ; v2(84.83,19.67) 83.66,19.67 83.13,20.2 81.64,20.2 80.64,19.2 77.75,19.2 76.51,20.43 74.95,20.43 73.96,21.42 70.08,21.42 65.09,26.4 58.14,26.4 57.43,27.11 56.03,27.11 55.06,28.08 53.97,28.08 53.45,28.59 52.23,28.59 51.15,29.67 47.49,29.67 47.17,29.35 40.98,29.35 37.99,32.34 31.77,32.34 28.55,35.56 27.48,35.56 25.89,37.14 25.89,37.36 25.07,38.18 25.07,41.57 25.45,41.95 25.45,44.09 25.77,44.41 25.77,46.82 26.42,47.47 26.42,48.26 26.21,48.47 26.21,50.57 28.49,52.85 28.49,53.45 28.87,53.84 28.87,54.48 v4(29.46,55.07)
  GND2 w0.102: v5(106.73,13.89) 106.65,13.81 v4(106.65,13.55) ; v4(29.46,55.07) 29.46,55.25 29.44,55.28 v5(29.44,55.48)
  GND3 w0.102: v5(29.44,55.48) 29.32,55.6 v6(29.32,55.87) ; v5(106.73,13.89) 107.05,13.89 v6(107.06,13.9)
  IN3 w0.064: v3(30.01,59.25) 29.23,58.47 29.23,55.96 v6(29.32,55.87)
  BOTTOM w0.076: UH4.AV43 v6(29.32,55.87)
SPKR: length 128.3
  TOP w0.127: v2(27.45,26.6) v1(30.32,26.6) 30.41,26.6 30.9,26.12 v2(33.37,26.12)
  IN1 w0.064: v4(20.89,49.41) 20.65,49.17 20.65,42.5 19.51,41.37 19.51,34.64 26.36,27.79 26.36,27.69 v2(27.45,26.6) ; v9(86.34,16.75) 85.54,16.75 85.15,17.14 76.12,17.14 73.19,20.07 69.46,20.07 64.66,24.88 60.36,24.88 60.14,25.1 58.07,25.1 57.7,24.73 56.09,24.73 54.34,26.48 45.15,26.48 43.9,27.73 39.09,27.73 38.09,26.73 33.98,26.73 v2(33.37,26.12)
  GND2 w0.102: v4(20.89,49.41) 20.88,49.42 v5(20.52,49.42)
  IN2 w0.074: v9(86.34,16.75) 86.34,16.83 91.09,21.58 91.09,22.21 92,23.12 95.54,23.12 95.99,22.67 97.53,22.67 98.38,23.51 103.8,23.51 104.37,23.51 v5(104.81,23.07)
  GND3 w0.102: v6(20.14,49.42) v5(20.52,49.42) ; v5(104.81,23.07) v6(104.81,22.61)
  BOTTOM w0.076: UH4.BD26 26.29,48.05 24.22,48.05 24.13,48.13 23.04,48.13 22.22,48.95 22.07,48.95
  BOTTOM w0.127: 22.07,48.95 20,48.95 19.53,49.42 v6(20.14,49.42) ; JIO1.B9 106.56,19.4 106.56,20.38 106.93,20.75 106.93,21.51 105.83,22.61 v6(104.81,22.61)
SRCCLKREQ1#: length 6.9
  TOP w0.127: RH102.2 23.76,48.6 v1(24.6,47.76) 25.19,47.76 26.22,46.73 v7(26.81,46.73)
  GND2 w0.102: v5(27.07,46.49) 27.05,46.49 v7(26.81,46.73)
  GND3 w0.102: v6(27.4,46.49) v5(27.07,46.49)
  BOTTOM w0.076: UH4.AW24 28.45,47.03 27.96,46.54 27.45,46.54 v6(27.4,46.49)
SRCCLKREQ2#: length 9.6
  TOP w0.127: v7(22.77,49.36) 23.34,49.36 v1(23.66,49.04)
  GND2 w0.102: v7(22.77,49.36) 22.77,49.35 v5(23.01,49.1)
  GND3 w0.102: v8(23.34,49.1) v5(23.01,49.1)
  IN3 w0.064: v8(23.34,49.1) 23.92,49.1 25.35,47.68 28.14,47.68 v6(29.28,46.54)
  BOTTOM w0.076: v6(29.28,46.54) 29.29,46.57 UH4.AT24
SRCCLKREQ4#: length 60.5
  TOP w0.127: v1(45.5,85.43) 45.18,85.74 45.18,86.51 45.54,86.86 v2(45.56,86.86) RT431.2
  IN1 w0.064: v4(27.11,47.59) 26.99,47.71 26.99,50.52 29.51,53.04 29.51,53.31 29.64,53.43 30.52,53.43 31.04,53.95 31.04,55.09 32.47,56.52 34.8,56.52 37.19,58.91 37.48,58.91 40.66,62.09 40.66,62.61 42.47,64.42 42.47,69.17 45,71.71 45,86.3 v2(45.56,86.86)
  GND2 w0.102: v4(27.11,47.59) v5(26.72,47.59)
  GND3 w0.102: v6(26.73,47.2) 26.72,47.21 v5(26.72,47.59)
  BOTTOM w0.076: 22.07,47.51 24.64,47.51 24.98,47.17 26.7,47.17 v6(26.73,47.2) 26.84,47.2 27.17,46.87 UH4.BB24
  BOTTOM w0.127: RH645.2 19.96,48.09 20.26,47.79 20.37,47.79 20.45,47.71 21.74,47.71 21.94,47.51 22.07,47.51
SRCCLKREQ5#: length 4.9
  BOTTOM w0.076: 22.74,47.72 25.58,47.72 UH4.BE25
  BOTTOM w0.127: 21.31,48.09 22.07,48.09 v1(22.26,47.9) 22.56,47.9 22.74,47.72
SRCCLKREQ9#: length 5.9
  BOTTOM w0.076: RP3.6 22.63,53.99 25.43,51.19 26,51.19 26.13,51.06 26.61,51.06 26.86,50.81 UH4.BC32
SRCCLKREQ10#: length 6.2
  BOTTOM w0.076: UH4.BB31 27.2,50.53 26.18,50.53 26.13,50.48 25.24,50.48 23.66,52.06 23.66,52.41 23.22,52.85 22.83,52.85 22.69,52.99 RP3.8
SRCCLKREQ11#: length 7
  BOTTOM w0.076: RP4.8 22.76,55.78 23.83,54.7 23.83,53.34 25.63,51.54 26.41,51.54 26.57,51.39 UH4.BC33
SRCCLKREQ12#: length 9.1
  BOTTOM w0.076: UH4.BA33 27.92,51.83 27.48,52.28 25.4,52.28 24.43,53.25 24.43,55.33 22.97,56.78 RP4.6
SRCCLKREQ13#: length 9.9
  BOTTOM w0.076: UH4.AW33 28.69,51.73 28.19,52.23 28.19,52.61 27.53,53.27 27.28,53.27 27.21,53.33 26.2,53.33 25.93,53.6 25.47,53.6 24.79,54.29 24.79,55.56 23.06,57.28 RP4.5
SRCCLKREQ14#: length 7.9
  BOTTOM w0.076: UH4.BB33 27.08,51.62 26.67,51.62 26.57,51.72 25.72,51.72 24.02,53.42 24.02,55.07 22.81,56.28 RP4.7
SRCCLKREQ15#: length 5.4
  BOTTOM w0.076: RP3.5 22.75,54.49 23.64,53.6 23.64,53.26 25.54,51.36 26.21,51.36 UH4.BD33
SSD1_PCIE_SATA#: length 221.3
  TOP w0.127: v7(90.42,2.12) 89.63,2.91 89.63,6.05 90.94,7.36 90.94,9.58 90.58,9.94 90.58,13.33 91.61,14.36 91.61,18.65 90.97,19.29 90.97,22.14 92.05,23.22 93.11,23.22 v1(94,24.1) 94.31,24.42 RD58.1
  GND2 w0.102: v7(90.42,2.12) v5(90.65,1.89)
  IN2 w0.074: v5(30.07,61.45) 30.07,60.66 29.77,60.36 29.77,57.66 30.45,56.97 30.45,56.65 30.07,56.27 30.07,54.59 32.83,51.83 v5(33.25,51.83)
  GND3 w0.102: v5(33.25,51.83) 33.48,51.83 v8(33.58,51.93) ; v5(30.07,61.45) 30.27,61.45 v6(30.45,61.62) ; v5(90.65,1.89) 90.44,1.89 v8(90.13,1.58)
  IN3 w0.064: v6(30.45,61.62) 30.1,61.62 29.66,62.06 25.56,62.06 24.69,62.93 17.08,62.93 15.37,61.23 3.08,61.23 2.44,60.59 2.44,56.08 5.31,53.22 5.31,47.97 4.97,47.64 4.97,37.78 5.6,37.15 5.6,33.78 4.97,33.15 4.97,27.71 3.61,26.35 3.61,19.6 3.25,19.24 3.25,17.28 3,17.03 3,10.23 6.62,6.61 11.05,6.61 13.45,9.01 14.21,9.01 18.18,5.04 24.19,5.04 25.51,3.71 30.76,3.71 32.23,2.24 36.43,2.24 37.03,1.64 54.58,1.64 55.48,2.55 56.12,2.55 57.45,1.21 89.76,1.21 v8(90.13,1.58) ; v8(33.58,51.93) 33.61,51.96 33.89,51.96 v3(34.94,53.01)
  BOTTOM w0.127: v6(30.45,61.62) 30.54,61.54 32.36,61.54 32.39,61.5 RH90.1
SSD_PCIE_WAKE#: length 4.5
  BOTTOM w0.127: RD19.1 88.49,18.5 88.86,18.87 JNGFF2.54 ; RD19.1 87.93,17.62 v1(87.73,17.42) ; RD19.1 RD18.1
SSD_PWR_EN: length 116.4
  IN1 w0.064: v4(23.42,56.11) 23.56,56.11 28.76,61.31 33.97,61.31 34.29,61.63 37.98,61.63 38.95,62.59 v4(38.95,63.14)
  GND2 w0.102: v4(23.42,56.11) 23.42,56.03 v5(23.22,55.84) ; v5(39.28,63.26) 39.15,63.14 v4(38.95,63.14)
  IN2 w0.074: v5(39.28,63.26) 41.23,61.31 v5(43.44,61.31) ; v5(76.04,21.55) 75.94,21.44 63.14,21.44 61.12,19.42 56.67,19.42 55.79,20.3 52.7,20.3 52.52,20.48 50.22,20.48 49.62,21.08 45.69,21.08 45.1,20.48 38.65,20.48 38.31,20.82 38.31,22.76 35.19,25.88 33.95,25.88 31.88,27.95 31.88,31.03 30.32,32.58 28.35,32.58 25.03,35.91 25.03,36.43 24.55,36.91 24.55,41.65 24.91,42.02 24.91,42.53 24.32,43.12 24.32,50.35 23.88,50.8 23.88,54.07 23.22,54.73 v5(23.22,55.84)
  GND3 w0.102: v6(76.4,21.55) v5(76.04,21.55) ; v6(43.89,61.01) 43.58,61.31 v5(43.44,61.31)
  BOTTOM w0.076: 43,57.94 42.57,57.51 42.57,57.05 42.3,56.79 UH4.M44
  BOTTOM w0.127: v1(75.87,21.81) 76.13,21.55 v6(76.4,21.55) 76.78,21.93 RZ17.1 RZ20.1
  BOTTOM w0.145: 43,57.94 43.2,58.15 43.84,58.15 44.24,58.55 44.24,60.41 43.89,60.76 v6(43.89,61.01)
SSD_SCP#: length 60.6
  GND2 w0.102: v7(43.95,11.79) 43.81,11.79 v5(43.63,11.61)
  GND3 w0.102: v6(43.82,12) 43.82,11.8 v5(43.63,11.61)
  IN3 w0.064: v3(88.88,1.72) 88.81,1.8 88.15,1.8 87.93,2.02 84.56,2.02 84.26,2.32 82.56,2.32 81.78,3.1 81.09,3.1 80.88,3.31 78.54,3.31 77.81,2.58 74.32,2.58 74.07,2.83 60.53,2.83 59.33,4.02 57.19,4.02 56.83,4.38 56.37,4.38 56.26,4.38 55.28,5.36 53.94,5.36 52.94,6.36 50.9,6.36 50.4,5.86 46.78,5.86 46.41,6.23 46.41,6.86 45.64,7.63 45.64,9.31 45.88,9.55 45.88,9.79 45.88,10.23 44.11,12 v6(43.82,12)
  BOTTOM w0.127: RD60.2 87.03,6.43 87.33,6.13 88.22,6.13 88.41,5.94 88.41,4.72 89.32,3.82 v1(89.32,2.62) 89.32,2.51 88.88,2.08 v3(88.88,1.72) ; RE48.1 v6(43.82,12)
SSD_SCP#_R: length 4
  BOTTOM w0.127: JNGFF2.8 88.64,7.37 RD60.1 87.9,6.67 v1(86.92,7.66)
SUS_ON_EC: length 31.6
  TOP w0.089: UE3.D2 v2(41.14,15.4)
  TOP w0.127: RE291.1 34.06,20.15 v2(34.13,20.07) 34.13,19.77 34.05,19.68 v1(34.05,19.2) 34.05,18.23 34.13,18.14 34.13,16.82 34.5,16.45 v2(34.53,16.45) ; v2(47.02,24.09) 47.41,24.47 47.9,24.47 48.65,25.21 UZ16.1
  IN1 w0.064: v2(34.53,16.45) 35.42,16.45 35.96,15.91 38.04,15.91 38.56,15.39 39.91,15.39 40.2,15.09 40.59,15.09 40.89,15.4 v2(41.14,15.4) ; v2(47.02,24.09) 46.89,24.22 44.98,24.22 43.19,26.02 41.19,26.02 39.96,24.78 38.25,24.78 34.13,20.67 v2(34.13,20.07)
SUS_ON_EC_P: length 271
  TOP w0.127: UZ15.1 48.12,23.85 49.13,24.86 49.86,24.86 50.05,25.05 RZ37.1 50.39,26.94 50.62,27.17 50.62,27.58 50.47,27.73 v1(49.83,27.73) 49.55,27.45 49.55,27.11 49.37,26.93 48.54,26.93 48.12,26.51 UZ16.4 47.12,26.93 44.88,26.93 44.46,26.51 UZ17.1 43.41,27.21 RZ40.1 43.84,27.92 44.24,28.33 v7(45.23,28.33) ; v2(76.6,98.25) 76.6,97.68 77,97.29 PR811.1 77.05,96.77 77.44,96.38 v2(77.44,96.32)
  IN1 w0.064: v4(49.95,84.36) 50.28,84.7 50.28,85.71 54.54,89.96 54.54,92.1 55.38,92.94 58.78,92.94 59.18,93.34 63.04,93.34 64.18,92.21 66.43,92.21 66.72,92.5 70.64,92.5 73.35,95.21 76.56,95.21 77.44,96.09 v2(77.44,96.32) ; v2(76.6,98.25) 76.6,98.49 77.77,99.66 77.77,107.42 80.25,109.89 v2(80.25,110.36) ; v2(155.87,23.22) 155.87,23.23 155.53,23.57 155.53,26.91 154.1,28.35 151.35,28.35 150.63,29.07 146.94,29.07 146.35,28.49 141.49,28.49 139.93,26.92 139.93,23.7 135.8,19.58 133.77,19.58 125.07,10.88 116.18,10.88 114.61,12.45 114.61,15.63 114.07,16.17 110.53,16.17 110.05,15.69 106.69,15.69 106.38,16 102.01,16 100.76,14.75 97.7,14.75 97.17,14.23 92.55,14.23 90.17,16.61 88.72,16.61 87.05,18.28 75.97,18.28 73.39,20.86 69.85,20.86 65.13,25.57 60.65,25.57 60.43,25.8 57.95,25.8 57.27,26.49 55.86,26.49 55.17,27.18 45.59,27.18 45.52,27.25 45.52,28.04 v7(45.23,28.33)
  GND2 w0.102: v5(45.36,28.73) 45.23,28.61 v7(45.23,28.33) ; v4(49.95,84.36) v5(49.95,84.03)
  IN2 w0.074: v5(49.95,84.03) 49.13,83.22 49.13,75.29 50.73,73.69 50.73,66.82 46.47,62.56 46.47,60.78 44.31,58.62 44.31,56.85 44.67,56.49 45.22,56.49 45.34,56.36 45.34,54.14 49.25,50.23 49.25,40.24 48.4,39.38 48.4,36.15 48.73,35.82 49.18,35.82 49.52,35.49 49.52,31.81 48.14,30.44 45.63,30.44 45.36,30.16 v5(45.36,28.73)
SUS_ON_EC_ST: length 82
  TOP w0.127: v2(51.79,33.43) 51.41,33.43 51.01,33.04 51.01,32.23 50.67,31.88 50.67,28.24 50.87,28.04 50.87,26.85 50.71,26.69 v1(50.71,26.18) 50.71,25.65 50.87,25.48 50.87,24.54 50.47,24.14 RZ37.2 RZ39.1 49.92,22.55 UZ15.4
  IN1 w0.064: v2(113.76,24.18) 112.72,25.22 106.26,25.22 105.18,24.14 104.62,24.14 103.53,23.05 96.57,23.05 93.67,25.96 85.53,25.96 84.77,25.19 82.04,25.19 81.95,25.09 80.17,25.09 79.3,25.96 78.68,25.96 77.3,27.35 75.94,27.35 74.97,26.37 73.06,26.37 72.81,26.63 69.04,26.63 66.17,29.5 65.38,29.5 64.63,30.25 62.75,30.25 61.8,31.2 58.48,31.2 58.27,30.99 55.96,30.99 55.2,31.76 54.97,31.76 53.29,33.43 v2(51.79,33.43)
SUS_ON_P: length 157.8
  TOP w0.127: RZ45.1 116.61,101.48 115.92,100.79 v1(115.92,99.51) 115.92,99.22 114.58,97.87 114.58,94.16 114.4,93.98 114.4,93.62 113.96,93.19 112.02,93.19 v7(111.91,93.3) ; v7(46.31,25.29) 46.23,25.21 UZ17.4
  IN1 w0.064: v4(71.17,93.51) 71.17,93.34 70.47,92.64 66.67,92.64 66.37,92.35 64.23,92.35 63.1,93.48 59.12,93.48 58.72,93.08 55.32,93.08 55,92.76 54.4,92.16 54.4,90.08 50.1,85.79 50.1,84.89 49.48,84.27 v4(49.48,82.7)
  GND2 w0.102: v4(49.48,82.7) v5(49.48,82.35) ; v5(71.43,93.8) 71.17,93.54 v4(71.17,93.51) ; v7(111.91,93.3) 111.86,93.3 111.65,93.5 v5(111.55,93.5) ; v5(46.56,26.08) 46.33,25.85 46.33,25.3 v7(46.31,25.29)
  IN2 w0.074: v5(49.48,82.35) 49.32,82.2 49.32,77.65 53.33,73.64 53.33,70.46 50.88,68 50.88,66.76 46.64,62.52 46.64,60.7 44.48,58.54 44.48,56.89 44.74,56.64 45.28,56.64 45.49,56.42 45.49,54.23 49.4,50.32 49.4,40.07 48.55,39.22 48.55,36.21 48.79,35.97 49.25,35.97 49.73,35.49 49.73,27.29 48.52,26.08 v5(46.56,26.08) ; v5(71.43,93.8) 71.72,94.09 79.18,94.09 80.73,95.64 82.32,95.64 86.18,99.5 90.29,99.5 91.23,98.56 91.23,97.72 95.78,93.17 110.74,93.17 111.07,93.5 v5(111.55,93.5)
SUSACK#: length 66.6
  TOP w0.127: v9(49.95,9.79) UE3.K12
  IN3 w0.064: v3(23.05,45.7) 22.62,45.27 21.45,45.27 21.31,45.13 21.31,44.74 21.18,44.61 18.82,44.61 18.1,43.88 18.1,43.33 17.72,42.96 17.72,41.95 17.43,41.65 17.43,39.86 17.92,39.36 17.92,38.71 18.12,38.51 18.12,36.47 17.86,36.21 17.86,35.89 18.12,35.63 18.12,34.7 23.57,29.24 23.57,28.86 25.17,27.27 25.17,26.65 27.05,24.77 v3(27.05,24.3)
  BOTTOM w0.127: v9(49.95,9.79) 50.7,10.54 v1(50.7,11.44) 50.7,13.89 50.38,14.21 49.05,14.21 48.43,14.83 47.03,14.83 45.66,16.2 43.17,16.2 42.9,15.93 39.26,15.93 38.97,16.22 38.28,16.22 37.63,15.58 35.01,15.58 34.78,15.35 33.29,15.35 32.84,15.8 32.84,20.28 28.72,24.4 27.15,24.4 v3(27.05,24.3)
SUSACK#_R: length 4.4
  BOTTOM w0.076: RH636.1 23.64,45.7 RH638.2 23.69,45.07 25.4,45.07 25.57,44.9 26.51,44.9 26.6,44.81 27.07,44.81 UH4.BB19
SUSCLK: length 89.6
  TOP w0.127: v2(85.72,27.19) v1(85.72,21.86) 85.72,20.17 v7(85.95,19.94)
  IN1 w0.064: v7(85.95,19.94) 86.24,19.65 87.52,19.65 89.59,17.58 90.71,17.58 91.99,16.3 99.4,16.3 v2(99.48,16.39) ; v2(85.72,27.19) 85.59,27.32 80.53,27.32 79.93,27.92 78.81,27.92 78.11,28.62 68.72,28.62 67.7,29.63 65.44,29.63 64.68,30.39 62.81,30.39 61.86,31.34 58.42,31.34 58.21,31.13 56.02,31.13 55.26,31.9 55.03,31.9 53.17,33.75 49.03,33.75 48.74,33.46 48.05,33.46 47.37,32.78 46.43,32.78 45.97,32.32 43.16,32.32 41.45,34.04 41.45,35.2 40.34,36.3 35.2,36.3 32.33,39.17 32.33,39.93 v4(30.86,41.41)
  GND2 w0.102: v5(86.43,20.15) 86.15,20.15 v7(85.95,19.94) ; v5(31.21,41.41) v4(30.86,41.41)
  GND3 w0.102: v6(86.97,20.38) 86.74,20.15 v5(86.43,20.15) ; v6(31.21,41.79) v5(31.21,41.41)
  BOTTOM w0.076: UH4.AN15 31.61,42.18 v6(31.21,41.79)
  BOTTOM w0.127: v6(86.97,20.38) 87.14,20.55 RD20.2
SUSWARN#: length 4.1
  BOTTOM w0.076: UH4.BD19 26.26,44.49 24.89,44.49 24.58,44.8 23.38,44.8 RH638.1 22.47,45.13 RH637.1
SVC: length 5.8
  TOP w0.203: PU1800.4 52.39,37.13 51.66,37.86 PR1816.2 51.29,37.98 50.9,38.37 49.95,38.37 49.51,37.94 ; 49.51,37.94 PR1808.2 ; 49.51,37.94 PR1801.1
SVD: length 6.6
  TOP w0.203: PU1800.2 53.05,37.93 52.36,38.63 v1(52.36,39.33) 52.17,39.52 51.79,39.52 50.52,40.79 PR1810.2 50.38,40.77 PR1806.2 PR1800.1
SVI2_SVC: length 62.8
  IN1 w0.064: v4(72.87,57.08) 72.19,56.39 71.27,56.39 70.49,55.61 63.06,55.61 58.9,51.44 58.9,48.99 58.61,48.7 58.61,47.63 51.15,40.18 51.15,38.64 v2(50.38,37.86)
  GND2 w0.102: v4(72.87,57.08) 72.87,57.16 v5(73.09,57.37)
  IN2 w0.074: v5(73.09,57.37) 73.42,57.71 73.42,60.08 73.17,60.34 73.17,75.46 76.98,79.27 79.6,79.27 v5(80.3,79.98)
  GND3 w0.102: v5(80.3,79.98) 80.54,80.22 v6(80.62,80.22)
  BOTTOM w0.127: UC1.H9 80.12,81.21 80.43,80.9 80.43,80.4 v6(80.62,80.22)
SVI2_SVD: length 61.2
  IN1 w0.064: v4(71.89,57.18) 71.63,57.18 70.38,55.94 62.7,55.94 58.55,51.79 58.55,49.03 58.33,48.82 58.33,47.82 50.39,39.88 v2(50.39,39.87)
  GND2 w0.102: v4(71.89,57.18) 71.89,57.4 v5(72.02,57.53)
  IN2 w0.074: v5(80.06,81.5) 79.48,80.92 79.48,79.88 79.18,79.58 76.86,79.58 72.87,75.59 72.87,60.22 73.12,59.96 73.12,58.6 72.05,57.53 v5(72.02,57.53)
  GND3 w0.102: v6(79.67,81.5) v5(80.06,81.5)
  BOTTOM w0.127: v6(79.67,81.5) 80.04,81.86 UC1.H8
SVI2_SVT: length 63.5
  IN1 w0.064: v2(50.38,38.88) 50.85,39.35 50.85,40.1 58.47,47.73 58.47,48.76 58.71,49 58.71,51.63 62.85,55.77 70.42,55.77 71.17,56.53 71.91,56.53 v4(72.4,57.01)
  GND2 w0.102: v4(72.4,57.01) 72.4,57.29 v5(72.57,57.46)
  IN2 w0.074: v5(81.1,80) 80.96,80.14 80.89,80.14 80.64,80.39 80.21,80.39 79.24,79.43 76.92,79.43 73.02,75.52 73.02,60.28 73.27,60.02 73.27,58.16 v5(72.57,57.46)
  GND3 w0.102: v6(81.4,80.27) 81.13,80 v5(81.1,80)
  BOTTOM w0.127: v6(81.4,80.27) 81.4,81.51 UC1.K8
SVT: length 5.2
  TOP w0.203: PU1800.3 52.82,37.53 v1(52.3,38.06) 51.47,38.88 PR1815.2 51.29,38.99 50.89,39.39 49.82,39.39 49.51,39.69 PR1807.2
SYNC: length 104.5
  TOP w0.127: v9(105.74,35.69) 105.3,35.69 v1(105.13,35.52)
  TOP w0.203: v9(137.79,45.85) 137.79,45.41 140.13,43.08 PU1100.34
  IN1 w0.254: v9(149.45,53.3) 149.45,54.18 151.77,56.51 151.77,62.43 150.7,63.5 149.91,63.5 149.89,63.52 v9(149.89,63.53)
  IN2 w0.254: 120.27,30.18 120.14,30.05 114.6,30.05 114.45,30.21 ; 120.27,30.18 120.27,34.07 v9(120.42,34.22) ; 120.27,30.18 120.39,30.05 123.73,30.05 124,29.78 127.13,29.78 127.48,30.13 ; v9(137.79,45.85) 137.79,43.92 136.06,42.2 136.06,36.23 135.23,35.39 135.23,31.81 133.2,29.78 127.83,29.78 127.48,30.13 ; v9(112.87,34.42) 112.87,32.47 114.45,30.89 114.45,30.21 ; 127.48,30.13 127.48,35.57 v9(127.61,35.69) ; 114.45,30.21 114.23,29.98 113.17,29.98 111.96,31.2 111.96,32.82 110.93,33.85 106.98,33.85 105.74,35.1 v9(105.74,35.69)
  BOTTOM w0.203: PU1302.10 106.69,36.11 106.27,35.69 v9(105.74,35.69) ; v9(149.89,63.53) 149.89,63.52 149.86,63.5 149.49,63.87 PU1301.10 ; v9(149.45,53.3) 149.45,53.68 149.03,54.1 PU1300.10 ; v9(120.42,34.22) 120.42,34.47 120.7,34.75 PU1201.10 ; PU1200.10 113.51,35.16 112.87,34.52 v9(112.87,34.42) ; PU1202.10 127.89,36.15 127.61,35.87 v9(127.61,35.69)
  BOTTOM w0.254: v9(149.45,53.3) 149.45,52.98 148.31,51.83 148.31,51.29 146.89,49.87 141.8,49.87 v9(137.79,45.85)
SYS_PRES#: length 150.1
  IN3 w0.064: v3(6.11,15.5) 4.75,14.14 4.75,10.15 7.01,7.88 11.61,7.88 13.2,9.48 14.46,9.48 18.46,5.48 24.68,5.48 v9(25.43,4.73) 30.18,4.73 32.39,2.52 36.55,2.52 37.15,1.92 50.27,1.92 50.51,2.17 51.86,2.17 52.21,1.81 54.51,1.81 55.39,2.69 56.21,2.69 57.54,1.35 88.91,1.35 v3(89.24,1.68) ; v3(114.8,16.22) 114.8,15.12 114.17,14.49 114.17,12.59 113.65,12.06 113.65,11.08 111.11,8.54 109.06,8.54 108.74,8.86 107.17,8.86 105.59,7.28 104.71,7.28 103.73,6.3 103.08,6.3 102.34,5.56 93.43,5.56 93.21,5.78 90.47,5.78 89.83,5.14 v3(88.81,5.14)
  BOTTOM w0.127: v3(89.24,1.68) 89.76,2.2 89.76,3.66 88.81,4.61 v3(88.81,5.14) ; v3(6.11,15.5) 6.51,15.91 R5865.1 ; BAT100.7 123.78,19.91 123.45,20.24 122.85,20.24 122.79,20.31 116.42,20.31 115.42,19.31 115.42,16.83 v3(114.8,16.22) 114.12,16.9 JIO1.D1
SYS_PRES#_1: length 2.7
  BOTTOM w0.127: JIO1.S13 102.06,4.4 102.06,3.28 102.47,2.86 R5822.1
SYS_PWROK: length 64.8
  TOP w0.127: v1(47.72,43.68) 47.56,43.52 PR1809.1 47.12,42.79 v2(47.02,42.7) ; v7(42.75,12.19) UE3.G4
  IN1 w0.064: v4(33.17,39.58) 33.36,39.39 39.94,39.39 41.8,41.26 45.53,41.26 46.97,42.7 v2(47.02,42.7) ; v7(42.75,12.19) 42.57,12.19 42.31,12.45 40.91,12.45 40.54,12.08 39.99,12.08 39.42,12.66 35.82,12.66 v7(35.57,12.4)
  GND2 w0.102: v5(33.17,39.2) v4(33.17,39.58) ; v7(35.57,12.4) 36.04,12.4 v5(36.19,12.25)
  GND3 w0.102: v5(33.17,39.2) 33.17,38.7 v8(33.18,38.69) ; v5(36.19,12.25) v8(35.9,11.96)
  IN3 w0.064: v3(27.22,27.27) 27.39,27.27 29.59,25.07 29.59,23.18 28.55,22.14 28.55,19.67 28.82,19.4 28.82,18.13 32.29,14.67 32.29,13.56 33.7,12.15 35.71,12.15 v8(35.9,11.96) ; v8(33.18,38.69) 32.88,38.39 32.25,38.39 v3(31.92,38.72)
  BOTTOM w0.076: 27.53,33.36 27.53,33.76 28.11,34.35 28.11,35.41 UH4.AY1 28.25,35.58 27.91,35.92 27.91,36.43 28.09,36.61 28.09,37.01 28.7,37.62 30.02,37.62 30.35,37.95 30.68,37.95 31.44,38.72 v3(31.92,38.72)
  BOTTOM w0.127: v3(27.22,27.27) 27.22,28.73 27.71,29.22 27.71,31.08 27.53,31.25 27.53,33.36
SYS_PWROK_1: length 12.2
  TOP w0.127: v2(47.95,43.06) 48.37,43.06 48.6,42.83 PR2337.1 48.36,42.21 PR1809.2 47.41,42.06 47.41,41.33 47.71,41.03 PC3289.1 PR2338.2 ; PU78.4 v2(44.16,42.74) v1(43.19,42.74)
  IN1 w0.064: v2(44.16,42.74) 45.74,44.32 47.79,44.32 47.95,44.15 v2(47.95,43.06)
SYS_PWROK_2: length 6.5
  TOP w0.203: PU1800.1 53.22,38.33 52.87,38.69 52.87,39.71 52.61,39.96 51.98,39.96 51.43,40.51 v1(51.43,40.66) 49.64,42.45 PR2337.2
SYS_RESET#: length 68.5
  TOP w0.127: v9(75.28,11.13) 75.73,11.58 78.2,11.58 v1(79.54,10.24) 79.83,9.95 JAPS1.13
  BOTTOM w0.076: 28.51,33.36 28.51,33.65 28.82,33.96 UH4.AW1
  BOTTOM w0.127: 28.51,33.36 28.51,31.39 28.29,31.17 28.29,30.55 28.53,30.31 RH132.1 28.65,28.16 37.33,19.47 47.4,19.47 48.15,18.73 55.4,18.73 61.67,12.45 72.25,12.45 73.57,11.13 v9(75.28,11.13)
TAB_LID#: length 223
  TOP w0.127: DZ128.1 22.18,44.55 21.93,44.3 21.93,44.1 21.74,43.91 20.58,43.91 20.34,44.15 19.34,44.15 19.28,44.21 17.79,44.21 15.97,46.03 15.97,47.35 14.55,48.77 v7(14.55,50.83) 11.85,53.54 11.85,59.96 12.26,60.38 12.26,66.79 13.28,67.81 13.28,76.78 15.09,78.59 16.07,78.59 16.57,79.08 R130.2 16.63,79.05 U20.3 ; v2(73.44,25.67) 74.54,24.58 74.54,21.95 72.87,20.28 72.87,16.53 72.4,16.06 72.4,14.43 68.93,10.96 v1(68.93,8.99) 68.93,5.9 66.54,3.51 58.77,3.51 57.92,2.66 55.94,2.66 54.96,3.64 v7(54.9,3.64) 55.02,3.76 55.02,4.14 55.94,5.06 55.94,7.81 57.4,9.27 57.4,10.78 56.73,11.45 56.46,11.45 RE260.1
  IN1 w0.064: v4(101.51,21.76) 96.14,21.76 95.19,22.7 88.18,22.7 88.08,22.8 86.15,22.8 85.49,23.46 79.82,23.46 78.11,25.16 75.79,25.16 75.4,25.56 73.55,25.56 v2(73.44,25.67)
  GND2 w0.102: v5(101.51,22.31) v4(101.51,21.76) ; v7(54.9,3.64) 54.9,3.38 v5(55.03,3.26) ; v7(14.55,50.83) 14.53,50.81 v5(14.22,50.81)
  GND3 w0.102: v6(101.91,22.43) 101.79,22.31 v5(101.51,22.31) ; v5(14.22,50.81) 13.92,50.81 v8(13.89,50.83) ; v8(54.64,3.26) v5(55.03,3.26)
  IN3 w0.064: v8(13.89,50.83) 13.89,51.82 11.66,54.06 8.24,54.06 7.31,53.13 7.31,44.63 8.18,43.76 8.18,39.67 8.84,39.02 8.84,38.64 8.34,38.14 8.34,34.75 8.58,34.51 12.9,34.51 14.53,32.89 14.53,28.58 16.3,26.8 16.3,25.56 15.5,24.75 15.5,21.08 19.2,17.38 19.34,17.38 22.56,14.16 22.56,13.48 25.12,10.92 25.66,10.92 29.28,7.3 32.17,7.3 33.72,5.75 37.42,5.75 38.58,4.6 39.3,4.6 40.09,3.8 44.39,3.8 44.66,3.54 45.43,3.54 46.33,2.64 49.97,2.64 50.22,2.88 53.3,2.88 53.68,3.26 v8(54.64,3.26)
TAB_LID#_IO_R: length 8.5
  BOTTOM w0.102: 101.37,16.11 101.58,15.9 JIO1.E13
  BOTTOM w0.127: 101.37,16.11 101,16.48 101,20.66 102.5,22.15 R5834.1 R5835.1
TAB_LID#_R: length 6.8
  GND2 w0.102: v7(21.43,44.55) 21.43,44.73 v5(21.87,45.17)
  GND3 w0.102: v5(21.87,45.17) 21.61,44.91 v6(21.6,44.91)
  IN3 w0.064: v6(21.6,44.91) 22.04,44.91 22.54,44.42 23.22,44.42 23.62,44.81 v3(25.16,44.81)
  BOTTOM w0.076: v3(25.16,44.81) 25.23,44.74 26.43,44.74 26.59,44.57 UH4.BC19
TABLE_MODE#: length 41.3
  TOP w0.127: v1(16.86,37.23) 16.99,37.23 17.88,38.12 QC124.1 v7(18.32,37.17) ; RE274.2 34.92,7.58 v7(33.85,8.64)
  GND2 w0.102: v7(33.85,8.64) 33.83,8.64 v5(33.58,8.9) ; v5(18.63,36.22) 18.32,36.52 v7(18.32,37.17)
  GND3 w0.102: v8(18.19,36.16) 18.24,36.22 v5(18.63,36.22) ; v5(33.58,8.9) 33.56,8.91 v8(33.56,9.25)
  IN3 w0.064: v8(33.56,9.25) 32.76,10.05 32.29,10.05 31.53,10.81 31.53,11.57 28.43,14.67 28.43,15.09 27.13,16.39 27.13,17.8 26.76,18.17 26.76,19.46 26.43,19.79 26.43,20.76 26.76,21.09 26.76,22.42 27.31,22.97 27.31,24.7 25.31,26.71 25.31,27.33 23.71,28.92 23.71,29.32 18.26,34.77 18.26,36.09 v8(18.19,36.16)
TABLE_MODE#_R: length 13.2
  TOP w0.127: v2(17.62,41.67) 17.43,41.67 17.17,41.41 RC394.1 17.67,40.66 QC124.3
  IN1 w0.064: v4(18.52,43.2) 17.85,42.53 17.85,41.9 v2(17.62,41.67)
  GND2 w0.102: v4(18.52,43.2) 18.58,43.25 v5(18.58,43.53)
  GND3 w0.102: v6(18.7,43.84) 18.7,43.65 v5(18.58,43.53)
  BOTTOM w0.076: 22.07,44.15 22.68,44.15 22.76,44.07 24.08,44.07 24.29,43.86 26.03,43.86 26.16,43.99 UH4.BD18
  BOTTOM w0.127: 22.07,44.15 RH596.1 21.6,43.86 21.31,43.58 19.47,43.58 19.21,43.84 v6(18.7,43.84)
TACH_FAN1: length 128.8
  TOP w0.127: v7(135.68,28.73) 135.44,28.49 RE2.2 CE1.1 DE1.2 ; v2(82.72,6.88) 83.36,6.88 83.66,7.18 83.66,12.96 82.83,13.79 82.83,17.24 83.78,18.19 83.78,27.81 v1(83.64,27.94) v7(83.21,28.38)
  IN1 w0.064: v2(82.72,6.88) 82.6,6.76 81.3,6.76 80.98,7.07 78.68,7.07 78.5,7.25 77.23,7.25 76.53,7.95 71.56,7.95 70.97,8.54 70.23,8.54 68.51,10.26 65.93,10.26 65.43,10.76 63.72,10.76 61.59,12.88 57.37,12.88 54.82,15.43 54.82,16.45 54.67,16.6 54.29,16.6 53.88,17.01 49.61,17.01 49.33,16.73 48.47,16.73 47.37,15.63 47.37,15.24 46.35,14.23 43.18,14.23 42.88,13.93 42.61,13.93 v2(42.35,14.19)
  GND2 w0.102: v7(135.68,28.73) v5(135.35,28.73) ; v5(83.21,28.71) v7(83.21,28.38)
  IN2 w0.074: v5(135.35,28.73) 123.64,28.73 123.32,29.06 115.22,29.06 114.99,28.83 113.92,28.83 113.4,28.31 109.83,28.31 107.11,31.03 106.41,31.03 105.84,31.6 100.5,31.6 99.58,30.68 96.63,30.68 95.96,30.01 86.46,30.01 84.64,28.19 83.72,28.19 83.21,28.71 v5(83.21,28.71)
TACH_FAN1_D: length 22.5
  TOP w0.127: v7(139.66,26.47) 139.25,26.05 v1(139.16,26.05) 138.46,26.05 137.86,26.66 DE1.1 137.86,28.16 RE3.2
  GND2 w0.102: v7(139.66,26.47) 139.93,26.47 v5(140.07,26.61)
  GND3 w0.102: v6(140.47,26.88) 140.34,26.88 v5(140.07,26.61)
  BOTTOM w0.127: JFAN1.3 144.34,38.42 144.69,38.06 144.69,35.64 146.47,33.86 146.47,32.15 145.46,31.15 145.46,30.35 145.03,29.91 143.34,29.91 142.15,28.72 141.07,28.72 140.47,28.12 v6(140.47,26.88)
TACH_FAN2: length 134.2
  TOP w0.122: v7(40.39,15.35) UE3.D1
  TOP w0.127: v7(82.52,7.17) 83.46,8.11 83.46,12.87 82.52,13.8 82.52,17.67 83.58,18.73 83.58,25.19 v1(82.67,26.09) v7(82.67,28.35) ; DE3.2 CE2.1 RE7.2 135.67,29.06 v7(136.17,29.06)
  IN1 w0.064: v7(40.39,15.35) 40.69,15.66 42.35,15.66 42.87,15.14 43.68,15.14 44,15.46 44.99,15.46 45.11,15.33 45.71,15.33 45.85,15.47 46.62,15.47 47.06,15.91 47.06,17.19 48.02,18.15 53.95,18.15 54.45,17.66 54.45,17.5 54.6,17.35 55.05,17.35 55.75,16.65 55.75,15.56 57.58,13.73 61.8,13.73 63.98,11.56 67.81,11.56 70.4,8.96 71.14,8.96 71.73,8.37 76.71,8.37 77.41,7.67 78.67,7.67 78.85,7.49 82.34,7.49 82.52,7.31 v7(82.52,7.17)
  GND2 w0.102: v7(136.17,29.06) 136.27,28.96 136.27,28.86 v5(136.42,28.71) ; v7(82.67,28.35) 82.65,28.38 v5(82.65,28.71)
  IN2 w0.074: v5(136.42,28.71) 136.04,28.33 134.67,28.33 134.44,28.56 123.61,28.56 123.26,28.91 115.28,28.91 115.03,28.65 113.98,28.65 113.49,28.16 109.76,28.16 107.04,30.88 106.35,30.88 105.78,31.45 100.56,31.45 99.65,30.53 96.69,30.53 95.99,29.83 86.53,29.83 84.74,28.04 83.32,28.04 v5(82.65,28.71)
TACH_FAN2_D: length 16.6
  TOP w0.127: v7(141.87,32.81) 141.87,32.5 v1(141.64,32.28) 141.42,32.28 140.86,31.71 140.86,30.78 140.33,30.24 139.61,30.24 139.26,30.59 138.26,30.59 DE3.1 137.86,29.28 RE8.2
  GND2 w0.102: v7(141.87,32.81) 141.83,32.78 v5(141.83,32.42)
  GND3 w0.102: v6(142.07,32.66) v5(141.83,32.42)
  BOTTOM w0.127: JFAN1.5 142.42,40.42 142,40.01 142,32.72 v6(142.07,32.66)
TBT_A_AUX_N_C: length 6.4
  IN1 w0.086: v2(42.45,75.24) 42.45,79.2 42.05,79.61 41.41,79.61 v6(41.1,79.92)
  GND2 w0.102: v5(41.36,80.18) 41.36,80.18 v6(41.1,79.92)
  GND3 w0.102: v5(41.36,80.18) 41.1,79.92 v6(41.1,79.92)
TBT_A_AUX_P_C: length 6.3
  IN1 w0.086: v6(41.75,79.92) 42.17,79.92 42.76,79.33 42.76,75.3 42.84,75.22 43,75.22 v2(43.02,75.24)
  GND2 w0.102: v5(41.98,80.2) 41.98,80.12 41.77,79.92 v6(41.75,79.92)
  GND3 w0.102: v6(41.75,79.92) 41.98,80.15 v5(41.98,80.2)
TBT_A_CC1: length 36.9
  IN1 w0.381: v9(12.88,81.68) 13.19,81.68 14.07,82.56 14.8,82.56 16.53,80.83 18.69,80.83 19.2,81.34 v4(19.43,81.34)
  GND2 w0.381: v5(19.84,81.65) 19.52,81.34 v4(19.43,81.34) ; v5(30.86,69.93) 30.95,70.03 v6(31.18,70.03)
  IN2 w0.381: v5(30.86,69.93) 30.4,69.93 29.99,70.34 29.99,71.49 v5(30.27,71.77)
  GND3 w0.254: v5(30.86,69.93) 30.95,70.03 v6(31.18,70.03)
  GND3 w0.381: v8(30.03,72) v5(30.27,71.77) ; v8(20.14,81.34) 19.84,81.64 v5(19.84,81.65)
  IN3 w0.127: JUSBC1.B5 6.98,81.64 v6(8.23,81.64)
  IN3 w0.381: v8(30.03,72) 29.69,72.34 29.69,72.56 26.7,75.55 26.7,79.32 25.31,80.71 20.63,80.71 20.14,81.21 v8(20.14,81.34)
  GND4 w0.127: JUSBC1.B5 6.98,81.64 v6(8.23,81.64)
  BOTTOM w0.127: JUSBC1.B5 6.98,81.64 v6(8.23,81.64)
  BOTTOM w0.381: 11.76,81.02 12.18,81.02 v16(12.48,81.32) 12.84,81.68 v9(12.88,81.68) ; 10.83,81.04 10.62,81.04 10.02,81.64 v6(8.23,81.64)
TBT_A_CC2: length 35.4
  TOP w0.127: v7(30.61,69.39) 30.55,69.39 v1(30.13,68.98)
  TOP w0.254: CP12.1 30.91,69.09 v7(30.61,69.39)
  TOP w0.305: 9.9,83.27 JUSBC1.A5
  TOP w0.381: 11.91,84.01 13.01,84.01 v9(13.08,84.08) ; 9.9,83.27 9.93,83.27 10.69,84.03 10.77,84.03
  IN1 w0.381: v4(19.5,83.44) 18.59,82.53 16.71,82.53 15.16,84.08 v9(13.08,84.08)
  GND2 w0.381: v5(30.93,69.32) 30.86,69.39 v7(30.61,69.39) ; v4(19.5,83.44) 19.63,83.44 v5(19.88,83.7)
  IN2 w0.381: v5(30.42,72.31) 30.39,72.31 30.39,72.28 30.08,72.28 29.53,71.73 29.53,70.15 30.31,69.37 30.88,69.37 v5(30.93,69.32)
  GND3 w0.381: v5(30.42,72.31) 30.2,72.54 30.2,72.54 30.2,72.55 v8(30.19,72.55) ; v6(31.18,69.03) 31.18,69.08 v5(30.93,69.32) ; v8(20.34,83.62) 20.27,83.7 v5(19.88,83.7)
  IN3 w0.381: v8(30.19,72.55) 30.19,72.71 27.19,75.71 27.19,79.48 23.05,83.62 v8(20.34,83.62)
TBT_A_SBU1: length 43.3
  IN3 w0.064: v3(31.68,65.53) 31.28,65.53 30.71,64.95 30.13,64.95 29.55,64.37 27.39,64.37 26.92,64.84 26.92,66.1 26.29,66.73 17.1,66.73 13.34,70.49 13.34,71.44 14.02,72.12 14.02,74.99 13.42,75.58 13.42,76.73 13.66,76.97 13.66,80.14 12.48,81.32 12.48,83.34 11.76,84.07 v6(11.31,84.07)
  BOTTOM w0.127: v16(12.38,84.04) 11.34,84.04 v6(11.31,84.07) 10.97,84.07 10.75,83.85 9.37,83.85 8.91,83.39 6.97,83.39 JUSBC1.B8
TBT_A_SBU2: length 38.9
  TOP w0.127: JUSBC1.A8 9.88,81.77 10.33,81.31 10.98,81.31 DT12.1 11.49,81.16 12.54,81.16 12.79,80.92 12.79,80.33 v9(12.82,80.3)
  IN3 w0.064: v3(32.18,65.53) 31.84,65.18 31.14,65.18 30.77,64.82 30.19,64.82 29.61,64.23 27.33,64.23 26.78,64.78 26.78,66.04 26.3,66.52 17.09,66.52 13.2,70.41 13.2,71.52 13.88,72.19 13.88,74.93 13.28,75.53 13.28,76.78 13.52,77.03 13.52,80.02 13.24,80.3 v9(12.82,80.3)
TBT_A_TRX_DTX_N1: length 28.1
  TOP w0.145: v9(31.64,77.23) 31.61,77.17 arc(31.53,77.09) 31.42,77.06 31.34,77.06 arc(31.1,77.11) 30.91,77.26 arc(30.81,77.43) 30.77,77.62 30.77,78.33 arc(30.72,78.72) 30.54,79.07 arc(29.85,79.62) 29,79.81 23.11,79.81 arc(22.61,79.9) 22.16,80.14 22.15,80.15 arc(22.14,80.15) 22.13,80.16 arc(21.45,80.51) 20.69,80.63 16.15,80.63 arc(15.22,80.45) 14.43,79.92 arc(14.29,79.8) 14.16,79.66 14.15,79.65 arc(13.87,79.43) 13.51,79.36 11.69,79.36 arc(11.49,79.39) 11.33,79.5 DT8.1 11.2,79.41 arc(11.08,79.33) 10.93,79.3 10.75,79.3 arc(10.66,79.32) 10.58,79.37 10.51,79.44 arc(10.47,79.5) 10.45,79.58 10.45,79.94 arc(10.39,80.26) 10.2,80.54 10.2,80.54 arc(10.14,80.59) 10.08,80.63 10.07,80.63 arc(9.98,80.66) 9.87,80.67 9.8,80.67 arc(9.71,80.69) 9.63,80.74 9.63,80.75 arc(9.57,80.76) 9.5,80.77 JUSBC1.A10
  BOTTOM w0.076: UT2.A21 32.91,77.08 arc(32.98,77.11) 33.01,77.18 arc(32.97,77.27) 32.88,77.31 32.71,77.31 arc(32.59,77.29) 32.49,77.22 32.43,77.16 arc(32.4,77.13) 32.35,77.13 31.8,77.13 arc(31.76,77.13) 31.72,77.16 v9(31.64,77.23)
TBT_A_TRX_DTX_N2: length 29.2
  BOTTOM w0.076: 30.83,80.07 30.84,80.07 30.85,80.09 30.85,80.11 30.92,80.18 31.1,80.18 arc(31.13,80.17) 31.15,80.16 31.39,79.92 arc(31.58,79.79) 31.81,79.75 32.37,79.75 arc(32.43,79.73) 32.49,79.7 32.51,79.67 arc(32.57,79.63) 32.64,79.62 32.88,79.62 arc(33.02,79.65) 33.15,79.73 UT2.B15
  BOTTOM w0.145: 30.83,80.07 26.94,80.07 arc(25.9,80.28) 25.02,80.87 23.11,82.78 arc(23.1,82.79) 23.09,82.8 arc(22.84,82.95) 22.56,83.06 arc(21.43,83.33) 20.27,83.42 16.91,83.42 arc(16.03,83.56) 15.23,83.96 arc(14.84,84.28) 14.5,84.65 arc(14.41,84.76) 14.33,84.87 arc(14.21,85.03) 14.06,85.17 arc(13.79,85.35) 13.5,85.49 arc(13.35,85.55) 13.19,85.6 arc(13.01,85.64) 12.82,85.66 arc(12.67,85.68) 12.51,85.68 11.77,85.68 arc(11.52,85.63) DT27.1 11.24,85.57 arc(11.08,85.68) 10.89,85.73 arc(10.86,85.74) 10.82,85.74 10.82,85.74 arc(10.7,85.72) 10.61,85.65 9.9,84.95 arc(9.25,84.51) 8.47,84.35 7.27,84.35 arc(7.19,84.34) 7.13,84.31 6.9,84.13 JUSBC1.B10
TBT_A_TRX_DTX_P1: length 28.1
  TOP w0.145: v9(31.64,76.62) 31.64,76.63 arc(31.5,76.72) 31.34,76.75 arc(30.97,76.83) 30.67,77.06 arc(30.52,77.32) 30.47,77.62 30.47,78.33 arc(30.42,78.62) 30.29,78.89 arc(29.72,79.34) 29,79.5 23.11,79.5 arc(22.5,79.61) 21.95,79.91 arc(21.35,80.22) 20.69,80.32 16.15,80.32 arc(15.33,80.16) 14.63,79.7 arc(14.51,79.58) 14.39,79.45 14.39,79.45 arc(14,79.15) 13.51,79.05 12,79.05 arc(11.96,79.04) 11.92,79.04 arc(11.85,79.03) 11.78,79.02 arc(11.59,78.98) 11.42,78.87 DT4.1 arc(11.26,78.81) 11.21,78.85 11.04,78.96 arc(11,78.98) 10.96,78.99 10.75,78.99 arc(10.54,79.03) 10.36,79.15 10.29,79.22 arc(10.18,79.39) 10.14,79.58 10.14,79.94 arc(10.1,80.14) 9.98,80.32 arc(9.96,80.34) 9.94,80.35 arc(9.91,80.36) 9.87,80.37 9.69,80.37 arc(9.61,80.35) 9.55,80.31 arc(9.48,80.28) 9.4,80.27 JUSBC1.A11
  BOTTOM w0.076: v9(31.64,76.62) 31.91,76.89 arc(31.99,76.94) 32.08,76.96 32.45,76.96 arc(32.48,76.95) 32.51,76.93 arc(32.6,76.87) 32.7,76.85 32.81,76.85 arc(33.01,76.89) 33.18,77.01 UT2.B21
TBT_A_TRX_DTX_P2: length 29.2
  BOTTOM w0.076: UT2.A15 32.9,79.84 arc(32.96,79.86) 32.99,79.93 arc(32.95,80.02) 32.86,80.05 32.64,80.05 arc(32.59,80.04) 32.54,80.01 32.5,79.97 arc(32.44,79.93) 32.36,79.91 31.81,79.91 arc(31.65,79.94) 31.51,80.04 31.27,80.27 arc(31.19,80.33) 31.1,80.35 30.88,80.35 30.84,80.38 30.83,80.38
  BOTTOM w0.145: 30.83,80.38 26.94,80.38 arc(26.02,80.57) 25.24,81.09 23.33,83 arc(23.3,83.03) 23.26,83.05 arc(22.97,83.23) 22.66,83.36 arc(21.48,83.64) 20.27,83.73 16.91,83.73 arc(16.12,83.85) 15.41,84.21 arc(15.05,84.5) 14.74,84.84 arc(14.66,84.94) 14.59,85.04 arc(14.44,85.24) 14.25,85.41 arc(13.95,85.62) 13.62,85.78 arc(13.44,85.84) 13.26,85.9 arc(13.06,85.94) 12.86,85.97 arc(12.84,85.97) 12.82,85.97 arc(12.67,85.99) 12.51,85.99 11.7,85.99 arc(11.58,86.01) 11.49,86.08 DT31.1 11.19,86.13 arc(11.07,86.05) 10.93,86.04 arc(10.89,86.05) 10.85,86.05 arc(10.84,86.05) 10.84,86.05 10.82,86.05 arc(10.72,86.04) 10.62,86.02 arc(10.5,85.96) 10.39,85.87 9.68,85.17 arc(9.13,84.79) 8.47,84.66 7.45,84.66 arc(7.14,84.73) JUSBC1.B11
TBT_A_TTX_C_DRX_N1: length 25.4
  BOTTOM w0.145: JUSBC1.B3 6.97,80.85 arc(7.12,80.74) 7.29,80.66 8.73,80.66 arc(9.32,80.54) 9.82,80.21 10.58,79.44 arc(10.72,79.34) 10.89,79.3 arc(10.92,79.3) 10.94,79.29 arc(11.07,79.32) 11.19,79.4 DT7.1 11.38,79.45 arc(11.55,79.33) 11.75,79.29 arc(11.76,79.29) 11.77,79.29 12.59,79.29 arc(12.71,79.29) 12.82,79.3 arc(13.5,79.5) 14.07,79.9 arc(14.9,80.46) 15.88,80.65 20.45,80.65 arc(21.28,80.54) 22.04,80.21 23.62,79.26 arc(23.99,79.02) 24.33,78.73 24.34,78.73 24.4,78.67 arc(24.77,78.4) 25.22,78.27 25.69,78.21 arc(26.06,78.19) 26.43,78.19 30.09,78.19 arc(30.11,78.19) 30.13,78.18 30.2,78.18 arc(30.38,78.22) CT45.2
TBT_A_TTX_C_DRX_N2: length 24.9
  TOP w0.145: JUSBC1.A3 9.46,84.27 arc(9.56,84.29) 9.64,84.34 arc(9.7,84.36) 9.76,84.37 9.81,84.37 arc(10.05,84.41) 10.25,84.55 arc(10.3,84.61) 10.35,84.67 arc(10.47,84.9) 10.52,85.14 10.52,85.14 arc(10.52,85.17) 10.52,85.21 10.52,85.25 arc(10.56,85.42) 10.66,85.57 10.72,85.63 arc(10.83,85.71) 10.96,85.74 10.98,85.74 arc(11.06,85.72) 11.12,85.68 DT28.1 11.47,85.65 arc(11.68,85.79) 11.93,85.84 12.97,85.84 arc(14.19,85.6) 15.22,84.91 15.8,84.33 arc(16.7,83.68) 17.76,83.36 17.79,83.36 arc(17.84,83.35) 17.9,83.35 arc(19.5,83.05) 20.89,82.21 arc(20.9,82.2) 20.91,82.19 21.42,81.88 arc(21.47,81.83) 21.51,81.77 21.51,81.76 arc(21.52,81.72) 21.53,81.67 21.53,81.61 arc(21.5,81.57) 21.47,81.53 v9(21.43,81.48)
  BOTTOM w0.145: v9(21.43,81.48) 21.71,81.31 arc(21.76,81.27) 21.81,81.24 arc(21.86,81.2) 21.91,81.17 22.15,81.04 arc(23.07,80.43) 24.06,79.92 24.89,79.54 24.89,79.55 arc(26.43,79.11) 28.03,78.96 29.95,78.96 arc(30.03,78.96) 30.11,78.96 arc(30.33,78.95) CT41.2
TBT_A_TTX_C_DRX_P1: length 25.4
  BOTTOM w0.145: JUSBC1.B2 7.08,80.28 arc(7.16,80.33) 7.25,80.35 8.73,80.35 arc(9.2,80.26) 9.6,79.99 10.36,79.22 arc(10.48,79.12) 10.62,79.05 arc(10.74,79.01) 10.86,78.99 arc(10.9,78.99) 10.94,78.98 arc(10.95,78.98) 10.95,78.98 arc(11.08,78.96) 11.18,78.89 DT3.1 11.36,78.8 arc(11.55,78.93) 11.78,78.98 12.59,78.98 arc(12.71,78.98) 12.82,78.99 arc(13.62,79.21) 14.29,79.68 arc(15.02,80.17) 15.88,80.34 20.45,80.34 arc(21.19,80.24) 21.88,79.95 23.46,79 arc(23.8,78.77) 24.12,78.51 24.18,78.45 arc(24.64,78.12) 25.18,77.96 25.66,77.9 arc(26.04,77.88) 26.43,77.88 30.29,77.88 arc(30.4,77.85) 30.49,77.79 CT43.2
