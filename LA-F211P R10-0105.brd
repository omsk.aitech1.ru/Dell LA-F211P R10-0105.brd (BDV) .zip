# Allegro board LA-F211P R10-0105.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on VCC: 147.9,40.98 147.55,41.34 147.55,47.47 148.18,48.11 148.18,48.47 148.18,48.47 148.18,48.64 148.18,48.64 148.18,69.83 149.2,70.84 149.2,85.53 147.29,87.44 147.29,89.6 142.95,93.94 142.44,93.94 141.96,94.42 141.96,110.68 141.17,111.46 91.43,111.46 90.78,110.8 90.78,107.02 76.15,107.02 74.99,108.17 74.85,108.17 74.79,108.11 74.63,108.11 74.59,108.15 74.59,108.41 74.73,108.56 74.85,108.56 75.16,108.86 75.16,108.88 75.36,109.24 75.43,109.65 75.43,111.65 75.67,112.21 76.23,112.45 148.36,112.45 148.96,112.53 149.72,112.87 149.94,112.9 152.92,112.9 153.48,112.66 153.72,112.1 153.72,109.3 153.63,109.09 153.42,109 153.02,109 152.52,108.8 152.32,108.3 152.32,96.59 152.61,95.48 153.71,94.39 153.82,93.99 153.82,47.45 149.22,47.45 148.69,46.92 148.69,41.21 148.46,40.98
GND on VCC: 54.56,32.85 53.57,33.84 53.57,38.46 54.31,39.2 59.05,39.2 59.79,38.46 59.79,33.59 59.05,32.85
GND on VCC: 67.47,29.74 67.47,41.82 68.08,42.44 102.93,42.44 104.26,41.1 107.77,41.1 109.04,42.37 112.22,42.37 115.14,45.29 133.43,45.29 134.21,46.08 134.21,49.61 140.94,49.61 140.94,44.15 115.69,44.15 113.02,41.48 109.97,41.48 108.58,40.09 102.29,40.09 99.92,37.72 99.92,31.62 98.04,29.74
GND on VCC: 147.14,0.2 147.16,0.23 147.16,6.03 146.02,7.17 146.02,19.79 156.01,29.77 162.2,17.86 171.78,8.46 172.34,7.82 172.54,7 172.54,2 172.01,0.73 170.74,0.2 161.16,0.2 160.95,0.29 160.66,1 160.16,1.2 155.16,1.2 154.66,1 154.37,0.29 154.16,0.2
GND on GND3: outline of 209 points within 0.2,0.2 172.54,112.9
GND on IN3: 31.03,75.96 30.17,76.82 30.17,83.81 30.55,84.2 30.86,84.2 30.95,84.1 31.74,84.1 31.96,84.32 32.39,84.32 32.62,84.1 32.62,82.36 32.67,82.3 32.67,76.22 32.42,75.96
GND on GND4: outline of 209 points within 0.2,0.2 172.54,112.9 ; 18 cut-outs
V0.9_VR_EN on TOP (solid shape): 69.39,28.07 69.39,27.24 69.32,27.17 67.62,27.17 67.5,27.29 67.5,28.68 67.66,28.85 68.61,28.85
VCC0V9_LVR_OUT on TOP (solid shape): 33.8,79.55 34.79,79.55 34.85,79.5 34.85,78.99 34.97,78.86 36.04,78.86 36.09,78.81 36.09,78.43 36.06,78.4 35.05,78.4 35,78.35 33.35,78.35 33.32,78.38 33.32,79.46 33.52,79.66 33.68,79.66
VCC0V9_SVR on TOP (solid shape): 35.48,82.04 35.48,80.41 35.43,80.36 34.44,80.36 34.39,80.41 34.39,82.04 34.41,82.06 35.45,82.06
VCC0V9_SVR on TOP (solid shape): 36.93,83.23 36.93,83 36.98,82.95 36.98,82.89 37.04,82.89 37.16,82.77 37.97,82.77 38.05,82.7 38.05,82.31 38.02,82.29 36.98,82.29 36.9,82.37 36.9,82.62 36.84,82.68 36.84,82.75 36.78,82.75 36.65,82.87 36.5,82.87 36.45,82.92 36.45,83.33 36.47,83.36 36.8,83.36
VCC0V9_SVR on BOTTOM (solid shape): 31.34,91.46 31.34,87.78 31.29,87.73 29.72,87.73 29.16,88.28 28.72,88.28 28.67,88.33 28.67,91.59 28.74,91.65 31.15,91.65
VCC0V9_SVR on IN2 (solid shape): outline of 426 points within 28.73,80.01 37.81,90.35
VCC0V9_SVR on GND3: 29,90.38 28.83,90.21 28.83,88.61 28.89,88.55 29.71,88.55 30.21,89.04 30.21,89.92 29.75,90.38
VCC_3V3_USB2 on TOP (solid shape): 36.8,80.13 36.8,79.75 36.78,79.72 36.32,79.72 36.22,79.62 36.22,79.16 36.19,79.14 35.81,79.14 35.79,79.16 35.79,80.1 35.84,80.16 36.78,80.16
VCCGT_B+ on TOP (solid shape): 152.83,66.2 152.83,50.35 151.71,49.23 150.21,49.23 149.7,49.74 149.7,51.71 150.66,52.66 150.66,54.25 150.21,54.69 144.5,54.69 144.37,54.82 144.37,55.71 144.62,55.96 149.55,55.96 151.33,57.74 151.33,60.08 150.97,60.43 150.97,64.22 150.57,64.62 144.56,64.62 144.31,64.87 144.31,66 144.46,66.15 149.91,66.15 150.19,66.43 152.6,66.43
VCCGT_B+ on BOTTOM (solid shape): 152.27,66.2 152.27,48.85 151.86,48.44 147.43,48.44 147.27,48.6 147.27,49.46 148.92,51.11 149.73,51.11 150.19,51.57 150.19,53.32 150.64,53.78 150.64,54.29 150.16,54.77 150.16,54.97 149.98,55.15 146.4,55.15 146.3,55.05 145.69,55.05 145.56,55.17 145.56,55.4 145.77,55.61 149.6,55.61 150.26,56.27 150.26,56.5 150.54,56.77 151.61,56.77 151.69,56.85 151.69,57.62 151.15,58.15 151.15,60.2 150.21,61.14 150.21,62.34 150.9,63.02 150.9,64.29 150.69,64.5 150.69,64.75 150.49,64.95 146.83,64.95 146.66,64.78 146.28,64.78 146.2,64.85 146.2,65.26 146.28,65.33 146.81,65.33 146.83,65.31 150.16,65.31 151.2,66.35 152.12,66.35
VCCSA_B+ on TOP (solid shape): 108.43,38.99 108.43,35.46 108.44,35.46 108.44,35.32 109.06,34.69 109.06,33.55 109.03,33.51 107.39,33.51 107.29,33.61 107.29,39.07 107.49,39.27 108.15,39.27
VCCSA_B+ on BOTTOM (solid shape): 108.12,39.3 108.12,36.86 108.38,36.61 108.38,35.34 109.09,34.63 109.09,33.03 109,32.94 108.17,32.94 107.86,33.26 106.56,33.26 106.53,33.29 106.53,34.25 106.88,34.6 107.26,34.6 107.74,35.08 107.74,38.77 107.51,38.99 107.51,39.3 107.62,39.4 108.02,39.4
VDD12_LG on TOP (solid shape): 59.14,55.2 59.41,55.2 59.53,55.07 59.53,54.95 58.9,54.31 58.9,54.06 58.77,53.93 58.52,53.93 58.39,54.06 58.39,54.8 58.43,54.88 58.44,54.97 58.44,54.99 58.65,55.2 59.14,55.2
VDD12_LX on TOP (solid shape): 58.39,56.47 58.39,55.48 57.98,55.07 57.98,55.04 57.82,54.87 57.82,54.83 57.78,54.79 57.78,54.06 57.71,53.98 57.43,53.98 57.38,54.03 57.38,55.07 56.74,55.71 56.74,56.47 56.99,56.72 58.14,56.72
VDD12_LX on TOP (solid shape): 65.76,60.28 65.76,58.76 66.14,58.38 66.77,58.38 67.03,58.12 67.03,57.61 66.77,57.36 64.11,57.36 63.85,57.11 63.85,56.6 63.6,56.34 62.84,56.34 62.71,56.47 62.71,57.61 62.43,57.89 58.24,57.89 58.2,57.92 58.2,60.72 58.52,61.04 62.58,61.04 63.22,61.68 64.36,61.68
VDD12_LX on BOTTOM (solid shape): 65.76,60.28 65.76,59.26 65.63,59.14 64.87,59.14 64.84,59.11 64.81,59.11 64.81,59.08 64.74,59.01 64.74,58.5 64.81,58.43 64.81,58.4 64.84,58.4 64.87,58.38 66.77,58.38 67.03,58.12 67.03,57.36 66.65,56.98 62.84,56.98 62.58,57.23 62.58,61.3 62.84,61.55 64.49,61.55
VDD12_LX on IN1 (solid shape): 58.52,56.72 58.52,55.45 58.26,55.2 57.63,55.2 57.5,55.33 57.5,56.6 57.76,56.85 58.39,56.85
VDD12_LX on IN1 (solid shape): 65.88,61.17 65.88,58.76 66.27,58.38 66.77,58.38 67.03,58.12 67.03,57.36 66.77,57.11 62.46,57.11 61.95,57.61 61.95,59.26 60.93,60.28 60.93,61.42 61.31,61.8 65.25,61.8
VDD12_UG on TOP (solid shape): 57.25,54.95 57.25,54.06 57.12,53.93 56.61,53.93 56.49,54.06 56.49,55.33 56.61,55.45 56.74,55.45
VDD12_UG on TOP (solid shape): 59.17,64.84 59.17,63.64 59.05,63.52 57.48,63.52 57.33,63.67 57.33,64.9 57.46,65.03 57.76,65.03 57.76,65.03 58.98,65.03
VDD12_UG on IN1 (solid shape): 57.02,56.14 57.12,56.04 57.12,54.44 56.87,54.18 56.69,54.18 56.26,54.62 56.26,56.5 56.31,56.55 57.02,56.55
VDDCI_EN on TOP (solid shape): 69.7,48.19 69.7,46.53 69.65,46.48 68.41,46.48 68.32,46.56 67.82,46.56 67.74,46.48 67.49,46.23 67.09,46.23 66.98,46.34 66.98,47.32 67.6,47.94 67.6,48.35 67.67,48.42 69.46,48.42
VDDCI_VIN on TOP (solid shape): 64.98,51.42 64.98,50.19 65.06,50.11 65.72,49.44 67.34,49.44 67.42,49.36 67.42,49.18 67.35,49.11 64.33,49.11 64.03,49.4 64.03,50.02 63.41,50.64 63.41,51.43 63.46,51.48 64.92,51.48
VDDCIP_FB on TOP (solid shape): 68.83,51.58 68.83,51.23 68.74,51.13 68.25,51.13 68.02,50.9 68.02,49.7 67.99,49.67 67.8,49.67 67.71,49.77 67.71,50.86 67.43,51.13 67.04,51.13 66.85,51.32 66.85,51.97 66.98,52.1 68.31,52.1
VDDCIP_LX on TOP (solid shape): 69.18,50.6 69.18,50.5 69.18,50.49 69.18,48.71 69.09,48.62 65.71,48.62 65.61,48.72 65.61,48.87 65.68,48.94 67.51,48.94 67.6,49.03 67.6,49.4 67.67,49.47 68.29,49.47 68.33,49.51 68.33,50.51 68.54,50.72 69.06,50.72
VDDCIP_LX on BOTTOM (solid shape): 68.68,52.72 69,52.72 69.2,52.52 69.2,49.24 68.58,48.62 65.48,48.62 64.74,49.35 64.74,50.95 64.8,51.01 65.95,51.01 66.09,51.15 66.09,52.35 66.47,52.72 68.68,52.72
VDDCIP_LX on IN3 (solid shape): 69.17,50.63 69.17,49.28 68.5,48.61 67.26,48.61 67.06,48.81 67.06,49.7 68.09,50.72 69.07,50.72
VDDCIP_LX on IN1: 69.06,50.72 68.55,50.72 68.33,50.5 68.33,49.51 68.29,49.46 67.79,49.46 67.61,49.29 67.61,48.69 67.67,48.63 68.53,48.63 69.18,49.28 69.18,50.6
1.05_VMMP_ALW_LX on TOP (solid shape): 19.91,22.92 19.91,22.24 19.85,22.18 19.08,22.18 18.84,22.42 18.84,22.51 18.67,22.69 18.03,22.69 17.94,22.78 17.94,22.98 18.02,23.06 19.53,23.06 19.57,23.09 19.74,23.09
1.05_VMMP_ALW_LX on TOP (solid shape): 25.63,21.93 25.63,20.53 25.56,20.47 22.51,20.47 22.3,20.26 22.3,19.72 22.21,19.63 21.51,19.63 21.37,19.77 21.37,21.8 21.43,21.86 22.64,21.86 22.96,22.18 25.37,22.18
1.05_VMMP_ALW_LX on IN1 (solid shape): 20.53,22.31 21.05,22.31 21.24,22.12 25.56,22.12 25.63,22.05 25.63,20.53 25.56,20.47 21.31,20.47 20.99,20.78 18.96,20.78 18.89,20.85 18.89,22.69 19.34,23.13 19.71,23.13
3S_BATT+ on BOTTOM (solid shape): 143.51,7.27 143.51,4.77 143.69,4.59 144.16,4.59 144.23,4.52 144.23,4.26 143.35,3.38 143.35,2.5 143.29,2.43 142.21,2.43 141.96,2.69 141.96,4.15 141.7,4.4 140.81,4.4 140.62,4.59 140.62,5.54 141.39,5.54 141.58,5.73 141.58,6.11 141.39,6.31 140.62,6.31 140.62,7 140.81,7.19 141.39,7.19 141.58,7.38 143.39,7.38
+1.05_VMM_ALW on TOP (solid shape): 26.83,25.8 26.83,24.59 26.45,24.21 26.21,24.21 26.15,24.14 24.63,24.14 24.54,24.23 24.54,24.65 24.57,24.68 24.82,24.68 24.89,24.75 24.89,25.86 24.91,25.89 26.74,25.89
+1.05_VMM_ALW on IN2 (solid shape): 89.51,25.36 89.51,24.74 88.98,24.21 88.11,24.21 87.86,24.47 87.86,25.09 88.24,25.48 89.38,25.48
+1.05_VMM_ALW on IN3 (solid shape): 90.14,25.1 90.14,24.59 89.73,24.18 88.5,24.18 88.36,24.32 88.36,25.1 88.45,25.18 90.06,25.18
+1.05_VMM_ALW on VCC: 77.04,22.31 76.28,23.07 24.59,23.07 24.36,23.3 24.36,25.38 24.46,25.48 78.99,25.48 79.75,24.72 83.13,24.72 83.9,25.48 89.53,25.48 90.01,25 90.01,23.68 88.64,22.31
+1.05_VMMP_ALW on TOP (solid shape): 24.15,26.55 24.49,26.55 24.74,26.31 24.74,25.61 24.16,25.61 24.16,25.1 24.74,25.1 24.74,24.85 24.42,24.85 24.23,24.66 24.23,24.28 24.48,24.02 25.59,24.02 25.69,23.92 25.69,22.88 25.56,22.75 23.15,22.75 22.58,23.32 22.58,24.19 22.65,24.4 22.58,24.61 22.58,26.56 24.14,26.56
+CHG_SRC_20V on TOP (solid shape): 155.52,12.02 155.52,10.46 155.43,10.37 153.26,10.37 153.1,10.53 153.1,11.31 153.91,12.12 155.42,12.12
+CHG_SRC_20V on TOP (solid shape): 157.32,16.79 157.32,15.23 157.05,14.96 155.15,14.96 154.76,14.56 153.13,14.56 152.94,14.75 152.94,16.4 153.47,16.93 157.19,16.93
+CHG_SRC_20V on BOTTOM (solid shape): 161.01,16.4 161.01,12.99 160.78,12.76 160.4,12.76 160.22,12.58 160.22,11.52 160.14,11.45 154.09,11.45 153.65,11.01 153.65,7.9 153.26,7.51 150.53,7.51 150.15,7.89 148.2,7.89 148.1,7.99 148.1,9.38 148.43,9.71 148.43,15.7 148.61,15.88 153.22,15.88 154.53,17.18 154.53,17.52 154.66,17.65 159.76,17.65
+CHG_VIN_20V on TOP (solid shape): 145.54,5.68 145.54,3.28 146.48,2.34 146.48,1.43 146.22,1.17 142.69,1.17 142.57,1.3 142.57,5.77 142.83,6.04 145.18,6.04
+CHG_VIN_20V on TOP (solid shape): 25.88,94.37 25.88,93.61 26.13,93.35 26.13,92.72 25.96,92.55 25.38,92.55 24.84,93.09 24.84,93.1 24.83,93.1 24.67,93.26 24.17,93.26 24.03,93.4 24.03,93.98 24.23,94.18 25.17,94.18 25.45,94.45 25.8,94.45
+CHG_VIN_20V on BOTTOM (solid shape): 5.6,62.74 5.6,59.51 5.08,58.99 3.07,58.99 2.87,59.19 2.87,62.72 3.13,62.98 5.36,62.98
+CHG_VIN_20V on BOTTOM (solid shape): 25.91,94.73 25.91,93.74 25.72,93.55 25.37,93.55 25.24,93.43 25.24,92.92 24.99,92.67 23.97,92.67 23.85,92.54 23.59,92.54 23.47,92.67 23.47,94.44 23.85,94.82 25.82,94.82
+CHG_VIN_20V on BOTTOM (solid shape): 17.28,65.7 17.28,64.42 17.47,64.23 17.8,64.23 18.03,64.46 18.03,65.23 18.16,65.36 20.74,65.36 20.96,65.14 20.96,63.05 20.71,62.8 12.92,62.8 12.84,62.89 12.84,66.02 12.98,66.17 16.82,66.17
+CHG_VIN_20V on BOTTOM (solid shape): 148.09,4.81 148.79,4.81 148.89,4.71 148.89,4.22 148.74,4.07 147.65,4.07 146.78,3.19 146.02,3.19 145.83,3 145.83,2.69 146.08,2.43 146.78,2.43 146.78,1.48 146.53,1.23 143.67,1.23 143.54,1.35 143.54,3.36 144.97,4.78 145.89,4.78 146.38,5.27 147.63,5.27
+CHG_VIN_20V on BOTTOM (solid shape): 116.15,12.87 116.15,10.6 116.33,10.43 116.33,8.88 115.8,8.36 114.54,8.36 114.42,8.48 113.93,8.48 113.42,7.98 113.42,7.72 113.17,7.46 111.83,7.46 111.74,7.55 111.74,8.27 111.78,8.4 111.74,8.53 111.74,10.1 111.97,10.33 112.23,10.33 112.72,10.82 112.72,12.1 112.91,12.29 113.3,12.29 113.31,12.26 113.65,12.2 113.68,12.54 113.68,13.12 113.83,13.27 115.75,13.27
+CHG_VIN_20V on GND2 (solid shape): 26.21,94.03 26.21,93.27 25.21,92.27 24.97,92.27 24.51,91.81 23.94,91.81 23.75,92 23.75,94 23.93,94.18 26.06,94.18
+CHG_VIN_20V on IN2 (solid shape): outline of 6570 points within 1.83,1.17 146.78,61.55
+CHG_VIN_20V on GND3 (solid shape): 26.21,94.3 26.21,93.35 24.64,91.79 24.14,91.79 23.43,92.49 23.43,94.39 23.89,94.85 25.66,94.85
+CHG_VIN_20V on GND3 (solid shape): 15.49,65.56 15.63,65.56 15.74,65.45 15.74,63.59 15.65,63.5 14.38,63.5 14.22,63.66 14.22,64.31 13.79,64.74 13.79,65.89 13.89,65.99 15.06,65.99
+CHG_VIN_20V on VCC: 107.36,1.17 107.36,1.17 100.37,1.17 98.21,2.64 96.05,1.17 2.98,1.17 2.98,1.97 2.66,2.95 1.83,3.56 1.83,19.92 2.66,20.53 2.98,21.51 2.98,24.41 2.98,24.41 2.98,27.6 2.7,28.52 1.97,29.13 1.97,45.77 2.56,46.38 2.78,47.2 2.78,47.95 2.99,48.16 3.35,48.7 3.48,49.34 3.48,50.49 3.48,50.49 3.48,52.92 3.35,53.56 2.99,54.1 2.64,54.46 2.64,54.45 1.83,55.26 1.83,56.59 1.65,57.33 1.17,57.92 1.17,69.81 6.68,69.81 9.75,72.87 9.75,93.28 15.35,98.89 29.84,98.89 29.94,98.78 29.94,95.06 26.41,91.52 19.68,91.52 18.01,89.85 18.01,69.15 16.68,67.83 16.68,63.97 16.25,63.53 12.39,63.53 11.15,62.29 11.15,57.97 10.79,57.61 8.5,57.61 7.85,56.96 7.85,14.07 14.34,7.58 96.85,7.58 100.28,11 115.44,11 119.63,6.81 145.66,6.81 146.66,5.82 146.66,1.17 135.33,1.17 135.33,1.5 134.84,2.68 133.66,3.17 117.94,3.17 117.94,3.17 116.87,3.17 116.27,3.68 115.51,3.87 109.51,3.87 108.33,3.38 107.84,2.2 107.84,1.17
+DC_IN_1 on TOP (solid shape): 16.47,73.86 16.47,72.54 16.26,72.33 14.71,72.33 14.58,72.45 14.58,73.86 14.67,73.95 16.38,73.95
+DC_IN_1 on BOTTOM (solid shape): 16.26,72.77 16.26,71.37 16.34,71.29 18.67,71.29 19.05,70.91 19.05,70.45 19.02,70.43 18.64,70.43 18.57,70.49 18.57,70.74 18.44,70.87 17.73,70.87 17.59,70.73 17.59,70.17 17.52,70.1 16.1,70.1 16,70.21 16,70.5 15.82,70.67 15.47,70.67 15.22,70.42 15.22,69.45 14.99,69.21 12.87,69.21 12.58,68.92 11.52,68.92 11.33,69.11 11.33,72.05 11.54,72.26 12.87,72.26 13.18,72.58 14.99,72.58 15.29,72.87 16.16,72.87
+DC_IN_2 on TOP (solid shape): 19.14,101.89 19.14,100.85 18.79,100.5 18.79,99.57 19.12,99.24 19.12,97.59 19.4,97.31 19.95,97.31 20.08,97.18 20.08,96.59 19.96,96.48 17.75,96.48 17.45,96.78 17.45,100.53 17.48,100.56 17.88,100.56 18.04,100.71 18.04,101.69 18.52,102.18 18.86,102.18
+DC_IN_2 on BOTTOM (solid shape): 18.89,99.02 20.55,99.02 20.65,99 20.74,99.02 20.83,99.02 20.88,98.97 20.88,98.75 20.86,98.67 20.87,98.6 20.86,98.52 20.88,98.44 20.88,98.19 20.86,98.11 20.87,98.04 20.86,97.98 20.87,97.8 21.08,97.59 22.75,97.59 22.86,97.49 22.86,95.94 22.75,95.84 21.36,95.84 20.48,94.96 20.48,94.56 20.42,94.51 19.28,94.51 19.22,94.45 17.87,94.45 17.8,94.38 16.96,94.38 16.94,94.4 16.94,94.9 17.67,95.63 17.67,99.3 17.89,99.52 18.39,99.52
+DC_IN_2 on IN1 (solid shape): outline of 149 points within 17.45,96.22 21.89,100.03
+EVDDC on IN1 (solid shape): outline of 83 points within 86.45,60.32 87.63,62.03
+EVDDQ on IN1 (solid shape): 84.97,61.38 84.97,60.79 85.07,60.69 85.08,60.66 85.11,60.63 85.15,60.6 85.18,60.58 85.28,60.48 85.28,59.66 85.2,59.58 84.88,59.58 83.89,60.57 83.89,60.94 84.15,60.94 84.15,60.89 84.15,60.85 84.17,60.81 84.19,60.78 84.22,60.75 84.25,60.72 84.29,60.7 84.33,60.69 84.38,60.69 84.42,60.69 84.46,60.7 84.5,60.72 84.53,60.75 84.56,60.78 84.58,60.81 84.6,60.85 84.6,60.89 84.6,60.94 84.6,60.98 84.58,61.02 84.56,61.05 84.53,61.08 84.5,61.11 84.46,61.13 84.42,61.14 84.38,61.14 84.33,61.14 84.29,61.13 84.25,61.11 84.22,61.08 84.19,61.05 84.17,61.02 84.15,60.98 84.15,60.94 83.89,60.94 83.89,61.55 84.18,61.84 84.51,61.84
+INV_PWR_SRC on TOP (solid shape): 66.52,93.66 66.52,92.28 66.24,92.01 65.15,92.01 64.82,92.33 65,92.84 64.56,93.16 64.38,93.16 64.35,93.16 64.35,93.62 64.46,93.74 66.44,93.74
+INV_PWR_SRC on BOTTOM (solid shape): 64.11,94.82 64.11,94.26 64.47,93.89 65.96,93.89 66.08,93.77 66.08,92.59 65.97,92.48 63.91,92.48 63.22,93.17 63.09,93.17 62.71,93.55 62.71,94.82 62.84,94.95 63.98,94.95
+LCDVDD on TOP (solid shape): 57.76,95.75 57.76,94.32 57.63,94.19 56.99,94.19 56.98,94.18 56.96,94.18 56.72,93.94 55.9,93.94 55.73,94.1 55.73,95.22 56.55,96.04 57.47,96.04
+LCDVDD on BOTTOM (solid shape): 57.63,94.82 57.63,93.17 57.5,93.05 55.85,93.05 55.72,93.17 55.72,94.82 55.85,94.95 57.5,94.95
+LCDVDD on BOTTOM (solid shape): 64.27,91.87 64.27,90.47 64.16,90.35 63.27,90.35 63.1,90.19 62.65,90.19 62.52,90.31 62.52,90.89 62.52,90.9 62.52,91.46 62.96,91.9 62.96,92.54 63.09,92.67 63.47,92.67
+LCDVDD on IN2 (solid shape): 57.63,95.46 60.68,95.46 61.23,94.91 61.26,94.84 61.23,94.77 61.25,94.35 61.66,94.34 61.73,94.36 61.8,94.33 63.98,92.16 63.98,91.54 63.94,91.47 63.86,91.44 63.52,91.12 63.91,90.85 63.92,90.85 63.98,90.85 63.98,90.44 63.66,90.13 62.58,90.13 62.46,90.25 62.46,91.52 59.81,94.17 59.81,94.2 59.53,94.54 59.2,94.24 59.19,94.2 59.15,94.19 58.56,94.19 58.55,94.22 58.26,94.42 57.98,94.22 57.97,94.19 56.11,94.19 55.72,94.57 55.72,95.84 55.85,95.97 57.12,95.97
+ODR_PWR on TOP (solid shape): 17.75,65.23 17.75,63.96 17.62,63.84 16.86,63.84 16.48,64.22 14.83,64.22 14.7,64.34 14.7,64.66 14.89,64.85 16.43,64.85 16.48,64.91 16.48,65.38 16.53,65.42 17.56,65.42
+ODR_PWR on IN1 (solid shape): 17.67,66.23 17.67,64.9 17.5,64.73 16.74,64.73 16.61,64.85 16.61,66.21 16.83,66.44 17.47,66.44
+ODR_PWR on IN1 (solid shape): 23.24,68.15 23.24,67.04 22.7,66.5 21.79,66.5 21.79,67.52 22.42,67.52 22.55,67.65 22.55,68.2 22.63,68.28 23.11,68.28
+RTCBATT on BOTTOM (solid shape): 164.94,7.27 164.94,5.67 164.69,5.42 163.42,5.42 163.1,5.73 163.1,7.28 163.32,7.5 164.71,7.5
+SD_VDD2 on TOP (solid shape): 3.53,64.73 3.53,62.31 3.27,62.06 1.63,62.06 1.5,62.19 1.5,62.59 1.6,62.69 2.77,62.69 2.89,62.82 2.89,64.73 2.96,64.79 3.09,64.79 3.15,64.85 3.4,64.85
+SD_VDD2 on BOTTOM (solid shape): 7.46,70.57 7.46,70.25 7.34,70.12 7.34,69.55 7.22,69.44 6.6,69.44 6.38,69.65 6.38,70.57 6.55,70.73 7.3,70.73
+SD_VDD2 on BOTTOM (solid shape): 6.31,66.47 6.31,64.14 5.88,63.71 3.08,63.71 2.96,63.84 2.96,64.66 3.08,64.79 3.4,64.79 3.59,64.6 4.45,64.6 4.72,64.87 4.72,66.43 4.85,66.56 6.22,66.56
+SD_VDD2 on IN1 (solid shape): 8.29,70.76 8.29,70.06 6.58,70.06 6.38,70.25 6.38,70.69 6.51,70.82 8.23,70.82
+TBT_VBUS1 on TOP (solid shape): 20.04,76.92 20.04,76.54 19.53,76.03 19.53,75.14 19.66,75.01 20.29,75.01 20.37,75.09 20.37,75.3 20.42,75.35 20.84,75.35 20.89,75.3 20.89,74.85 20.32,74.28 18.48,74.28 17.95,74.81 17.95,76.54 18.08,76.66 18.66,76.66 19.16,77.17 19.78,77.17
+TBT_VBUS1 on BOTTOM (solid shape): 15.88,76.43 15.88,75.84 16.04,75.69 17.7,75.69 18.14,75.24 18.14,74 18,73.86 16.47,73.86 16.24,73.63 16.24,73.1 16.16,73.02 15.23,73.02 14.91,72.69 12.14,72.69 11.67,73.16 11.13,73.16 11.04,73.25 11.04,73.83 11.16,73.95 11.41,73.95 11.6,74.14 11.6,74.82 11.69,74.91 11.85,74.91 11.97,75.02 11.97,75.96 12.06,76.06 12.93,76.06 13.05,75.94 13.14,75.94 13.21,75.87 13.21,75.57 13.21,75.57 13.21,75.21 13.36,75.07 14.92,75.07 15.17,75.32 15.17,76.46 15.28,76.56 15.75,76.56
+TBT_VBUS1 on IN1 (solid shape): 9.81,84.16 9.81,83.65 9.69,83.52 7.52,83.52 7.36,83.68 7.36,84.11 7.53,84.28 9.69,84.28
+TBT_VBUS1 on IN1 (solid shape): 9.81,81.43 9.81,80.92 9.62,80.73 7.63,80.73 7.38,80.98 7.38,81.33 7.54,81.49 9.75,81.49
+TBT_VBUS1 on GND2 (solid shape): 9.94,84.66 9.94,83.83 9.75,83.64 9.18,83.64 8.99,83.83 8.99,84.72 9.12,84.85 9.75,84.85
+TBT_VBUS1 on GND2 (solid shape): 9.95,81.21 9.95,80.32 9.82,80.19 9.19,80.19 9,80.38 9,81.21 9.19,81.4 9.76,81.4
+TBT_VBUS1 on GND2 (solid shape): 19.15,74.87 19.15,74.46 19.06,74.37 16.32,74.37 16.04,74.64 16.04,74.88 16.16,74.99 19.03,74.99
+TBT_VBUS1 on GND2 (solid shape): 13.97,75.09 13.97,72.21 13.87,72.11 13.73,72.11 13.72,72.11 12.44,72.11 12.17,72.37 12.17,74.97 12.44,75.23 13.83,75.23
+TBT_VBUS1 on IN2 (solid shape): outline of 488 points within 7.35,72.08 17.84,86.06
+TBT_VBUS1 on GND3 (solid shape): 9.94,84.72 9.94,83.77 9.75,83.58 9.18,83.58 8.99,83.77 8.99,84.66 9.18,84.85 9.81,84.85
+TBT_VBUS1 on GND3 (solid shape): 9.95,81.27 9.95,80.38 9.76,80.19 9.12,80.19 9,80.32 9,81.27 9.19,81.46 9.76,81.46
+TBT_VBUS1 on GND3 (solid shape): 14.03,75.02 14.03,72.23 13.9,72.1 12.65,72.1 12.47,72.28 12.47,72.65 11.74,73.39 11.4,73.39 11.32,73.46 11.32,73.65 11.63,73.96 11.63,74.89 11.98,75.24 13.81,75.24
+TBT_VBUS1 on IN3 (solid shape): outline of 338 points within 7.39,72.2 13.67,84.47
+TBT_VBUS2 on TOP (solid shape): 20.79,98.9 21.25,98.9 21.95,98.21 21.95,98.03 21.7,97.79 21.7,96.37 21.98,96.09 22.82,96.09 23.48,95.44 25.28,95.44 25.39,95.32 25.39,94.99 24.98,94.58 22.71,94.58 22.12,95.17 22.11,95.19 21.97,95.48 21.68,95.62 21.67,95.62 21.19,96.1 21.19,96.51 21.18,96.52 21.18,96.58 20.84,96.92 20.84,97.74 20.77,97.81 20.32,97.81 20.24,97.89 20.24,98.61 20.54,98.9
+TBT_VBUS2 on BOTTOM (solid shape): 13.62,106.23 13.62,104.58 13.84,104.36 14.39,104.36 15.87,102.88 16.15,102.88 16.36,102.66 16.67,102.66 16.82,102.52 16.91,102.45 16.88,102.34 17.1,101.77 17.33,102.34 17.3,102.46 17.4,102.52 19.68,102.52 19.72,102.48 19.72,102 19.72,102 19.72,101.26 19.85,101.14 21.01,101.14 21.28,101.4 22.73,101.4 22.86,101.28 22.86,99.73 22.86,99.6 22.65,99.4 21.38,99.4 21.12,99.65 20.74,99.65 20.65,99.66 20.55,99.65 17.75,99.65 17.37,100.03 16.14,100.03 15.83,100.34 15.83,100.62 15.83,100.63 15.83,100.69 13.46,103.05 12.17,103.05 11.83,103.39 11.83,106.23 11.99,106.38 13.47,106.38
+TBT_VBUS2 on IN1 (solid shape): 9.81,100.29 9.81,99.9 9.68,99.77 7.41,99.77 7.39,99.79 7.39,100.37 7.5,100.48 9.62,100.48
+TBT_VBUS2 on IN1 (solid shape): 8.22,97.68 8.25,97.65 8.31,97.61 8.4,97.59 8.5,97.61 8.51,97.62 9.75,97.62 9.81,97.55 9.81,96.98 9.75,96.92 8.04,96.92 8.03,96.92 7.56,96.92 7.38,97.1 7.38,97.54 7.53,97.68
+TBT_VBUS2 on GND2 (solid shape): 9.94,100.86 9.94,100.03 9.75,99.84 9.18,99.84 8.99,100.03 8.99,100.92 9.12,101.05 9.75,101.05
+TBT_VBUS2 on GND2 (solid shape): 9.95,97.41 9.95,96.52 9.82,96.39 9.19,96.39 9,96.58 9,97.41 9.19,97.6 9.76,97.6
+TBT_VBUS2 on IN2 (solid shape): outline of 775 points within 7.37,93.97 21.67,104.29
+TBT_VBUS2 on GND3 (solid shape): 9.94,100.92 9.94,99.97 9.75,99.78 9.18,99.78 8.99,99.97 8.99,100.86 9.18,101.05 9.81,101.05
+TBT_VBUS2 on GND3 (solid shape): 9.95,97.47 9.95,96.58 9.76,96.39 9.12,96.39 9,96.52 9,97.47 9.19,97.66 9.76,97.66
+TBT_VBUS2 on IN3 (solid shape): outline of 478 points within 7.37,96.54 21.82,104.67
+VGA_CORE on TOP (solid shape): outline of 887 points within 69.82,41.48 103.89,78.24
+VGA_CORE on BOTTOM (solid shape): outline of 1114 points within 83.25,76.09 102.72,77.23
+VGA_CORE on BOTTOM (solid shape): outline of 3222 points within 68.81,43.14 102.65,63.33
+VGA_CORE on IN1 (solid shape): outline of 8388 points within 69.73,42.53 102.84,77.3
+VGA_CORE on GND2 (solid shape): 79.05,44.69 79.05,44.34 78.7,43.99 77.25,43.99 77.12,44.13 77.12,44.68 77.21,44.77 78.97,44.77
+VGA_CORE on GND2 (solid shape): 83.75,47.45 83.75,47.13 83.1,46.48 82.12,46.48 81.78,46.82 81.78,47.45 81.89,47.57 83.64,47.57
+VGA_CORE on GND2 (solid shape): 88.34,44.59 88.34,43.61 87.99,43.27 87.36,43.27 87.24,43.39 87.24,45.13 87.36,45.24 87.68,45.24
+VGA_CORE on IN2 (solid shape): outline of 12251 points within 68.81,42.94 103.05,77.3
+VGA_CORE on GND3 (solid shape): 83.75,47.45 83.75,47.13 83.1,46.48 82.12,46.48 81.78,46.82 81.78,47.45 81.89,47.57 83.64,47.57
+VGA_CORE on GND3 (solid shape): 88.34,44.59 88.34,43.61 87.99,43.27 87.36,43.27 87.24,43.39 87.24,45.13 87.36,45.24 87.68,45.24
+VGA_CORE on IN3 (solid shape): outline of 7445 points within 68.93,42.88 103.65,77.23
+VGA_CORE on GND2: 80.11,48.85 80.74,48.22 80.74,47.07 80.11,46.44 77.44,46.44 77.19,46.69 77.19,47.07 77.7,47.58 77.7,48.34 78.2,48.85
+VGA_CORE on GND2: 72.11,46.56 70.08,46.56 69.57,47.07 69.57,48.22 70.2,48.85 71.98,48.85 72.62,48.22 72.62,47.07
+VGA_CORE on VCC: 70.24,42.94 69.69,43.49 69.69,49 70.18,49.49 72.09,49.49 72.62,50.01 72.62,54.59 73.1,55.07 79.2,55.07 79.85,55.73 79.85,67.16 79.96,67.27 81.36,67.27 81.76,67.67 81.76,73.09 81.23,73.62 79.96,73.62 79.85,73.72 79.85,77.3 102.42,77.3 102.9,76.81 102.9,43.3 102.55,42.94
+VGA_CORE on GND3: 80.11,48.85 80.74,48.22 80.74,47.45 80.11,46.82 78.33,46.82 77.7,47.45 77.7,48.22 78.33,48.85
+VGA_CORE on GND3: 71.98,48.85 72.62,48.22 72.62,47.45 71.98,46.82 70.2,46.82 69.57,47.45 69.57,48.22 70.2,48.85
+VGA_CORE_LX1 on BOTTOM (solid shape): 86.74,41.64 86.76,41.61 87.6,41.61 87.6,42.53 90.36,42.53 90.71,42.18 90.71,38.56 91,38.27 91,36.86 90.28,36.86 90.26,36.88 90.26,38.05 89.98,38.33 86.3,38.33 86.24,38.38 86.24,39.56 85.96,39.85 85.54,39.85 85.42,39.97 85.42,42.53 85.44,42.55 86.74,42.55
+VGA_CORE_LX2 on BOTTOM (solid shape): 70.66,41.64 71.5,41.64 71.5,42.55 71.52,42.58 73.11,42.58 73.75,41.93 73.95,41.73 73.95,39.52 73.75,39.32 73.75,36.95 73.67,36.87 72.97,36.87 72.95,36.88 72.95,38.16 72.73,38.38 68.95,38.38 68.95,39.26 69.31,39.62 69.31,42.45 69.24,42.52 69.3,42.58 70.66,42.58
+VGA_CORE_LX3 on BOTTOM (solid shape): 78.74,41.66 78.76,41.64 79.6,41.64 79.6,42.55 81.2,42.55 82.23,41.52 82.23,36.91 82.2,36.88 81.49,36.88 81.44,36.93 81.44,38.16 81.24,38.36 77.5,38.36 77.42,38.45 77.42,42.55 77.44,42.58 78.74,42.58
+VGA_CORE_LX4 on BOTTOM (solid shape): 95.48,41.55 96.36,41.55 96.36,42.5 98.73,42.5 99.05,42.18 99.05,40.28 99.86,39.46 99.86,36.98 99.74,36.85 99.12,36.85 99.05,36.92 99.05,38.16 98.85,38.37 95.08,38.37 94.99,38.46 94.99,39.66 94.68,39.98 94.24,39.98 94.14,40.08 94.14,42.47 94.19,42.53 95.48,42.53
+VPP_25 on TOP (solid shape): 82.38,66.48 82.38,64.4 82.25,64.27 80.41,64.27 79.89,64.79 79.28,64.79 79.14,64.93 79.14,66.55 79.24,66.64 82.22,66.64
+VPP_25 on BOTTOM (solid shape): outline of 150 points within 76.3,64.28 80.43,65.87
+VPP_25 on IN1 (solid shape): 75.58,66.25 78.39,66.25 78.71,65.94 78.71,65.37 78.58,65.23 75.13,65.23 73.38,66.98 71.41,66.98 71.24,67.15 71.24,67.96 71.35,68.07 73.77,68.07
+VPP_25 on GND2 (solid shape): 79.83,65.83 79.83,65.39 79.67,65.23 78.62,65.23 78.36,65.48 78.36,65.84 78.59,66.07 79.6,66.07
+VPP_25 on IN2 (solid shape): 62.05,68.97 62.05,68.86 61.42,68.23 61.35,68.23 60.31,69.27 60.31,69.41 60.88,69.99 61.03,69.99
+VPP_25 on IN2 (solid shape): 71.72,67.95 71.72,67.13 71.58,66.99 69.52,66.99 69.47,67.05 69.47,67.98 69.52,68.03 71.63,68.03
B+ on TOP (solid shape): 55.72,63.71 55.72,62.57 55.34,62.19 53.57,62.19 53.31,62.44 53.31,63.84 53.95,64.47 54.96,64.47
B+ on TOP (solid shape): 61.69,99.78 61.69,96.9 61.52,96.73 59.92,96.73 59.67,96.97 59.67,99.66 60.04,100.03 61.44,100.03
B+ on TOP (solid shape): 119.66,19.06 119.66,17.86 119.27,17.48 116.68,17.48 116.56,17.61 116.56,19.08 116.71,19.23 119.48,19.23
B+ on TOP (solid shape): 59.98,106.44 59.98,104.98 59.53,104.54 58.84,104.54 58.64,104.34 58.44,104.34 58.38,104.29 57.31,104.29 57.12,104.48 57.12,106.38 57.31,106.57 59.85,106.57
B+ on TOP (solid shape): 99.29,29.74 99.29,28.78 98.9,28.4 97.32,28.4 97.32,28.91 96.81,28.91 96.81,28.4 96.12,28.4 95.97,28.56 95.97,29.23 96.67,29.93 99.09,29.93
B+ on TOP (solid shape): 139.27,86.2 139.27,85.97 139.74,85.51 141.48,85.51 141.55,85.45 141.55,82.65 141.48,82.58 139.85,82.58 139.53,82.9 138.97,82.9 138.9,82.97 138.9,84.25 137.82,85.33 137.82,86.15 137.98,86.31 139.16,86.31
B+ on BOTTOM (solid shape): 151.99,47.7 151.99,45.41 151.61,45.03 148.82,45.03 148.68,45.18 148.68,47.69 148.83,47.83 151.85,47.83
B+ on BOTTOM (solid shape): 8.99,56.6 8.99,55.96 8.73,55.71 7.89,55.71 7.57,55.39 7.57,55.12 7.37,54.92 6.05,54.92 6,54.98 6,56.04 7.07,57.11 8.48,57.11
B+ on BOTTOM (solid shape): 84.05,91.4 84.05,90.89 83.16,90 82.39,90 82.01,90.38 82.01,90.7 81.95,90.76 81.95,91.52 82.01,91.59 82.01,91.78 82.27,92.03 83.41,92.03
B+ on BOTTOM (solid shape): 106.29,34.27 106.29,33.27 106.4,33.15 107.78,33.15 108.15,32.79 110.43,32.79 110.51,32.87 110.51,33.27 110.53,33.29 111.48,33.29 111.6,33.17 111.6,30.75 111.48,30.63 104.53,30.63 104.52,30.64 104.16,30.64 103.98,30.82 103.98,34.07 104.28,34.38 106.17,34.38
B+ on BOTTOM (solid shape): 9.78,18.46 9.78,17.37 9.82,17.34 9.82,17.32 9.84,17.32 9.85,17.3 9.88,17.3 9.89,17.29 10.88,17.29 11.04,17.14 11.04,16.99 10.26,16.21 8.36,16.21 8.17,16.4 8.17,17.24 7.85,17.56 7.85,18.37 7.85,18.37 7.85,18.59 8.08,18.82 9.43,18.82
B+ on BOTTOM (solid shape): 60.3,75.01 60.3,73.49 60.04,73.23 52.93,73.23 52.42,72.73 52.42,66.63 53.18,65.87 53.18,64.85 53.44,64.6 54.71,64.6 54.96,64.34 54.96,63.46 54.58,63.07 52.8,63.07 51.79,64.09 51.79,65.11 50.77,66.12 50.77,73.36 52.17,74.76 56.74,74.76 57.25,75.27 60.04,75.27
B+ on BOTTOM (solid shape): 135.8,27.32 135.8,24.91 136.56,24.15 137.45,24.15 137.64,23.96 137.64,23.39 137.58,23.32 132.94,23.32 132.69,23.07 132.69,21.86 132.94,21.61 133.7,21.61 133.77,21.55 133.77,20.78 133.64,20.66 131.73,20.66 130.97,21.42 130.97,27.01 130.27,27.7 129.57,27.7 129.45,27.83 129.45,28.53 129.51,28.59 134.53,28.59
B+ on BOTTOM (solid shape): 137.26,33.98 137.35,33.99 137.8,33.99 137.89,33.98 137.98,33.99 138.44,33.99 138.53,33.98 138.62,33.99 139.06,33.99 139.32,33.74 139.32,30.94 139.06,30.69 137.03,30.69 136.95,30.77 136.95,33.91 137.03,33.99 137.17,33.99
B+ on BOTTOM (solid shape): 6.83,10.52 9.59,9.37 12.05,11.09 14.01,11.09 14.08,11.03 14.08,9.43 13.46,8.81 13.46,8.72 13.1,8.36 7.68,8.36 6.57,9.47 5.12,9.47 5.01,9.58 5.01,11.21 5.13,11.33 6.03,11.33
B+ on BOTTOM (solid shape): 137.07,11.96 141.89,11.96 142.08,11.77 142.08,9.86 141.83,9.61 141.83,8.46 142.02,8.27 144.88,8.27 145.83,7.32 146.14,7.32 146.59,6.87 147.61,6.87 147.72,6.76 147.72,5.93 147.6,5.81 146.54,5.81 145.82,6.53 145.54,6.53 144.43,7.64 141.58,7.64 141.32,7.38 140.5,7.38 140.31,7.19 140.31,6.43 140.18,6.31 138.91,6.31 138.72,6.11 138.72,5.73 138.91,5.54 139.67,5.54 139.67,5.04 138.15,5.04 138.15,6.43 137.89,6.69 137.89,6.94 137.77,7.07 136.94,7.07 135.91,8.09 135.91,9.81 135.73,9.99 135.23,9.99 135.1,10.12 135.1,11.77 134.78,12.08 134.59,12.08 134.53,12.15 134.53,12.72 134.59,12.78 136.24,12.78
B+ on GND2 (solid shape): 141.86,83.46 141.86,82.71 141.79,82.65 140.9,82.65 140.77,82.78 140.77,83.28 141.09,83.59 141.73,83.59
B+ on IN2 (solid shape): 99.54,29.55 99.54,28.72 99.48,28.66 97.89,28.66 97.63,28.91 97.63,29.42 97.89,29.67 99.41,29.67
B+ on IN2 (solid shape): 106.99,29.21 106.99,29.09 107.03,29.04 107.03,28.85 106.84,28.66 105.13,28.66 104.94,28.85 104.94,29.42 105.19,29.67 106.52,29.67
B+ on IN2 (solid shape): outline of 3263 points within 81.82,21.04 152.02,94.69
B+ on IN2 (solid shape): outline of 4753 points within 8.86,7.32 138.27,21.04
B+ on GND3 (solid shape): 146.44,94.36 146.44,94.02 146.23,93.82 146.03,93.82 146.03,93.81 145.11,93.81 145.03,93.89 145.03,94.38 145.28,94.63 146.16,94.63
B+ on GND3 (solid shape): 60.42,74.63 60.42,73.87 60.17,73.62 57.62,73.62 57.33,73.91 57.33,74.85 57.74,75.27 59.79,75.27
B+ on GND3 (solid shape): 83.16,91.78 83.54,91.78 84.05,91.27 84.05,90.63 83.28,89.87 82.65,89.87 82.01,90.51 82.01,90.89 81.89,91.01 81.89,91.4 82.01,91.52 82.01,91.65 82.27,91.9 83.03,91.9
B+ on IN3 (solid shape): 106.52,33.86 106.97,33.86 107.44,33.39 111.25,33.39 111.46,33.18 111.46,30.75 111.34,30.63 104.72,30.63 104.53,30.81 104.53,34.25 104.65,34.37 106.02,34.37
B+ on IN3 (solid shape): 13.97,10.97 13.97,9.78 13.81,9.62 13.16,9.62 13.15,9.61 11.64,8.1 7.85,8.1 7.78,8.11 7.71,8.1 6.98,8.1 5.24,9.85 5.24,10.55 5.52,10.83 6.54,10.83 6.78,10.59 6.78,10.59 9.58,9.37 12.06,11.13 13.81,11.13
B+ on IN3 (solid shape): outline of 126 points within 130.59,22.05 140.56,33.74
B+ on GND2: 119.2,19.13 118.04,19.13 117.88,18.97 117.88,18.35 118.07,18.16 119.18,18.16 119.29,18.26 119.29,19.04
B+ on VCC: outline of 90 points within 8.35,7.32 155.06,107.58
B+_+0.95VSP on TOP (solid shape): 97.15,28.25 97.16,28.23 98.29,28.23 98.34,28.27 99.39,28.27 99.64,28.02 102.31,28.02 102.36,27.97 102.36,26.46 102.3,26.4 101.4,26.4 101.35,26.35 101.16,26.35 101.09,26.27 101.09,25.91 100.99,25.81 94.7,25.81 94.33,26.18 94.33,27.96 94.57,28.2 96.92,28.2 96.97,28.25 96.97,28.76 97.15,28.76
B+_+1VALWP on BOTTOM (solid shape): 8.86,55.25 8.86,53.39 8.53,53.06 8.53,52.31 8.53,52.3 8.53,51.79 9.09,51.24 9.09,49.79 9.01,49.71 6.31,49.71 6.16,49.87 6.16,54.24 6.46,54.54 7.48,54.54 7.73,54.79 7.73,55.25 7.83,55.35 8.76,55.35
B+_AMP on TOP (solid shape): 116.3,19.59 116.3,14.23 116.91,13.62 117.47,13.62 117.55,13.54 117.55,12.38 117.48,12.31 115.86,12.31 114.63,13.54 114.63,17.35 114.45,17.53 113.79,17.53 113.74,17.58 113.74,19.97 113.84,20.07 115.82,20.07
B+_AMP on BOTTOM (solid shape): 117.62,13.32 117.62,12.68 117.66,12.64 117.66,12.45 117.85,12 118.31,11.83 118.31,7.92 116.9,6.51 112.98,6.51 112.72,6.77 112.72,7.08 112.91,7.27 113.42,7.27 113.68,7.53 113.68,8.04 113.89,8.25 115.83,8.25 115.85,8.26 116.43,8.84 116.43,8.85 116.47,8.89 116.47,10.52 116.28,10.71 116.28,13.19 116.52,13.43 117.51,13.43
B+_CAM on TOP (solid shape): 148.12,110 148.12,107.08 147.93,106.89 146.02,106.89 145.83,107.08 145.83,109.94 145.96,110.06 148.05,110.06
B+_CAM on TOP (solid shape): 143.11,88.71 143.11,86.01 142.92,85.83 139.93,85.83 139.2,86.55 137.82,86.55 137.49,86.89 137.49,88.1 137.7,88.31 138.05,88.31 138.05,88.31 138.59,88.31 138.71,88.43 138.71,88.99 139.06,89.33 142.48,89.33
B+_CAM on BOTTOM (solid shape): 147.61,108.03 147.61,106.32 147.5,106.2 147.46,106.23 147.18,106.28 146.97,106.11 146.89,106.05 146.81,106.08 146.49,106.15 146.26,105.91 146.25,105.87 143.8,105.87 143.72,105.95 143.72,106.05 143.75,106.08 143.75,107.14 143.88,107.27 145.01,107.27 146.02,108.29 147.35,108.29
B+_CAM on IN1 (solid shape): 145.95,98.87 145.95,97.86 145.83,97.73 145.02,97.73 144.92,97.83 144.92,98.95 145.01,99.03 145.79,99.03
B+_CAM on IN1 (solid shape): 143.24,89.48 143.24,88.44 143.2,88.41 142.4,88.41 142.2,88.62 142.2,89.43 142.31,89.54 143.18,89.54
B+_CAM on GND2 (solid shape): 146.23,98.86 146.23,98.32 146.12,98.21 145.36,98.21 145.03,98.53 145.03,98.94 145.15,99.06 146.04,99.06
B+_CAM on IN2 (solid shape): 148.22,107.71 148.22,107.03 147.88,106.69 146.28,106.69 145.9,107.07 145.9,108.11 146.04,108.24 147.69,108.24
B+_CAM on IN2 (solid shape): 147.8,100.86 147.8,100.53 146.84,99.57 146.84,98.33 146.71,98.21 145.78,98.21 145.63,98.36 145.63,98.37 145.59,98.41 145.59,100.42 145.92,100.75 146.31,100.71 146.47,101.05 146.5,101.14 146.57,101.17 147.49,101.17
B+_VDD08 on BOTTOM (solid shape): 147.45,94.58 147.55,94.48 147.55,92.81 147.15,92.41 147.15,91.29 147.2,91.23 147.64,91.23 147.7,91.17 147.7,89.68 147.66,89.64 146.52,89.64 146.46,89.71 146.46,90.13 145.94,90.66 145.24,90.66 144.61,91.29 144.61,92.93 144.77,93.09 146.23,93.09 146.71,93.57 146.71,94.54 146.76,94.59 147.45,94.59
B+_VDD12 on TOP (solid shape): 57.51,63.34 61.43,63.34 61.57,63.2 61.57,62.19 61.76,61.99 62.2,61.99 62.26,61.93 62.26,61.3 62.2,61.23 57.82,61.23 57.5,60.92 57.5,60.53 57.25,60.28 54.46,60.28 54.3,60.44 54.3,61.76 54.48,61.94 55.42,61.94 55.98,62.49 55.98,63.78 56.12,63.92 56.93,63.92
B+_VDD12 on BOTTOM (solid shape): 57.76,62.44 58.52,62.44 58.77,62.19 58.77,60.92 58.65,60.79 57.63,60.79 57.38,60.53 56.36,60.53 56.23,60.66 56.23,62.95 56.49,63.2 56.99,63.2
BATT++ on BOTTOM (solid shape): 129.77,20.33 131.82,20.33 132.08,20.07 132.08,12.77 132.88,11.97 133.84,11.97 134.22,11.59 134.22,7.07 135.25,7.07 135.28,7.09 135.77,7.09 135.92,6.94 135.92,6.41 136.46,6.41 136.5,6.36 136.5,5.01 136.82,4.69 136.82,1.19 136.77,1.13 135.46,1.13 135.35,1.24 135.35,2.22 134.34,3.23 126.84,3.23 125.19,4.88 125.19,8.42 128.29,8.42 128.29,8.37 128.29,8.32 128.31,8.27 128.33,8.23 128.36,8.18 128.4,8.15 128.44,8.12 128.49,8.09 128.54,8.08 128.59,8.07 128.64,8.07 128.69,8.08 128.74,8.09 128.79,8.12 128.83,8.15 128.87,8.18 128.9,8.23 128.92,8.27 128.94,8.32 128.95,8.37 128.95,8.42 128.94,8.48 128.92,8.53 128.9,8.57 128.87,8.61 128.83,8.65 128.79,8.68 128.74,8.7 128.69,8.72 128.64,8.73 128.59,8.73 128.54,8.72 128.49,8.7 128.44,8.68 128.4,8.65 128.36,8.61 128.33,8.57 128.31,8.53 128.29,8.48 128.29,8.42 125.19,8.42 125.19,13.37 125.23,13.41 125.23,15.17 128.38,18.32 128.38,20.15 128.39,20.15 128.39,20.95 128.47,21.04 129.05,21.04
BATT++ on IN3 (solid shape): outline of 102 points within 126.72,5.04 135.92,19.7
BST_1VALWP on BOTTOM (solid shape): 9.13,49.49 9.13,49.28 8.59,48.75 6.88,48.75 6.79,48.84 6.79,49.45 6.88,49.54 9.08,49.54
BST_1VALWP_R on BOTTOM (solid shape): 6.68,49.38 6.68,48.54 6.49,48.35 6.49,47.88 6.42,47.82 5.04,47.82 4.95,47.91 4.95,49.21 5.13,49.38 6.67,49.38
BST_+0.95VSP on TOP (solid shape): 101.95,28.4 102,28.4 102.05,28.35 102.05,28.2 102,28.15 99.89,28.15 99.77,28.28 99.77,28.83 99.95,29.01 101.34,29.01
BST_VDD08 on BOTTOM (solid shape): 147.7,89.4 147.7,89.24 147.61,89.14 146.74,89.14 146.14,88.55 145.45,88.55 145.39,88.61 145.39,89.26 145.44,89.32 146.08,89.32 146.23,89.47 147.63,89.47
BST_VDD08_A on BOTTOM (solid shape): 146.13,88.3 146.13,87.78 145.91,87.56 145.91,87.1 145.82,87.01 145.31,87.01 145.25,87.07 145.25,88.29 145.32,88.35 146.07,88.35
BST_VGT1 on TOP (solid shape): 56.42,53.42 56.42,52.98 56.8,52.6 57.06,52.6 57.18,52.47 57.18,51.83 57.12,51.77 55.91,51.77 55.34,52.34 55.34,53.49 55.41,53.55 56.3,53.55
CCG5_VBUS1_CSN_P1 on BOTTOM (solid shape): 25.14,75.51 25.14,72.49 25.04,72.39 24.27,72.39 24.11,72.56 24.11,75.42 24.3,75.62 25.04,75.62
CCG5_VBUS2_CSN_P2 on TOP (solid shape): 29.08,99.68 29.08,98.35 29.05,98.32 27,98.32 26.75,98.56 26.75,99.65 26.88,99.78 28.98,99.78
CHG_BST1 on TOP (solid shape): 160.14,7.19 160.63,7.19 160.75,7.32 161.64,7.32 161.71,7.26 161.71,7.13 161.64,7.07 160.82,7.07 160.44,6.69 159.93,6.69 159.55,7.07 159.55,7.32 159.67,7.45 159.88,7.45
CHG_BST1 on BOTTOM (solid shape): 159.49,8.54 159.49,7.63 159.67,7.45 159.93,7.45 160.18,7.19 160.44,7.19 160.63,7 160.63,6.47 160.41,6.26 160.09,6.26 159.97,6.37 159.97,6.52 159.48,7 159.27,7 158.78,7.49 158.78,8.4 158.79,8.4 158.79,8.52 158.83,8.57 159.47,8.57
CHG_BST2 on BOTTOM (solid shape): 164.04,11.77 164.04,10.88 163.66,10.5 163.28,10.5 163.16,10.62 163.15,10.64 163.15,10.97 162.94,11.18 162.94,11.8 163.03,11.89 163.92,11.89
CHG_DCIN on BOTTOM (solid shape): 162.26,5.38 162.26,4.74 162.14,4.62 160.87,4.62 160.49,5 160.49,5.25 160.74,5.5 162.14,5.5
CHG_LG1 on TOP (solid shape): 161.39,8.97 161.39,8.78 161.7,8.47 161.7,8.37 161.62,8.29 160.86,8.29 160.75,8.4 160.75,8.71 160.19,9.28 159.48,9.28 159.42,9.33 159.42,9.66 159.47,9.71 160.65,9.71
CHG_LG1 on BOTTOM (solid shape): 143.29,12.15 143.29,9.92 143.23,9.86 142.72,9.86 142.59,9.99 142.59,12.15 142.78,12.34 143.1,12.34
CHG_LG1 on IN2 (solid shape): 143.48,11.77 143.48,11 143.35,10.88 143.35,9.99 143.1,9.73 142.47,9.73 142.21,9.99 142.21,11.77 142.47,12.02 143.23,12.02
CHG_LG1 on IN2 (solid shape): 160.75,10.37 160.75,10.12 161.52,9.35 161.52,8.91 161.2,8.59 161.01,8.59 159.74,9.86 159.74,10.37 159.99,10.62 160.5,10.62
CHG_LG2 on TOP (solid shape): 162.4,9.67 162.4,8.65 162.34,8.59 162.21,8.59 162.15,8.65 162.15,9.48 161.64,9.99 161.32,9.99 160.68,10.63 160.68,10.96 160.8,11.08 160.99,11.08
CHG_LG2 on BOTTOM (solid shape): 135.86,20.21 135.86,19.32 135.67,19.13 134.65,19.13 134.46,19.32 134.46,20.21 134.65,20.4 135.67,20.4
CHG_LG2 on IN3 (solid shape): 136.37,19.83 136.37,19.58 136.05,19.26 135.8,19.26 135.35,19.7 134.72,19.7 134.59,19.83 134.59,20.21 134.72,20.34 135.86,20.34
CHG_LG2 on IN3 (solid shape): 161.39,10.75 161.39,10.62 161.64,10.37 161.64,10.12 161.52,9.99 161.26,9.99 160.88,10.37 160.12,10.37 159.99,10.5 159.99,11 160.12,11.13 161.01,11.13
CHG_LX1 on TOP (solid shape): 154.49,19.13 155.38,19.13 155.42,19.09 155.42,17.32 155.32,17.22 155.23,17.22 155.22,17.21 153.77,17.21 153.77,17.23 153.58,17.42 153.58,19.07 153.68,19.18 154.44,19.18
CHG_LX1 on TOP (solid shape): 160.63,8.59 160.63,8.34 160.82,8.15 161.63,8.15 161.7,8.08 161.7,7.95 161.64,7.89 160.56,7.89 160.09,8.36 159.86,8.36 159.59,8.64 159.59,8.95 159.8,9.16 160.05,9.16
CHG_LX1 on BOTTOM (solid shape): 160.06,9.22 160.23,9.22 160.63,8.83 160.63,8.34 160.5,8.21 160.05,8.21 159.54,8.72 158.85,8.72 158.78,8.78 158.78,9.71 158.85,9.77 159.51,9.77
CHG_LX1 on BOTTOM (solid shape): 158.09,22.45 158.09,17.96 157.93,17.81 154.56,17.81 154.06,17.31 153.75,17.31 153.6,17.45 153.6,18.79 153.32,19.07 152.37,19.07 152.05,18.74 152.05,17.74 152.04,17.74 152.04,16.44 151.77,16.17 148.32,16.17 147.95,15.8 147.95,13.15 147.61,12.81 142.49,12.81 142.29,13.01 142.29,17.85 142.93,18.5 144.7,18.5 147.93,21.72 147.93,22.14 155.79,22.14 155.79,22.09 155.8,22.04 155.81,21.99 155.83,21.94 155.87,21.9 155.9,21.86 155.94,21.83 155.99,21.81 156.04,21.79 156.09,21.79 156.14,21.79 156.19,21.79 156.24,21.81 156.29,21.83 156.33,21.86 156.37,21.9 156.4,21.94 156.42,21.99 156.44,22.04 156.45,22.09 156.45,22.14 156.44,22.19 156.42,22.24 156.4,22.29 156.37,22.33 156.33,22.37 156.29,22.4 156.24,22.42 156.19,22.44 156.14,22.45 156.09,22.45 156.04,22.44 155.99,22.42 155.94,22.4 155.9,22.37 155.87,22.33 155.83,22.29 155.81,22.24 155.8,22.19 155.79,22.14 147.93,22.14 147.93,24.72 148.64,25.43 155.11,25.43
CHG_LX1 on IN2 (solid shape): 154.82,18.41 154.82,16.6 154.96,16.45 154.96,16.31 154.43,15.77 154.18,15.77 153.61,16.34 153.61,18.47 153.66,18.52 154.71,18.52
CHG_LX1 on IN2 (solid shape): 160.63,8.59 160.63,8.4 160.5,8.27 160.05,8.27 159.67,8.65 159.1,8.65 159.07,8.69 158.75,8.69 158.34,9.1 158.34,9.48 158.59,9.73 159.48,9.73
CHG_LX2 on TOP (solid shape): 139.54,15.89 139.54,14.37 139.42,14.24 137.77,14.24 137.58,14.43 137.58,15.89 137.77,16.08 139.35,16.08
CHG_LX2 on TOP (solid shape): 162.47,10.69 162.47,10.24 162.79,9.92 162.79,8.65 162.72,8.59 162.66,8.59 162.59,8.65 162.59,9.67 161.16,11.11 161.16,11.49 161.28,11.61 161.54,11.61
CHG_LX2 on BOTTOM (solid shape): 147.67,24.95 147.67,21.89 144.51,18.73 142.93,18.73 142.88,18.78 141.8,17.7 141.8,15.32 141.68,15.2 140.75,15.2 140.23,14.67 140.23,12.79 139.84,12.4 137.04,12.4 136.42,13.02 136.42,20.83 136.9,21.32 138.11,21.32 138.39,21.6 138.39,23.01 140.69,25.3 147.32,25.3
CHG_LX2 on BOTTOM (solid shape): 161.39,12.27 161.39,11.77 162.4,10.75 162.4,10.47 162.28,10.34 161.92,10.34 161.13,11.13 161.07,11.13 160.92,11.17 160.76,11.13 160.75,11.13 160.5,11.39 160.5,12.27 160.68,12.45 161.06,12.45 161.07,12.46 161.2,12.46
CHG_LX2 on IN3 (solid shape): 139.73,14.18 139.73,13.93 139.35,13.54 139.23,13.54 138.59,14.18 138.15,14.18 138.02,14.31 138.02,14.69 138.08,14.75 139.16,14.75
CHG_LX2 on IN3 (solid shape): 162.28,11.13 162.28,10.81 162.47,10.62 162.47,10.31 162.28,10.12 162.02,10.12 161.9,10.24 161.9,10.43 160.82,11.51 160.82,11.77 161.07,12.02 161.39,12.02
CHG_UG1 on TOP (solid shape): 159.9,8.15 160.12,8.15 160.56,7.7 161.64,7.7 161.71,7.64 161.71,7.51 161.64,7.45 160.69,7.45 160.56,7.32 160.26,7.32 159.94,7.64 159.77,7.64 159.61,7.8 159.28,7.8 159.12,7.96 159.12,8.25 159.24,8.38 159.68,8.38
CHG_UG1 on BOTTOM (solid shape): 153.21,18.71 153.21,16.53 153.02,16.34 152.5,16.34 152.37,16.47 152.37,18.62 152.56,18.81 153.11,18.81
CHG_UG1 on IN2 (solid shape): 153.26,18.71 153.26,17.1 153.01,16.85 152.12,16.85 151.86,17.1 151.86,18.62 152.12,18.88 153.09,18.88
CHG_UG1 on IN2 (solid shape): 159.48,8.21 159.86,8.21 160.12,7.96 160.37,7.96 160.63,7.7 160.63,7.45 160.5,7.32 160.25,7.32 159.99,7.58 159.61,7.58 159.23,7.19 158.34,7.19 158.09,7.45 158.09,8.08 158.34,8.34 159.36,8.34
CHG_UG1 on IN3 (solid shape): 159.1,19.26 159.1,18.24 158.85,17.99 157.32,17.99 157.07,18.24 157.07,19.26 157.32,19.51 158.85,19.51
CHG_UG1 on IN3 (solid shape): 154.43,19.56 154.43,18.55 154.34,18.46 153.88,18.46 153.87,18.45 153.66,18.35 153.57,18.14 153.12,17.7 152.32,17.7 152.14,17.87 152.14,18.85 153.01,19.72 154.28,19.72
CHG_UG2 on BOTTOM (solid shape): 141.7,14.75 141.7,14.24 141.26,13.8 141.26,12.85 141.07,12.66 140.62,12.66 140.5,12.78 140.5,13.81 140.43,13.87 140.43,14.66 140.65,14.88 141.58,14.88
CHG_UG2 on IN3 (solid shape): 142.66,15.2 142.66,14.75 142.47,14.56 141.89,14.56 141.6,14.27 140.43,14.27 140.36,14.34 140.36,14.84 140.84,15.32 142.53,15.32
CHG_UG2 on IN3 (solid shape): 163.23,11.45 163.23,10.94 163.04,10.75 163.04,10.24 162.98,10.18 162.72,10.18 162.59,10.31 162.59,10.75 162.47,10.88 162.47,11.45 162.59,11.58 163.1,11.58
GPU_B+ on TOP (solid shape): outline of 504 points within 64.98,29.42 95.79,36.06
GPU_B+ on BOTTOM (solid shape): 103.65,34.07 103.65,31.12 103.4,30.87 101.68,30.87 101.48,31.07 101.48,33.96 101.76,34.25 103.48,34.25
GPU_B+ on BOTTOM (solid shape): 75.91,35.69 79.35,35.69 79.35,34.55 79.34,34.55 78.13,34.55 77.84,34.25 77.84,33.57 77.72,33.45 75.25,33.45 74.32,34.38 74.32,35.7 75.9,35.7
GPU_B+ on BOTTOM (solid shape): 85.26,35.66 88.1,35.66 88.1,34.53 86.86,34.53 86.59,34.26 86.59,33.53 86.47,33.41 85.1,33.41 84.83,33.68 83.38,33.68 82.98,34.08 82.98,35.66 83.05,35.73 85.19,35.73
GPU_B+ on BOTTOM (solid shape): 93.81,35.67 96.95,35.67 96.95,34.54 95.74,34.54 95.43,34.22 95.43,33.55 95.3,33.43 93.48,33.43 93.34,33.57 92.32,33.57 91.82,34.06 91.82,35.67 91.89,35.74 93.75,35.74
GPU_B+ on BOTTOM (solid shape): 66.71,36.32 66.71,35.96 66.82,35.86 67.85,35.86 68.04,35.67 70.79,35.67 70.79,34.54 69.58,34.54 69.26,34.22 69.26,33.57 69,33.31 65.88,33.31 65.6,33.59 65.6,34.16 66.1,34.85 65.6,35.55 65.6,36.34 65.69,36.43 66.61,36.43
GPU_B+ on IN3 (solid shape): outline of 3715 points within 65.87,24.97 103.31,41.74
LDO_1VALWP on BOTTOM (solid shape): 11.27,49.08 12.39,49.08 12.72,48.75 13.37,48.75 13.39,48.72 13.39,48.09 13.34,48.04 10.8,48.04 10.47,48.37 10.47,49.15 10.55,49.23 11.12,49.23
LDO_+0.95VSP on TOP (solid shape): 104.82,31.22 104.82,29.17 104.14,28.48 103.55,28.48 103.48,28.56 103.48,29.32 103.53,29.37 103.55,29.37 104.01,29.83 104.01,31.32 104.13,31.44 104.6,31.44
LDO_IN on BOTTOM (solid shape): 48.74,68.15 48.74,62.95 48.42,62.63 47.32,62.63 47.19,62.77 47.19,63.19 46.33,64.05 46.33,65.87 47.85,67.39 47.85,68.15 47.98,68.28 48.61,68.28
LDO_VDD08 on BOTTOM (solid shape): 149.88,89.06 149.88,88.77 150.34,88.31 152.02,88.31 152.18,88.15 152.18,87.7 152.07,87.59 149.43,87.59 149.12,87.9 149.12,89.07 149.18,89.14 149.8,89.14
LX_1VALWP on BOTTOM (solid shape): 9.47,52.84 9.47,52.39 9.42,52.34 9.42,51.45 9.37,51.4 9.2,51.4 9.15,51.45 9.15,51.58 8.82,51.92 8.82,52.84 8.94,52.96 9.35,52.96
LX_1VALWP on BOTTOM (solid shape): 9.86,49.14 9.86,48.02 10.03,47.85 10.03,47.66 10.18,47.5 13.33,47.5 13.84,47 13.84,44.25 13.51,43.92 8.25,43.92 6.6,45.56 6.6,48.31 6.75,48.46 8.48,48.46 9.23,49.21 9.79,49.21
LX_1VALWP on IN3 (solid shape): 9.51,52.88 9.51,47.92 8.91,47.32 8.05,47.32 8.05,47.32 7.93,47.32 7.81,47.44 7.81,52.8 8.02,53.02 9.37,53.02
LX_+0.95VSP on TOP (solid shape): 103.91,36.91 103.91,30.77 102.92,29.77 102.92,29.7 102.92,28.45 102.89,28.43 102.13,28.43 100.76,29.8 100.76,33.89 101.7,34.83 101.7,37.01 101.83,37.14 103.68,37.14
LX_+0.95VSP on BOTTOM (solid shape): 104.77,39.45 104.77,34.98 104.59,34.8 102.17,34.8 101.93,35.04 101.93,36.91 101.37,37.47 101.37,39.91 101.5,40.04 104.19,40.04
LX_+0.95VSP on IN1 (solid shape): 103.85,36.97 103.85,30.71 102.92,29.77 102.92,28.53 102.82,28.43 102.1,28.43 102.1,26.26 102.1,25.84 101.99,25.72 101.09,25.72 100.76,26.05 100.76,32.74 101.01,32.99 101.01,33.38 101.83,34.19 101.83,36.92 102.04,37.14 103.68,37.14
LX_+0.95VSP on IN3 (solid shape): 103.64,38.48 103.64,35.05 103.53,34.94 102.01,34.94 101.78,35.17 101.78,38.41 102.02,38.65 103.47,38.65
LX_VDD08 on BOTTOM (solid shape): 148.52,89.01 148.52,87.66 148.81,87.36 150.24,87.36 150.68,86.92 150.68,84.59 150.54,84.45 150.54,84.44 150.39,84.29 146.44,84.29 146.04,84.7 146.04,87.53 146.65,88.14 146.65,88.85 146.79,88.99 147.64,88.99 147.77,89.12 148.41,89.12
LX_VDD08 on IN3 (solid shape): 148.19,91.94 148.19,87.77 148.01,87.59 146.72,87.59 146.69,87.62 146.45,87.62 146.28,87.79 146.28,91.73 146.4,91.73 146.4,91.68 146.41,91.63 146.42,91.58 146.45,91.53 146.48,91.49 146.51,91.46 146.56,91.42 146.6,91.4 146.65,91.39 146.7,91.38 146.76,91.38 146.81,91.39 146.86,91.4 146.9,91.42 146.94,91.46 146.98,91.49 147.01,91.53 147.04,91.58 147.05,91.63 147.06,91.68 147.06,91.73 147.05,91.78 147.04,91.83 147.01,91.88 146.98,91.92 146.94,91.96 146.9,91.99 146.86,92.01 146.81,92.03 146.76,92.04 146.7,92.04 146.65,92.03 146.6,92.01 146.56,91.99 146.51,91.96 146.48,91.92 146.45,91.88 146.42,91.83 146.41,91.78 146.4,91.73 146.28,91.73 146.28,91.84 146.56,92.12 148.01,92.12
Net_332 on TOP (solid shape): 15.11,38.56 7.11,38.56 7.11,46.56 15.11,46.56
Net_332 on TOP (solid shape): 123.19,21.29 115.19,21.29 115.19,29.29 123.19,29.29
Net_333 on TOP (solid shape): 152.14,13.22 142.14,13.22 142.14,28.22 152.14,28.22
SNUB_+0.95VSP on TOP (solid shape): 100.08,32.3 100.08,30.84 99.98,30.75 98.25,30.75 98.04,30.96 98.04,32.22 98.18,32.36 100.02,32.36
TBT_SVR_IND on BOTTOM (solid shape): 34.39,91.28 34.39,89.49 34.46,89.41 34.87,89.41 34.9,89.39 34.9,88.93 34.85,88.88 34.46,88.88 34.39,88.8 34.39,88.25 34.49,88.14 34.87,88.14 34.9,88.12 34.9,87.2 34.29,86.59 34.29,86.16 34.24,86.11 33.96,86.11 33.91,86.06 33.91,85.73 33.85,85.68 33.58,85.68 33.52,85.73 33.52,86.39 32.03,87.89 32.03,91.17 32.33,91.47 34.2,91.47
VCORE_B+ on TOP (solid shape): 129.96,39.45 129.96,34.03 130.25,33.74 133.4,33.74 133.46,33.67 133.53,33.51 133.7,33.43 134.08,33.05 134.9,33.05 134.95,33 134.95,31.43 131.8,28.28 125.62,28.28 123.8,30.1 114.66,30.1 114.17,30.6 114.17,38.64 114.3,38.77 114.93,38.77 115.06,38.64 115.06,34.58 115.31,34.32 115.49,34.32 115.62,34.19 115.62,32.95 115.8,32.77 120.88,32.77 121.79,33.69 121.79,38.06 121.92,38.18 122.59,38.18 122.75,38.02 122.75,32.64 123.12,32.28 126.65,32.28 127.94,33.56 127.94,34.13 128.88,35.07 128.88,39.48 128.98,39.58 129.83,39.58
VCORE_B+ on BOTTOM (solid shape): outline of 101 points within 111.86,30.69 139.1,39.55
VCORE_B+ on IN3 (solid shape): outline of 2558 points within 112.24,30.65 134.97,43.14
N12389 on TOP (solid shape): 130.19,44.61 130.19,41.33 129.99,41.13 127.57,41.13 127.35,41.34 127.35,44.43 127.7,44.78 130.03,44.78
N12389 on BOTTOM (solid shape): 133.91,43.63 133.91,41.72 131.49,39.3 131.49,37.22 131.42,37.14 129.69,37.14 129.59,37.24 129.59,39.55 128.93,40.21 127.57,40.21 127.33,40.45 127.33,43.73 127.49,43.89 133.65,43.89
N12635 on BOTTOM (solid shape): 128.9,39.86 128.9,39.58 128.77,39.45 128.77,38.06 127.99,38.06 127.99,39.12 127.82,39.29 127.55,39.29 127.48,39.35 127.48,39.92 127.57,40.01 128.75,40.01
