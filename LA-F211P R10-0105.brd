# Allegro board LA-F211P R10-0105.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
L2N7002WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L_7X7X3_M
  custom 0.591x0.591 smd: 1(0,0) 4(6.05,0)
  rect 0.762x0.508 smd: 2(0.8,0) 3(5.25,0)
L_7X7X4_M
  custom 0.591x0.591 smd: 1(0,0) 4(6.05,0)
  rect 0.762x0.508 smd: 2(0.8,0) 3(5.25,0)
LED_HT-F196BP5_2P
  rect 0.787x0.787 smd: 1(0,0) 2(1.5,0)
LED_LTW-270TLA_2P
  rect 0.889x0.889 smd: 1(0,0) 2(1.9,0)
LNG2DMTR_LGA12_2X2
  oval 0.406x0.305 smd: 1(0,0) 4(0,-1.5) 7(1.602,-1.5) 10(1.602,0)
  oval 0.508x0.305 smd: 2(0.051,-0.5) 3(0.051,-1) 8(1.551,-1) 9(1.551,-0.5)
  oval 0.305x0.508 smd: 5(0.551,-1.5) 6(1.051,-1.5) 11(1.051,0) 12(0.551,0)
LNTA7002NT1G_SC-89-3
  round 0.533 smd: 1(0,0) 2(-0.5,-1.1) 3(0.5,-1.1)
LP2301ALT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MAG_MLD-06CZH1R0M-N1L_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
MAG_MMD05CZR47M_4P
  custom 0.54x0.54 smd: 1(0,0) 4(4.35,0)
  rect 0.762x0.508 smd: 2(0.699,0) 3(3.652,0)
MAG_MMD-05AB-1R0M-V1L_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
MAG_MMD-05CZ-1R5M-X2L_2P
  rect 1.905x2.794 smd: 1(0,0) 2(4.1,0)
MAG_MMD-05CZ-R33M-V1L_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
MAG_MMD-10CZN1R0M-R1L_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
MAG_MND-04ABIR60M-XGL_2P
  rect 1.448x3.708 smd: 1(0,0) 2(2.845,0)
MAGLA_MMD-05CZ-1R0M-M7L_2P
  rect 1.905x2.794 smd: 1(0,0) 2(4.1,0)
MC74VHC1G08DFT2G_SC70-5
  oval 0.381x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MC74VHC1G09DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MEC5105_WFBGA_169P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A6(4,0) A7(4.801,0) A8(5.601,0) A9(6.401,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B6(4,-0.8) B7(4.801,-0.8) B8(5.601,-0.8) B9(6.401,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C6(4,-1.6) C7(4.801,-1.6) C8(5.601,-1.6) C9(6.401,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D6(4,-2.4) D7(4.801,-2.4) D8(5.601,-2.4) D9(6.401,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E6(4,-3.2) E7(4.801,-3.2) E8(5.601,-3.2) E9(6.401,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F6(4,-4) F7(4.801,-4) F8(5.601,-4) F9(6.401,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G6(4,-4.801) G7(4.801,-4.801) G8(5.601,-4.801) G9(6.401,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H6(4,-5.601) H7(4.801,-5.601) H8(5.601,-5.601) H9(6.401,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J6(4,-6.401) J7(4.801,-6.401) J8(5.601,-6.401) J9(6.401,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K6(4,-7.201) K7(4.801,-7.201) K8(5.601,-7.201) K9(6.401,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L6(4,-8.001) L7(4.801,-8.001) L8(5.601,-8.001) L9(6.401,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M6(4,-8.801) M7(4.801,-8.801) M8(5.601,-8.801) M9(6.401,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N6(4,-9.601) N7(4.801,-9.601) N8(5.601,-9.601) N9(6.401,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601)
MMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MP2949AGQKT-0022-Z_TQFN48_6X6-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.648x4.648 smd: 49(3.05,-2.2)
MP86901-BGLT-Z_TQFN21_3X4
  oval 1.6x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1.3) 4(0,-2.1) 6(2,-1.7) 7(2,-0.9) 8(2,0)
  custom 0.2x0.2 smd: 5(1,-2.65)
  custom 0.175x0.175 smd: 9(2.2,0.85) 15(-0.2,0.85)
  oval 0.203x0.787 smd: 10(1.8,0.85) 11(1.4,0.85) 12(1,0.85) 13(0.6,0.85) 14(0.2,0.85)
MP86901-CGLT-Z_TQFN21_3X4
  oval 1.6x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1.3) 4(0,-2.1) 6(2,-1.7) 7(2,-0.9) 8(2,0)
  custom 0.2x0.2 smd: 5(1,-2.65)
  custom 0.175x0.175 smd: 9(2.2,0.85) 15(-0.2,0.85)
  oval 0.203x0.787 smd: 10(1.8,0.85) 11(1.4,0.85) 12(1,0.85) 13(0.6,0.85) 14(0.2,0.85)
MURAT_BLM15GA750SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX121SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_DLM0NSN900HY2D_4P
  rect 0.305x0.305 smd: 1(0,0) 2(0.6,0) 3(0.6,-0.5) 4(0,-0.5)
NB679AGD-Z_QFN12_2X3
  oval 1.702x0.254 smd: 1(0,0) 2(0,-1) 7(1.3,-0.5)
  oval 0.254x0.889 smd: 3(-0.1,-2.05) 4(0.4,-2.05) 5(0.9,-2.05) 6(1.4,-2.05) 9(1.4,1.05) 10(0.9,1.05) 11(0.4,1.05) 12(-0.1,1.05)
  oval 0.889x0.254 smd: 8(1.706,0)
NB680GD-Z_QFN12_2X3
  oval 1.702x0.254 smd: 1(0,0) 2(0,-1) 7(1.3,-0.5)
  oval 0.254x0.889 smd: 3(-0.1,-2.05) 4(0.4,-2.05) 5(0.9,-2.05) 6(1.4,-2.05) 9(1.4,1.05) 10(0.9,1.05) 11(0.4,1.05) 12(-0.1,1.05)
  oval 0.889x0.254 smd: 8(1.706,0)
NB685GQ-Z_QFN16_3X3
  oval 2.311x0.254 smd: 1(0,0) 2(0,-1) 9(1.7,-0.5)
  oval 0.254x0.889 smd: 3(-0.4,-2.05) 4(0.1,-2.05) 5(0.6,-2.05) 6(1.1,-2.05) 7(1.6,-2.05) 8(2.1,-2.05) 11(2.1,1.05) 12(1.6,1.05) 13(1.1,1.05) 14(0.6,1.05) 15(0.1,1.05) 16(-0.4,1.05)
  oval 1.092x0.254 smd: 10(2.31,0)
NCP81022MNTXG_QFN52_6X6-S
  oval 0.838x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 27(6.15,-4.8) 28(6.15,-4.4) 29(6.15,-4) 30(6.15,-3.6) 31(6.15,-3.2) 32(6.15,-2.8) 33(6.15,-2.4) 34(6.15,-2) 35(6.15,-1.6) 36(6.15,-1.2) 37(6.15,-0.8) 38(6.15,-0.4) 39(6.15,0)
  oval 0.203x0.838 smd: 14(0.675,-5.475) 15(1.075,-5.475) 16(1.475,-5.475) 17(1.875,-5.475) 18(2.275,-5.475) 19(2.675,-5.475) 20(3.075,-5.475) 21(3.475,-5.475) 22(3.875,-5.475) 23(4.275,-5.475) 24(4.675,-5.475) 25(5.075,-5.475) 26(5.475,-5.475) 40(5.475,0.675) 41(5.075,0.675) 42(4.675,0.675) 43(4.275,0.675) 44(3.875,0.675) 45(3.475,0.675) 46(3.075,0.675) 47(2.675,0.675) 48(2.275,0.675) 49(1.875,0.675) 50(1.475,0.675) 51(1.075,0.675) 52(0.675,0.675)
  rect 4.699x4.699 smd: 53(3.075,-2.4)
NCP81151MNTBG_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.194x0.787 smd: 9(0.75,1.1)
NCP302045MNTXG_PQFN33_5X5
  oval 0.305x0.711 smd: 1(0,-0.051) 2(0.5,-0.051) 3(1,-0.051) 4(1.5,-0.051) 5(2,-0.051) 6(2.5,-0.051) 7(3,-0.051) 8(3.5,-0.051)
  custom 0.32x0.32 smd: 9(3.135,1.215)
  custom 0.543x0.543 smd: 10(2.225,3.215)
  rect 3.81x0.711 smd: 11(1.75,4.851)
  rect 0.711x1.295 smd: 12(-0.701,3.65)
  oval 0.711x0.305 smd: 13(-0.701,2.65) 14(-0.701,2.15) 15(-0.701,1.65) 16(-0.701,1.15) 17(-0.701,0.65)
  rect 1.422x1.118 smd: 18(0.7,1.215)
  rect 0.584x0.356 smd: 19(0.09,2.625)
NPCT650JAAYX_QFN32_5X5-S
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.505x3.505 smd: 33(2.55,-1.75)
R0201_0OHM
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
RB520SM-30T2R_EMD2-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RJU003N03_UMT3
  oval 0.787x0.889 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT9059GQW_WDFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.464x1.626 smd: 11(1,1.55)
RT9069-33GB_SOT23-5
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0,2.6)
RTS5242-GR_QFN32_4X4-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI1303DL-T1-E3_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
SI3457CDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SKY-S-PCH_BGA_837P-T
  round 0.305 smd: A2(-0.354,0) A3(-0.854,0) A4(-1.355,0) A42(-20.273,0) A43(-20.773,0) A44(-21.274,0) AA17(-7.715,10.039) AA18(-8.49,10.039) AA20(-9.264,10.039) AA21(-10.039,10.039) AA23(-10.814,10.039) AA25(-11.588,10.039) AA26(-12.363,10.039) AA28(-13.138,10.039) AA29(-13.913,10.039) AB7(-2.638,10.147) AB8(-3.4,10.147) AB10(-4.162,10.147) AB11(-4.924,10.147) AB13(-5.686,10.147) AB14(-6.448,10.147) AB15(-7.007,10.147) AB31(-14.62,10.147) AB32(-15.179,10.147) AB33(-15.941,10.147) AB35(-16.703,10.147) AB36(-17.465,10.147) AB38(-18.227,10.147) AB39(-18.989,10.147) AC17(-7.715,10.814) AC18(-8.49,10.814) AC20(-9.264,10.814) AC21(-10.039,10.814) AC23(-10.814,10.814) AC25(-11.588,10.814) AC26(-12.363,10.814) AC28(-13.138,10.814) AC29(-13.913,10.814) AD7(-2.638,11.481) AD8(-3.4,11.481) AD10(-4.162,11.481) AD11(-4.924,11.481) AD13(-5.686,11.481) AD14(-6.448,11.481) AD15(-7.007,11.481) AD31(-14.62,11.481) AD32(-15.179,11.481) AD33(-15.941,11.481) AD35(-16.703,11.481) AD36(-17.465,11.481) AD38(-18.227,11.481) AD39(-18.989,11.481) AE17(-7.715,11.588) AE18(-8.49,11.588) AE20(-9.264,11.588) AE21(-10.039,11.588) AE23(-10.814,11.588) AE25(-11.588,11.588) AE26(-12.363,11.588) AE28(-13.138,11.588) AE29(-13.913,11.588) AF17(-7.715,12.363) AF18(-8.49,12.363) AF20(-9.264,12.363) AF21(-10.039,12.363) AF23(-10.814,12.363) AF25(-11.588,12.363) AF26(-12.363,12.363) AF28(-13.138,12.363) AF29(-13.913,12.363) AG7(-2.638,12.586) AG8(-3.4,12.586) AG10(-4.162,12.586) AG11(-4.924,12.586) AG13(-5.686,12.586) AG14(-6.448,12.586) AG15(-7.007,12.586) AG31(-14.62,12.586) AG32(-15.179,12.586) AG33(-15.941,12.586) AG35(-16.703,12.586) AG36(-17.465,12.586) AG38(-18.227,12.586) AG39(-18.989,12.586) AH17(-7.715,13.138) AH18(-8.49,13.138) AH20(-9.264,13.138) AH21(-10.039,13.138) AH23(-10.814,13.138) AH25(-11.588,13.138) AH26(-12.363,13.138) AH28(-13.138,13.138) AH29(-13.913,13.138) AJ7(-2.74,13.767) AJ8(-3.502,13.767) AJ10(-4.264,13.767) AJ11(-5.026,13.767) AJ13(-5.788,13.767) AJ14(-6.499,13.767) AJ15(-7.007,13.767) AJ17(-7.715,13.913) AJ18(-8.49,13.913) AJ20(-9.264,13.913) AJ21(-10.039,13.913) AJ23(-10.814,13.913) AJ25(-11.588,13.913) AJ26(-12.363,13.913) AJ28(-13.138,13.913) AJ29(-13.913,13.913) AJ31(-14.62,13.767) AJ32(-15.179,13.767) AJ33(-15.941,13.767) AJ35(-16.703,13.767) AJ36(-17.465,13.767) AJ38(-18.227,13.767) AJ39(-18.989,13.767) AL7(-2.74,14.885) AL8(-3.502,14.885) AL10(-4.264,14.885) AL11(-5.026,14.885) AL13(-5.788,14.885) AL17(-7.861,14.62) AL19(-9.042,14.62) AL22(-10.147,14.62) AL24(-11.481,14.62) AL27(-12.586,14.62) AL29(-13.767,14.62) AL32(-15.154,14.91) AL33(-15.916,14.91) AL35(-16.678,14.91) AL36(-17.44,14.91) AL38(-18.202,14.91) AL39(-18.964,14.91) AM15(-6.718,15.154) AM17(-7.861,15.179) AM19(-9.042,15.179) AM22(-10.147,15.179) AM24(-11.481,15.179) AM27(-12.586,15.179) AM29(-13.767,15.128) AN7(-2.791,15.85) AN8(-3.553,15.799) AN10(-4.315,15.799) AN11(-5.061,15.84) AN15(-6.718,15.916) AN17(-7.861,15.941) AN19(-9.042,15.941) AN22(-10.147,15.941) AN24(-11.481,15.941) AN27(-12.586,15.941) AN29(-13.767,15.84) AN31(-14.885,15.84) AN36(-17.284,15.901) AN38(-18.046,15.901) AN39(-18.808,15.901) AP11(-4.774,16.365) AR7(-2.815,16.851) AR9(-3.73,16.891) AR15(-6.718,16.678) AR17(-7.861,16.703) AR19(-9.042,16.703) AR22(-10.147,16.703) AR24(-11.481,16.703) AR27(-12.586,16.703) AR29(-13.767,16.602) AR31(-14.885,16.602) AR33(-15.84,16.566) AR34(-16.365,16.854) AR38(-18.21,16.882) AR39(-18.972,16.882) AT9(-3.876,17.527) AT10(-4.503,17.477) AT13(-5.727,17.284) AT15(-6.718,17.44) AT17(-7.861,17.465) AT19(-9.042,17.465) AT22(-10.147,17.465) AT24(-11.481,17.465) AT27(-12.586,17.465) AT29(-13.767,17.364) AT31(-14.885,17.364) AT33(-15.799,17.313) AT36(-17.477,17.125) AU7(-2.878,17.808) AU35(-16.891,17.897) AU36(-17.527,17.751) AU39(-18.804,17.955) AV6(-2.577,18.459) AV11(-4.745,18.21) AV13(-5.727,18.046) AV15(-6.718,18.202) AV17(-7.861,18.227) AV19(-9.042,18.227) AV22(-10.147,18.227) AV24(-11.481,18.227) AV27(-12.586,18.227) AV29(-13.767,18.126) AV31(-14.885,18.126) AV33(-15.799,18.075) AW9(-3.673,18.804) AW11(-4.745,18.972) AW13(-5.727,18.808) AW15(-6.718,18.964) AW17(-7.861,18.989) AW19(-9.042,18.989) AW22(-10.147,18.989) AW24(-11.481,18.989) AW27(-12.586,18.989) AW29(-13.767,18.888) AW31(-14.885,18.888) AW33(-15.85,18.837) AW35(-16.851,18.813) AW37(-17.808,18.75) AY5(-2.05,19.399) AY38(-18.459,19.051) B1(0,0.354) B2(-0.484,0.484) B3(-0.99,0.488) B43(-20.614,0.51) B44(-21.144,0.484) B45(-21.628,0.354) BA40(-19.399,19.577) BB1(0,20.273) BB45(-21.628,20.273) BC1(0,20.773) BC2(-0.488,20.637) BC44(-21.118,20.614) BC45(-21.628,20.773) BD1(0,21.274) BD2(-0.484,21.144) BD3(-1.013,21.118) BD43(-20.637,21.139) BD44(-21.144,21.144) BD45(-21.628,21.274) BE2(-0.354,21.628) BE3(-0.854,21.628) BE4(-1.355,21.628) BE42(-20.273,21.628) BE43(-20.773,21.628) BE44(-21.274,21.628) C1(0,0.854) C2(-0.51,1.013) C42(-20.102,0.954) C44(-21.139,0.99) C45(-21.628,0.854) D1(0,1.355) D45(-21.628,1.355) F8(-3.169,2.577) G9(-3.819,2.878) G11(-4.777,2.815) G13(-5.778,2.791) G15(-6.743,2.74) G17(-7.861,2.74) G19(-9.042,2.638) G22(-10.147,2.638) G24(-11.481,2.638) G27(-12.586,2.638) G29(-13.767,2.638) G31(-14.91,2.664) G33(-15.901,2.82) G35(-16.882,2.656) G37(-17.955,2.823) H13(-5.829,3.553) H15(-6.743,3.502) H17(-7.861,3.502) H19(-9.042,3.4) H22(-10.147,3.4) H24(-11.481,3.4) H27(-12.586,3.4) H29(-13.767,3.4) H31(-14.91,3.426) H33(-15.901,3.582) H35(-16.882,3.418) J7(-2.823,3.673) J10(-4.101,3.876) J11(-4.737,3.73) J39(-18.75,3.819) K10(-4.151,4.503) K13(-5.829,4.315) K15(-6.743,4.264) K17(-7.861,4.264) K19(-9.042,4.162) K22(-10.147,4.162) K24(-11.481,4.162) K27(-12.586,4.162) K29(-13.767,4.162) K31(-14.91,4.188) K33(-15.901,4.344) K36(-17.125,4.151) K37(-17.751,4.101) L7(-2.656,4.745) L8(-3.418,4.745) L12(-5.263,4.774) L13(-5.788,5.061) L15(-6.743,5.026) L17(-7.861,5.026) L19(-9.042,4.924) L22(-10.147,4.924) L24(-11.481,4.924) L27(-12.586,4.924) L29(-13.767,4.924) L31(-14.91,4.95) L37(-17.897,4.737) L39(-18.813,4.777) M35(-16.854,5.263) N7(-2.82,5.727) N8(-3.582,5.727) N10(-4.344,5.727) N15(-6.743,5.788) N17(-7.861,5.788) N19(-9.042,5.686) N22(-10.147,5.686) N24(-11.481,5.686) N27(-12.586,5.686) N29(-13.767,5.686) N31(-14.91,5.712) N35(-16.566,5.788) N36(-17.313,5.829) N38(-18.075,5.829) N39(-18.837,5.778) P17(-7.861,6.499) P19(-9.042,6.448) P22(-10.147,6.448) P24(-11.481,6.448) P27(-12.586,6.448) P29(-13.767,6.448) P31(-14.91,6.474) R7(-2.664,6.718) R8(-3.426,6.718) R10(-4.188,6.718) R11(-4.95,6.718) R13(-5.712,6.718) R14(-6.474,6.718) R17(-7.861,7.007) R19(-9.042,7.007) R22(-10.147,7.007) R24(-11.481,7.007) R27(-12.586,7.007) R29(-13.767,7.007) R33(-15.84,6.743) R35(-16.602,6.743) R36(-17.364,6.743) R38(-18.126,6.743) R39(-18.888,6.743) U7(-2.638,7.861) U8(-3.4,7.861) U10(-4.162,7.861) U11(-4.924,7.861) U13(-5.686,7.861) U14(-6.448,7.861) U15(-7.007,7.861) U17(-7.715,7.715) U18(-8.49,7.715) U20(-9.264,7.715) U21(-10.039,7.715) U23(-10.814,7.715) U25(-11.588,7.715) U26(-12.363,7.715) U28(-13.138,7.715) U29(-13.913,7.715) U31(-14.62,7.861) U32(-15.128,7.861) U33(-15.84,7.861) U35(-16.602,7.861) U36(-17.364,7.861) U38(-18.126,7.861) U39(-18.888,7.861) V17(-7.715,8.49) V18(-8.49,8.49) V20(-9.264,8.49) V21(-10.039,8.49) V23(-10.814,8.49) V25(-11.588,8.49) V26(-12.363,8.49) V28(-13.138,8.49) V29(-13.913,8.49) W7(-2.638,9.042) W8(-3.4,9.042) W10(-4.162,9.042) W11(-4.924,9.042) W13(-5.686,9.042) W14(-6.448,9.042) W15(-7.007,9.042) W31(-14.62,9.042) W32(-15.179,9.042) W33(-15.941,9.042) W35(-16.703,9.042) W36(-17.465,9.042) W38(-18.227,9.042) W39(-18.989,9.042) Y17(-7.715,9.264) Y18(-8.49,9.264) Y20(-9.264,9.264) Y21(-10.039,9.264) Y23(-10.814,9.264) Y25(-11.588,9.264) Y26(-12.363,9.264) Y28(-13.138,9.264) Y29(-13.913,9.264)
  round 0.279 smd: A5(-1.855,0) A41(-19.772,0) BA1(0,19.772) BA45(-21.628,19.772) BE5(-1.855,21.628) BE41(-19.772,21.628) E1(0,1.855) E45(-21.628,1.855)
  round 0.254 smd: A6(-2.356,0) A40(-19.272,0) AB4(-1.411,10.331) AB5(-1.876,10.147) AB41(-19.751,10.147) AD4(-1.393,11.323) AD5(-1.876,11.481) AD41(-19.751,11.481) AF5(-1.929,12.535) AF41(-19.7,12.535) AG4(-1.411,12.605) AJ5(-1.978,13.767) AJ41(-19.751,13.767) AL4(-1.411,14.878) AL5(-1.978,14.885) AL41(-19.7,14.91) AN4(-1.393,15.87) AN5(-2.029,15.977) AN41(-19.57,15.901) AR5(-1.927,16.995) AR41(-19.734,16.882) AU41(-19.851,17.904) AV4(-1.585,18.134) AW4(-1.379,19.018) AW42(-20.054,18.629) AY1(0,19.272) AY45(-21.628,19.272) B6(-2.364,0.518) B25(-12.039,0.508) B40(-19.515,0.459) BA4(-1.212,19.933) BA5(-2.047,19.909) BA9(-3.723,19.851) BA11(-4.745,19.734) BA13(-5.727,19.57) BA15(-6.718,19.7) BA17(-7.861,19.751) BA20(-9.092,19.7) BA22(-10.147,19.751) BA24(-11.481,19.751) BA26(-12.535,19.699) BA29(-13.767,19.65) BA31(-14.885,19.65) BA33(-15.977,19.599) BA35(-16.995,19.7) BA41(-19.909,19.581) BB3(-0.652,20.158) BB7(-2.998,20.054) BB38(-18.134,20.043) BB39(-19.018,20.248) BB41(-19.933,20.416) BB43(-20.674,20.102) BC4(-1.526,20.674) BC42(-20.158,20.976) BE6(-2.356,21.628) BE40(-19.272,21.628) C10(-4.089,1.087) C28(-13.183,1.087) C37(-17.729,1.087) D3(-0.954,1.526) D5(-1.694,1.212) D7(-2.61,1.379) D8(-3.493,1.585) D10(-4.476,1.411) D15(-6.75,1.411) D17(-8.031,1.393) D19(-9.023,1.411) D24(-11.296,1.411) D27(-12.578,1.393) D29(-13.569,1.411) D31(-14.851,1.393) D33(-15.843,1.411) D36(-17.124,1.393) D39(-18.629,1.574) D43(-20.976,1.47) E5(-1.719,2.047) E6(-2.229,2.05) E11(-4.632,1.927) E13(-5.651,2.029) E15(-6.743,1.978) E17(-7.861,1.978) E20(-9.092,1.929) E22(-10.147,1.876) E24(-11.481,1.876) E26(-12.535,1.927) E29(-13.767,1.876) E31(-14.91,1.927) E33(-15.901,2.058) E35(-16.882,1.894) E37(-17.904,1.776) E41(-19.581,1.719) E42(-20.416,1.694) F1(0,2.356) F41(-19.577,2.229) F44(-21.11,2.364) F45(-21.628,2.356) G4(-1.574,2.998) G42(-20.248,2.61) H3(-0.926,3.423) H40(-19.051,3.169) H42(-20.043,3.493) J3(-1.087,3.898) J5(-1.776,3.723) K4(-1.393,4.503) K42(-20.217,4.476) K43(-20.54,4.089) L5(-1.894,4.745) L41(-19.7,4.632) N4(-1.411,5.785) N5(-2.058,5.727) N41(-19.599,5.651) R5(-1.927,6.718) R41(-19.65,6.743) U4(-1.411,8.058) U5(-1.876,7.861) U41(-19.65,7.861) V3(-1.087,8.445) W4(-1.393,9.05) Y5(-1.927,9.092) Y41(-19.699,9.092)
  oval 0.203x0.254 smd: A7(-2.92,0) A9(-3.962,0) A12(-5.219,0) A14(-6.261,0) A16(-7.492,0) A18(-8.534,0) A21(-9.766,0) A23(-10.807,0) A25(-12.039,0) A28(-13.08,0) A30(-14.312,0) A32(-15.354,0) A35(-16.586,0) A37(-17.652,0) A39(-18.707,0) AA4(-1.487,9.588) AA42(-20.138,9.766) AE4(-1.489,11.862) AE42(-20.14,12.039) AK4(-1.489,14.135) AK42(-20.14,14.312) AP4(-1.489,16.408) AR42(-20.14,16.586) B7(-2.87,0.508) B8(-3.555,0.386) B10(-4.089,0.579) B11(-4.603,0.418) B12(-5.219,0.508) B13(-5.88,0.386) B14(-6.363,0.579) B15(-6.877,0.418) B16(-7.492,0.508) B18(-8.153,0.386) B19(-8.636,0.579) B20(-9.15,0.418) B21(-9.766,0.508) B22(-10.426,0.386) B23(-10.909,0.579) B24(-11.423,0.418) B27(-12.699,0.386) B28(-13.183,0.579) B29(-13.696,0.418) B30(-14.312,0.508) B31(-14.973,0.386) B32(-15.456,0.579) B33(-15.97,0.418) B35(-16.586,0.508) B36(-17.246,0.386) B37(-17.729,0.579) B38(-18.205,0.418) B39(-18.757,0.508) BB10(-4.503,20.235) BB13(-5.785,20.217) BB15(-6.776,20.235) BB17(-8.058,20.217) BB19(-9.05,20.235) BB22(-10.331,20.217) BB24(-11.323,20.235) BB27(-12.605,20.217) BB29(-13.596,20.235) BB31(-14.878,20.217) BB33(-15.87,20.235) BB36(-17.151,20.217) BC8(-3.423,20.702) BC9(-3.898,20.54) BC10(-4.478,20.743) BC13(-5.658,20.702) BC14(-6.172,20.54) BC15(-6.751,20.743) BC17(-7.931,20.702) BC18(-8.445,20.54) BC19(-9.024,20.743) BC22(-10.204,20.702) BC23(-10.718,20.54) BC24(-11.298,20.743) BC26(-12.478,20.702) BC27(-12.992,20.54) BC29(-13.571,20.743) BC31(-14.751,20.702) BC32(-15.265,20.54) BC33(-15.844,20.743) BC35(-17.024,20.702) BC36(-17.538,20.54) BC38(-18.168,20.743) BD6(-2.113,21.168) BD7(-2.87,21.12) BD8(-3.423,21.21) BD9(-3.898,21.048) BD10(-4.381,21.242) BD11(-5.042,21.12) BD13(-5.658,21.21) BD14(-6.172,21.048) BD15(-6.655,21.242) BD16(-7.315,21.12) BD17(-7.931,21.21) BD18(-8.445,21.048) BD19(-8.928,21.242) BD21(-9.588,21.12) BD22(-10.204,21.21) BD23(-10.718,21.048) BD24(-11.201,21.242) BD25(-11.862,21.12) BD26(-12.478,21.21) BD27(-12.992,21.048) BD28(-13.475,21.242) BD30(-14.135,21.12) BD31(-14.751,21.21) BD32(-15.265,21.048) BD33(-15.748,21.242) BD34(-16.408,21.12) BD35(-17.024,21.21) BD36(-17.538,21.048) BD38(-18.072,21.242) BD39(-18.758,21.12) BE7(-2.92,21.628) BE9(-3.975,21.628) BE11(-5.042,21.628) BE14(-6.274,21.628) BE16(-7.315,21.628) BE18(-8.547,21.628) BE21(-9.588,21.628) BE23(-10.82,21.628) BE25(-11.862,21.628) BE28(-13.094,21.628) BE30(-14.135,21.628) BE32(-15.367,21.628) BE34(-16.408,21.628) BE37(-17.666,21.628) BE39(-18.707,21.628) C8(-3.459,0.885) C11(-4.603,0.926) C13(-5.783,0.885) C14(-6.363,1.087) C15(-6.877,0.926) C17(-8.057,0.885) C19(-8.636,1.087) C20(-9.15,0.926) C22(-10.33,0.885) C23(-10.909,1.087) C24(-11.423,0.926) C27(-12.603,0.885) C29(-13.696,0.926) C31(-14.877,0.885) C32(-15.456,1.087) C33(-15.97,0.926) C36(-17.15,0.885) C38(-18.205,0.926) D13(-5.758,1.393) D22(-10.305,1.393) L4(-1.487,5.042) M42(-20.138,5.219) T4(-1.487,7.315) T42(-20.138,7.492)
  oval 0.254x0.203 smd: AA1(0,9.588) AA2(-0.508,9.588) AA44(-21.12,9.766) AA45(-21.628,9.766) AB2(-0.418,10.204) AB3(-0.926,10.204) AB42(-20.235,10.305) AB43(-20.743,10.33) AB44(-21.242,10.426) AC1(0,10.82) AC2(-0.579,10.718) AC3(-1.087,10.718) AC43(-20.54,10.909) AC44(-21.048,10.909) AC45(-21.628,10.807) AD2(-0.386,11.201) AD3(-0.885,11.298) AD42(-20.217,11.296) AD43(-20.702,11.423) AD44(-21.21,11.423) AE1(0,11.862) AE2(-0.508,11.862) AE44(-21.12,12.039) AE45(-21.628,12.039) AF2(-0.418,12.478) AF3(-0.926,12.478) AG2(-0.579,12.992) AG3(-1.087,12.992) AG42(-20.235,12.578) AG43(-20.743,12.603) AG44(-21.242,12.699) AH1(0,13.094) AH2(-0.386,13.475) AH43(-20.54,13.183) AH44(-21.048,13.183) AH45(-21.628,13.08) AJ3(-0.885,13.571) AJ4(-1.393,13.596) AJ42(-20.217,13.569) AJ43(-20.702,13.696) AJ44(-21.21,13.696) AK1(0,14.135) AK2(-0.508,14.135) AK44(-21.12,14.312) AK45(-21.628,14.312) AL2(-0.418,14.751) AL3(-0.926,14.751) AL42(-20.235,14.851) AL43(-20.743,14.877) AL44(-21.242,14.973) AM1(0,15.367) AM2(-0.579,15.265) AM3(-1.087,15.265) AM43(-20.54,15.456) AM44(-21.048,15.456) AM45(-21.628,15.354) AN2(-0.386,15.748) AN3(-0.885,15.844) AN42(-20.217,15.843) AN43(-20.702,15.97) AN44(-21.21,15.97) AP1(0,16.408) AP2(-0.508,16.408) AR2(-0.418,17.024) AR3(-0.926,17.024) AR44(-21.12,16.586) AR45(-21.628,16.586) AT2(-0.579,17.538) AT3(-1.087,17.538) AT4(-1.411,17.151) AT42(-20.235,17.124) AT43(-20.743,17.15) AT44(-21.242,17.246) AU1(0,17.666) AU43(-20.54,17.729) AU44(-21.048,17.729) AU45(-21.628,17.652) AV2(-0.386,18.072) AV3(-0.885,18.168) AV43(-20.702,18.205) AV44(-21.21,18.205) AW1(0,18.707) AW2(-0.508,18.758) AW44(-21.12,18.757) AW45(-21.628,18.707) AY44(-21.168,19.515) BB11(-5.042,20.14) BB16(-7.315,20.14) BB21(-9.588,20.14) BB25(-11.862,20.138) BB30(-14.135,20.138) BB34(-16.408,20.138) D12(-5.219,1.489) D16(-7.492,1.489) D21(-9.766,1.489) D25(-12.039,1.487) D30(-14.312,1.487) D35(-16.586,1.487) F2(-0.459,2.113) G1(0,2.92) G2(-0.508,2.87) G44(-21.12,2.87) G45(-21.628,2.92) H2(-0.418,3.423) H43(-20.743,3.459) H44(-21.242,3.555) J1(0,3.975) J2(-0.579,3.898) J45(-21.628,3.962) K2(-0.386,4.381) K3(-0.885,4.478) K44(-21.048,4.089) L1(0,5.042) L2(-0.508,5.042) L43(-20.702,4.603) L44(-21.21,4.603) M44(-21.12,5.219) M45(-21.628,5.219) N2(-0.418,5.658) N3(-0.926,5.658) N42(-20.235,5.758) N43(-20.743,5.783) N44(-21.242,5.88) P1(0,6.274) P2(-0.579,6.172) P3(-1.087,6.172) P43(-20.54,6.363) P44(-21.048,6.363) P45(-21.628,6.261) R2(-0.386,6.655) R3(-0.885,6.751) R4(-1.393,6.776) R42(-20.217,6.75) R43(-20.702,6.877) R44(-21.21,6.877) T1(0,7.315) T2(-0.508,7.315) T44(-21.12,7.492) T45(-21.628,7.492) U2(-0.418,7.931) U3(-0.926,7.931) U42(-20.235,8.031) U43(-20.743,8.057) V1(0,8.547) V2(-0.579,8.445) V44(-21.242,8.153) V45(-21.628,8.534) W2(-0.386,8.928) W3(-0.885,9.024) W42(-20.217,9.023) W43(-20.54,8.636) W44(-21.048,8.636) Y43(-20.702,9.15) Y44(-21.21,9.15)
  round 0.368 smd: AY2(-0.518,19.263) BD40(-19.263,21.11) C4(-1.47,0.652)
SMF22A-SOD123FL-2-S
  rect 1.295x1.397 smd: 1(0,0) 2(2.9,0)
STARC_115B40-000000-G4-R_40P
  round 0.838 hole 0.838 unplated: (-0.75,-2.125) (20.25,-2.125)
  oval 0.305x1.143 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.499x2.997 smd: 41(22,-2.125) 42(-2.5,-2.125)
  rect 2.794x1.499 smd: 43(15.45,-4.175) 44(4.05,-4.175)
SW_MSS3-Q-T-R_3P
  round 0.94 hole 0.94 unplated: (0.75,-1.75) (3.75,-1.75)
  oval 0.711x1.499 smd: 1(0,0) 2(3,0) 3(4.5,0)
  rect 0.991x0.787 smd: 4(-1.4,-0.7) 5(-1.4,-2.8) 6(5.9,-0.7) 7(5.9,-2.8)
SW_NTC311-EA1T-A160T_4P
  rect 1.651x1.041 smd: 1(0,0) 2(3.85,0)
  rect 1.651x1.041 hole 0.66: 3(-0.1,-1.525) 4(3.95,-1.525)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SW_SSAL120100_3P
  rect 0.787x0.787 smd: 1(0,0) 3(3.4,0)
  rect 1.194x0.787 smd: 2(1.7,0)
  rect 1.041x0.889 smd: 4(-2.375,-1.6) 5(5.775,-1.6)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8286RAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8868QMC_QFN10_2X2
  oval 1.803x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1)
  oval 0.838x0.254 smd: 4(1.675,-1) 5(1.675,-0.5) 6(1.675,0)
  oval 0.254x0.838 smd: 7(1.35,0.825) 8(0.85,0.825) 9(0.35,0.825) 10(-0.15,0.825)
SYV659LQWC_QFN7_1P5X1P5
  oval 0.889x0.254 smd: 1(0,0.1) 2(0,-0.35)
  oval 0.254x0.889 smd: 3(0.35,-1.18) 4(0.8,-1.18) 5(1.25,-1.18)
  oval 1.295x0.254 smd: 6(1.4,-0.35) 7(1.4,0.1)
T-SOL_158-1000902614_23P-T
  oval 0.61x1.092 smd: 1(0,0) 2(-0.9,0) 3(-1.8,0) 4(-2.7,0) 5(-3.6,0) 6(-4.5,0) 7(-5.4,0) 8(-6.3,0) 9(-7.9,0)
  rect 0.889x1.499 smd: 10(-9.9,-0.51) 11(4.7,-0.51)
  rect 1.092x0.991 smd: 12(0.71,-13.45)
  oval 0.61x0.787 smd: 13(-0.54,-13.35) 14(-1.45,-13.35) 15(-2.36,-13.35) 16(-3.27,-13.35) 17(-4.18,-13.35) 18(-5.09,-13.35) 19(-6,-13.35) 20(-6.91,-13.35) 21(-7.82,-13.35)
  oval 1.092x1.905 hole 0.406x1.194: 22(4.6,-9.75) 23(-9.8,-9.75)
TAI-T_HCB1608KF-121T3_L0603_2P
  rect 0.991x0.787 smd: 1(0,0) 2(1.6,0)
TAI-T_HCB2012KF-121T50_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
TPC12
  round 0.305 smd: 1(0,0)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS61099YFFR_DSBGA_6P
  round 0.271 smd: A1(0,0) A2(0.4,0) B1(0,-0.4) B2(0.4,-0.4) C1(0,-0.8) C2(0.4,-0.8)
TS5A3159ADCKR_SC70-6
  oval 0.381x1.372 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0.65,1.74) 6(0,1.74)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
UNIMI_LLGCAX005_182P-T
  round 2.692 hole 2.692 unplated: (6.17,-12.83) (6.17,-1.83)
  round 1.092 hole 1.092 unplated: (12,-12.25)
  oval 1.092x1.499 hole 1.092x1.499 unplated: (12,0)
  round 0.66 smd: A1(0,0) A2(1,0) A3(2,0) A4(3,0) A5(4,0) A6(5,0) A8(7,0) A9(8,0) A10(9,0) A11(10,0) B1(0,-1) B2(1,-1) B3(2,-1) B4(3,-1) B5(4,-1) B9(8,-1) B10(9,-1) B11(10,-1) C1(0,-2) C2(1,-2) C3(2,-2) C4(3,-2) C5(4,-2) C10(9,-2) C11(10,-2) C12(11,-2) C13(12,-2) D1(0,-3) D2(1,-3) D3(2,-3) D4(3,-3) D5(4,-3) D9(8,-3) D10(9,-3) D11(10,-3) D12(11,-3) D13(12,-3) E1(0,-4) E2(1,-4) E3(2,-4) E4(3,-4) E5(4,-4) E6(5,-4) E7(6,-4) E8(7,-4) E9(8,-4) E10(9,-4) E11(10,-4) E12(11,-4) E13(12,-4) F1(0,-5) F2(1,-5) F3(2,-5) F4(3,-5) F5(4,-5) F6(5,-5) F7(6,-5) F8(7,-5) F9(8,-5) F10(9,-5) F11(10,-5) F12(11,-5) F13(12,-5) G1(0,-6) G2(1,-6) G3(2,-6) G4(3,-6) G5(4,-6) G6(5,-6) G7(6,-6) G8(7,-6) G9(8,-6) G10(9,-6) G11(10,-6) G12(11,-6) G13(12,-6) H1(0,-7) H2(1,-7) H3(2,-7) H4(3,-7) H5(4,-7) H6(5,-7) H7(6,-7) H8(7,-7) H9(8,-7) H10(9,-7) H11(10,-7) H12(11,-7) H13(12,-7) J1(0,-8) J2(1,-8) J3(2,-8) J4(3,-8) J5(4,-8) J6(5,-8) J7(6,-8) J8(7,-8) J9(8,-8) J10(9,-8) J11(10,-8) J12(11,-8) J13(12,-8) K1(0,-9) K2(1,-9) K3(2,-9) K4(3,-9) K5(4,-9) K6(5,-9) K7(6,-9) K8(7,-9) K9(8,-9) K10(9,-9) K11(10,-9) K12(11,-9) K13(12,-9) M1(0,-10) M2(1,-10) M3(2,-10) M4(3,-10) M5(4,-10) M6(5,-10) M7(6,-10) M8(7,-10) M9(8,-10) M10(9,-10) M11(10,-10) M12(11,-10) M13(12,-10) N1(0,-11) N2(1,-11) N3(2,-11) N4(3,-11) N5(4,-11) N6(5,-11) N8(7,-11) N9(8,-11) N10(9,-11) N11(10,-11) N12(11,-11) N13(12,-11) P1(0,-12) P2(1,-12) P3(2,-12) P4(3,-12) P5(4,-12) P9(8,-12) P10(9,-12) P11(10,-12) Q1(0,-13) Q2(1,-13) Q3(2,-13) Q4(3,-13) Q5(4,-13) Q10(9,-13) Q11(10,-13) R1(0,-14) R2(1,-14) R3(2,-14) R4(3,-14) R5(4,-14) R9(8,-14) R10(9,-14) R11(10,-14) R12(11,-14) R13(12,-14) S1(0,-15) S2(1,-15) S3(2,-15) S4(3,-15) S5(4,-15) S6(5,-15) S7(6,-15) S8(7,-15) S9(8,-15) S10(9,-15) S11(10,-15) S12(11,-15) S13(12,-15)
  custom 0.151x0.151 smd: A7(6,0) C9(8,-2) N7(6,-11) Q9(8,-13)
W25Q80DVZPIG_WSON8
  oval 0.66x1.092 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.9) 6(2.54,5.9) 7(1.27,5.9) 8(0,5.9)
  rect 4.293x3.404 smd: 9(1.905,2.95)
W25Q256FVEIG_WSON8
  oval 0.66x0.991 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,8) 6(2.54,8) 7(1.27,8) 8(0,8)
  rect 4.293x3.404 smd: 9(1.905,4)
X_7XA0000600_4P
  rect 0.889x1.041 smd: 1(0,0) 2(2.1,0) 3(2.1,1.75) 4(0,1.75)
Y_7M25000016_4P
  rect 0.991x0.889 smd: 1(0,0) 2(2.15,0) 3(2.15,1.55) 4(0,1.55)
Y_CM31532768DZFT_2P
  rect 1.092x1.905 smd: 1(0,0) 2(2.5,0)
Y_X1A000141000200_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
1.2V_DDR_OT: PR802.2 PU800.11
1.2V_DDR_PG: PR806.1 PU800.12 RE180.2
1.2V_DDRP_FB: PC802.2 PR803.2 PR804.1 PU800.13
1.2V_DDRP_LX: PC800.2 PL800.1 PR801.1 PU800.9
1.2V_DDRP_VIN: PC807.1 PC808.1 PC809.1 PL801.2 PU800.1
1.05V_VMMP_ALW_VIN: PC901.1 PL900.2 PU900.5
1.8V_PRIM_PWRGD: RE245.1 UE3.L7
1.8VALW_VIN: PC1501.1 PL1500.2 PU1500.5
1.8VALWP_FB: PC1502.2 PR1504.2 PR1505.1 PU1500.1
1.8VALWP_LX: PL1501.1 PR1503.1 PU1500.6
1.8VALWP_ON: PC1500.1 PR1500.2 PR1502.1 PU1500.2
1.8VALWP_PG: LED_PRI.1 PR1507.1 RE245.2 RE264.1 RE295.1
1VALW_PG: PR708.2 RE295.2
2.5V_MEM_PG: PR813.1 PR2305.2 RE299.2
3.3V_CAM_EN#: QZ9.2 RZ50.1 UH4.BD14
3.3V_MSATA_EN: RH193.1 UH4.BD27
3.3V_TS_EN: RZ13.1 UH4.AR29 UZ4.3
3VALW_EN: PR604.2 PR606.1 PU600.11
3VALW_LX: PC600.2 PL601.1 PR602.1 PU600.7
3VALW_VIN: PC601.1 PC602.1 PC603.1 PC604.1 PL600.2 PU600.1
3VD_EN: PR623.2 PR625.1 PU603.11
3VD_LX: PC636.2 PL607.1 PR621.1 PU603.7
3VD_VIN: PC637.1 PC638.1 PC639.1 PC640.1 PL606.2 PU603.1
5VALW_EN: PR611.2 PR612.1 PU601.11
5VALW_LX: PC612.2 PL603.1 PR609.1 PU601.7
5VALW_VIN: PC613.1 PC614.1 PC615.1 PC616.1 PL602.2 PL609.2 PU601.1
5VD_EN: PR617.2 PR618.1 PU602.11
5VD_LX: PC624.2 PL605.1 PR615.1 PU602.7
5VD_VIN: PC625.1 PC626.1 PC627.1 PC628.1 PL604.2 PL608.2 PU602.1
+0.6V_A_VREFDQ: T748.1(TP-1) UC1.DF13
+0.6V_B_VREFDQ: CD324.1 RD228.1 UC1.DG13
+0.6V_DDR_B_VREFDQ: CD320.1 CD321.1 CD322.1 CD323.1 RD226.2 RD227.1 RD228.2 UD5.M1 UD6.M1 UD7.M1 UD8.M1
+0.6V_DDR_VREFCA: CD263.1 CD264.1 CD292.1 CD316.1 RD160.2 RD161.2 RD162.1 UD1.M1 UD2.M1 UD3.M1 UD4.M1
+0.6V_VREFCA: CD291.1 RD161.1 UC1.DE13
+0.6VS: CD285.1 CD286.1 CD287.1 CD288.1 CD289.1 CD290.1 CD296.1 CD297.1 CD300.1 CD303.1 CD312.1 CD318.1 CD328.1 CD336.1 CD337.1 CD341.1 CD342.1 CD348.1 CD349.1 CD351.1 CD361.1 CD363.1 CD364.1 CD373.1 CD380.1 CD383.1 CD386.1 CD389.1 CD392.1 CD395.1 CD398.1 CD401.1 PJP801.2 RD166.2 RD167.2 RD168.2 RD169.2 RD170.2 RD171.2 RD172.2 RD173.2 RD174.2 RD175.2 RD176.2 RD177.2 RD178.2 RD179.2 RD180.2 RD181.2 RD182.2 RD183.2 RD184.2 RD185.2 RD186.2 RD187.2 RD188.2 RD189.2 RD190.2 RD191.2 RD192.2 RD198.2 RD199.2 RD200.2 RD201.2 RD203.2 RD204.2 RD205.2 RD206.2 RD207.2 RD208.2 RD209.2 RD210.2 RD211.2 RD212.2 RD213.2 RD214.2 RD215.2 RD216.2 RD217.2 RD218.2 RD219.2 RD220.2 RD221.2 RD222.2 RD223.2 RD224.2 RD225.2
+0.6VSP: PC810.1 PC811.1 PJP801.1 PU800.5 PU800.8
+0.95VSP: PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1012.1 PC1014.1 PJP1000.1 PL1001.2 PR1004.1
+1.2V_DDR: CD265.1 CD266.1 CD267.1 CD268.1 CD269.1 CD270.1 CD271.1 CD272.1 CD273.1 CD274.1 CD275.1 CD276.1 CD277.1 CD278.1 CD295.1 CD298.1 CD299.1 CD302.1 CD304.1 CD306.1 CD307.1 CD308.1 CD309.1 CD310.1 CD311.1 CD313.1 CD315.1 CD317.1 CD325.1 CD329.1 CD330.1 CD332.1 CD334.1 CD335.1 CD338.1 CD339.1 CD340.1 CD343.1 CD346.1 CD350.1 CD352.1 CD353.1 CD354.1 CD355.1 CD356.1 CD357.1 CD358.1 CD360.1 CD362.1 CD367.1 CD368.1 CD369.1 CD371.1 CD372.1 CD374.1 CD375.1 CD376.1 CD378.1 CD381.1 CD384.1 CD387.1 CD390.1 CD393.1 CD396.1 CD399.1 CH36.1 CH53.1 CH54.1 CH62.1 CH63.1 CH64.1 CH65.1 CH66.1 CH67.1 CH68.1 CH69.1 CH70.1 CH71.1 CH72.1 CH228.1 CH229.1 CH230.1 CH231.1 PJP800.2 RC32.1 RD160.1 RD193.1 RD202.1 RD226.1 RH216.2 UC1.AP12 UC1.AR6 UC1.AT6 UC1.AT12 UC1.AY6 UC1.BA6 UC1.BF6 UC1.BG6 UC1.BM12 UC1.BP5 UC1.BP6 UC1.BR5 UC1.BR9 UC1.BV12 UC1.BW11 UC1.CD6 UC1.CD7 UC1.CE6 UC1.CE12 UC1.CF12 UC1.CJ6 UC1.CL6 UC6.5 UD1.A1 UD1.A9 UD1.B3 UD1.B9 UD1.C1 UD1.D1 UD1.D9 UD1.E2 UD1.E7 UD1.F2 UD1.F8 UD1.G1 UD1.G7 UD1.G9 UD1.J1 UD1.J2 UD1.J8 UD1.J9 UD1.L1 UD1.L9 UD1.R1 UD1.T9 UD2.A1 UD2.A9 UD2.B3 UD2.B9 UD2.C1 UD2.D1 UD2.D9 UD2.E2 UD2.E7 UD2.F2 UD2.F8 UD2.G1 UD2.G7 UD2.G9 UD2.J1 UD2.J2 UD2.J8 UD2.J9 UD2.L1 UD2.L9 UD2.R1 UD2.T9 UD3.A1 UD3.A9 UD3.B3 UD3.B9 UD3.C1 UD3.D1 UD3.D9 UD3.E2 UD3.E7 UD3.F2 UD3.F8 UD3.G1 UD3.G7 UD3.G9 UD3.J1 UD3.J2 UD3.J8 UD3.J9 UD3.L1 UD3.L9 UD3.R1 UD3.T9 UD4.A1 UD4.A9 UD4.B3 UD4.B9 UD4.C1 UD4.D1 UD4.D9 UD4.E2 UD4.E7 UD4.F2 UD4.F8 UD4.G1 UD4.G7 UD4.G9 UD4.J1 UD4.J2 UD4.J8 UD4.J9 UD4.L1 UD4.L9 UD4.R1 UD4.T9 UD5.A1 UD5.A9 UD5.B3 UD5.B9 UD5.C1 UD5.D1 UD5.D9 UD5.E2 UD5.E7 UD5.F2 UD5.F8 UD5.G1 UD5.G7 UD5.G9 UD5.J1 UD5.J2 UD5.J8 UD5.J9 UD5.L1 UD5.L9 UD5.R1 UD5.T9 UD6.A1 UD6.A9 UD6.B3 UD6.B9 UD6.C1 UD6.D1 UD6.D9 UD6.E2 UD6.E7 UD6.F2 UD6.F8 UD6.G1 UD6.G7 UD6.G9 UD6.J1 UD6.J2 UD6.J8 UD6.J9 UD6.L1 UD6.L9 UD6.R1 UD6.T9 UD7.A1 UD7.A9 UD7.B3 UD7.B9 UD7.C1 UD7.D1 UD7.D9 UD7.E2 UD7.E7 UD7.F2 UD7.F8 UD7.G1 UD7.G7 UD7.G9 UD7.J1 UD7.J2 UD7.J8 UD7.J9 UD7.L1 UD7.L9 UD7.R1 UD7.T9 UD8.A1 UD8.A9 UD8.B3 UD8.B9 UD8.C1 UD8.D1 UD8.D9 UD8.E2 UD8.E7 UD8.F2 UD8.F8 UD8.G1 UD8.G7 UD8.G9 UD8.J1 UD8.J2 UD8.J8 UD8.J9 UD8.L1 UD8.L9 UD8.R1 UD8.T9 UZ18.1 UZ18.2
+1.2V_DDRP: PC802.1 PC803.1 PC804.1 PC805.1 PC806.1 PC816.1 PC817.1 PJP800.1 PL800.2 PR803.1 PU800.6
+1.2V_VCCPLL_OC: CH232.1 CH233.1 CZ32.1 RH216.1 RZ44.2 UC1.BM13 UC1.BM14 UC1.CY13 UC1.DA13
+1.8V_3.3V_ALW_VTR3: CE55.1 RE183.2 RE263.2 UE3.N5
+1.8VALW: C93.1 CE54.1 CH238.1 PJP1500.2 PR1101.1 PR1133.1 QC123.2 QC124.2 QC126.2 R115.1 RC102.1 RC384.1 RE263.1 U14.1 U14.2 UC9.5
+1.8VALWP: PC1502.1 PC1503.1 PC1504.1 PJP1500.1 PL1501.2 PR1504.1
+1V_MPHY: CH96.1 CH97.1 RH202.1 RH206.2 UH4.U21 UH4.U23 UH4.U25 UH4.U26 UH4.V26 UH4.V28
+1V_MPHY_MPHYPLL: CH93.1 CH94.1 CH95.1 RH202.2 UH4.A43 UH4.B43 UH4.C44 UH4.C45
+1V_PCH: RH100.1 RH201.1 RH205.1 RH641.2 UH4.AC17 UH4.AD15 UH4.AL22 UH4.N17 UH4.R17 UH4.R19 UH4.U20 UH4.V17
+1V_PCH_AZPLL: CH123.1 LH1.2 UH4.AN19
+1V_PCH_CLK5: CH90.1 CH91.1 CH92.1 RH205.2 UH4.K2 UH4.K3
+1V_PCH_PRIM: RH642.2 UH4.AA23 UH4.AA26 UH4.AA28 UH4.AC23 UH4.AC26 UH4.AC28 UH4.AE23 UH4.AE26 UH4.AJ20 UH4.AJ21 UH4.AJ23 UH4.AJ25 UH4.Y23 UH4.Y25
+1V_PCH_USBPLL: CH98.1 CH99.1 RH203.2 UH4.AJ5 UH4.AL5
+1V_VCCDSW: CH86.1 RH201.2 UH4.BA29
+1VALW: CH122.1 CZ21.1 CZ28.1 LH1.1 PJP700.2 RH203.1 RH206.1 RH641.1 RH642.1 UZ7.1 UZ7.2 UZ7.7 UZ14.1 UZ14.2 UZ14.7
+1VALWP: PC706.1 PC707.1 PC708.1 PC709.1 PC710.1 PJP700.1 PL701.2 PR702.1
+2.5V_MEM: CD256.1 CD279.1 CD280.1 CD281.1 CD282.1 CD283.1 CD284.1 CD293.1 CD301.1 CD305.1 CD314.1 CD319.1 CD326.1 CD327.1 CD331.1 CD333.1 CD344.1 CD345.1 CD347.1 CD359.1 CD365.1 CD366.1 CD370.1 CD377.1 CD379.1 CD382.1 CD385.1 CD388.1 CD391.1 CD394.1 CD397.1 CD400.1 PR2300.2 UD1.B1 UD1.R9 UD2.B1 UD2.R9 UD3.B1 UD3.R9 UD4.B1 UD4.R9 UD5.B1 UD5.R9 UD6.B1 UD6.R9 UD7.B1 UD7.R9 UD8.B1 UD8.R9
+3.3V_1.8V_ESPI: RC386.2 RH129.2 RH134.2 RH166.2 RH167.2 RH591.2 RH592.2 RH593.2 RH594.2 RH596.2 RH625.2 RH660.2
+3.3V_1.8V_PGPPA: RC384.2 RC386.1 UH4.BA31
+3.3V_EC5105: CE43.1 CE44.1 CE45.1 CE49.1 CE50.1 CE51.1 PJP1402.2 RE105.2 RE107.2 RE108.2 RE109.2 RE111.2 RE112.2 RE113.2 RE119.2 RE124.2 RE127.2 RE130.2 RE133.2 RE227.2 RE228.2 RE265.2 RE266.2 RE267.2 RE268.2 RE269.2 RE270.2 RE276.2 RE277.2 RE278.2 RE300.2 RE426.2 RE435.2 RE437.2 UE3.B7 UE3.G8 UE3.H1 UE3.K2 UE3.M9
+3.3V_EC_PLL: CE47.1 CE48.1 RE113.1 UE3.F1
+3.3VDX_SSD: CD58.1 CD60.1 CD61.1 CD62.1 CD63.1 CZ18.1 JNGFF2.2 JNGFF2.4 JNGFF2.12 JNGFF2.14 JNGFF2.16 JNGFF2.18 JNGFF2.62 JNGFF2.64 JNGFF2.66 RD17.1 RD19.2 RZ18.2
+3V_LDO: JIO1.Q10 PC128.1 PC129.1 PC143.1 PC144.1 PC145.1 PC146.1 PC547.1 PR116.1 PR145.1 PR166.1 PR172.1 PR246.2 PR254.2 PR383.2 PT502.1(TP-1) PU100.5 PU101.5 PU102.5 PU503.5 PU2301.5 PU2302.5 PU2303.5 RP99.2
+3V_LDOP: PQ325.1 PR354.2
+3V_PCH: CH102.1 CH107.1 CH108.1 CH117.1 CZ10.1 JAPS1.1 LH2.1 R208.1 R532.1 R5855.1 RC9.1 RE11.1 RE14.1 RE264.2 RH90.2 RH91.2 RH92.2 RH93.2 RH106.2 RH107.2 RH112.2 RH113.2 RH117.2 RH122.2 RH132.2 RH136.1 RH139.1 RH140.1 RH141.1 RH142.1 RH151.1 RH154.1 RH155.1 RH159.2 RH160.2 RH161.2 RH162.2 RH189.1 RH191.2 RH192.2 RH194.1 RH195.1 RH196.1 RH197.1 RH204.1 RH219.2 RH220.2 RH223.2 RH226.2 RH227.2 RH587.2 RH588.2 RH611.1 RH643.2 RH648.2 RH649.2 RH650.2 RH651.2 RH652.2 RH654.2 RH656.1 RZ10.2 UH4.AN5 UH4.BA20 UH4.BD3 UH4.BE3 UH4.BE4 UZ8.5 UZ10.5 UZ11.5
+3V_PCH_AZIO: CH118.1 LH2.2 UH4.BA15
+3V_PCH_DSW: CC170.1 CC171.1 CH101.1 CH242.1 R2743.2 R5852.1 R5854.1 RH124.2 RH125.2 RH126.2 RH128.2 RH582.1 UC10.5 UH4.BA24 UH4.W15
+3V_PCH_SPI: RH204.2 UH4.BE41 UH4.BE42 UH4.BE43
+3V_ROM: JSPI2.10 RH109.1 RH110.1 RH111.1 RH122.1 UH6.8
+3V_TBT: C1095.1 C1096.1 CT61.1 CT62.1 CT63.1 CT64.1 CT65.1 LT2.2 RT11.1 RT13.1 RT50.2 UT2.A2 UT2.A3 UT2.B3 UT2.H9
+3V_TBT_S0: C1089.1 C1090.1 CT91.1 CT92.1 CT93.1 LT2.1 UT2.R13
+3V_VCCPGPPBCDEFGH: CH100.1 CH103.1 CH104.1 RH648.1 UH4.AD41 UH4.AJ41 UH4.AL41 UH4.BA45 UH4.BB45 UH4.BC42 UH4.BC44 UH4.BC45 UH4.BD40
+3VA_TBT: C1091.1 C1092.1 CT51.1 CT60.1 RT10.1 RT14.1 RT19.1 RT20.1 RT25.1 RT26.1 RT27.1 RT29.1 RT30.1 RT31.1 RT44.1 RT45.1 RT46.1 RT47.1 RT49.1 RT84.1 RT100.1 RT427.1 UT2.F8 UT3.8
+3VA_TBT_LC: C1093.1 C1094.1 CT59.1 RT3.1 RT4.1 RT5.1 RT6.1 UT2.R6
+3VALW: C375.1 C3002.1 C3310.2 C3312.1 CE46.1 CE52.1 CE53.1 CE70.1 CT129.1 CT130.1 CZ6.1 CZ9.1 JIO1.A11 JIO1.B11 JIO1.C12 JIO1.C13 JIO1.D13 JIO1.R1 JIO1.R2 JIO1.S1 JIO1.S2 JKB1.3 PC713.1 PC1013.1 PJP600.2 PJP1402.1 PL900.1 PQ328.1 PR152.1 PR156.1 PR178.1 PR179.2 PR202.2 PR203.2 PR219.2 PR248.2 PR249.2 PR256.2 PR257.2 PR706.1 PR1008.1 PR1102.1 PR1105.1 PR1106.1 PR1107.1 PR1141.1 PR1200.1 PR1202.1 PR1204.1 PR1300.1 PR1302.1 PR1304.1 PU700.15 PU1000.15 Q4.2 QH1.2 QH1.5 QH2.2 QH2.5 R130.1 R1194.1 R2741.2 R5853.1 RC10.1 RC395.1 RC396.1 RE15.1 RE150.1 RE156.2 RE194.1 RE196.2 RE200.1 RE201.1 RE202.1 RE203.1 RE204.1 RE215.1 RE247.2 RH581.1 RH605.1 RH606.1 RP30.2 RP31.1 RP85.2 RP86.2 RP94.2 RPE7.5 RPE7.6 RPE7.7 RPE7.8 RT49.2 U14.4 U20.2 U736.1 U736.2 U736.4 U4253.5 U4254.5 UC4.5 UC5.5 UE7.5 UE12.2 UE13.5 UZ3.1 UZ3.2 UZ5.1 UZ5.2 UZ15.5 UZ16.5 UZ17.5 UZ23.1 UZ23.2 UZ24.1 UZ24.2
+3VALW_DSW_R: R2743.1 U736.7 U736.8
+3VALWP: PC606.1 PC607.1 PC608.1 PC609.1 PJP600.1 PL601.2 PR628.1 PU600.5
+3VD: C101.1 C3022.1 CZ12.1 PC2301.1 PC3278.1 PJP603.2 PL1500.1 PL2204.1 PR263.1 PR265.1 PR810.1 PR901.1 PR2301.2 PR2321.1 PR2333.1 PU2300.7 PU2300.8 PU2300.9 PU2304.15 U14.6 U14.7 U15.7 U15.8 UZ4.1 UZ4.2 UZ6.5
+3VD_LDO: PC641.2 PU603.6
+3VDP: PC642.1 PC643.1 PC644.1 PC645.1 PJP603.1 PL607.2 PU603.5
+3VLP: PC605.2 PU600.6 RE251.2 RTCD1.2
+3VS: C190.1 C225.1 C377.1 CH89.1 CZ8.1 CZ34.1 F1.2 JESPI1.1 JESPI1.2 JIO1.R3 JIO1.S3 JKB1.4 PR1013.1 PR1104.1 PU78.5 QC125.2 QZ9.3 R207.1 R530.1 R531.1 RE1.1 RE2.1 RE6.1 RE7.1 RE12.1 RE272.1 RE292.2 RH59.1 RH66.2 RH67.2 RH97.2 RH101.1 RH102.1 RH103.1 RH104.1 RH118.2 RH148.1 RH174.2 RH175.1 RH176.1 RH177.2 RH178.1 RH179.2 RH180.1 RH182.1 RH584.2 RH586.2 RH640.2 RH645.1 RH657.2 RP1.5 RP1.6 RP1.7 RP1.8 RP2.1 RP2.2 RP2.3 RP2.4 RP3.1 RP3.2 RP3.3 RP3.4 RP4.1 RP4.2 RP4.3 RP4.4 RT50.1 RZ8.2 RZ14.1 RZ50.2 RZ61.1 UH4.AD13 UH7.5 UV14.5
+3VS_CAM: CV235.1 CV247.1 CZ33.1 JCAM1.12 JCAM1.13 RZ49.2
+3VS_CR: CR1.1 CR2.1 CR3.1 CR4.1 RR8.1 RR10.2 RR41.1 RZ14.2 UR1.11 UR1.27
+3VS_FP: C191.1 F1.1 JFP1.1 R5836.2 R5837.1
+3VS_SENSOR: C185.1 C186.1 C2984.1 C3021.1 JCAM1.14 JKB1.2 R207.2 R208.2 R1090.2 R1207.2 U18.9 U18.10
+3VS_TPM: CE5.1 CE6.1 CE7.1 RE10.1 RE11.2 RE27.1 RE272.2 UE2.14 UE2.22
+3VS_TPM_VSB: CE8.1 CE9.1 RE15.2 UE2.1
+3VS_TS: C3003.1 C3004.1 C3005.1 CZ13.1 D18.1 JEDP1.22 QV10.2 QV11.2 QV11.5 RC183.1 RC184.1 RR43.1 RR44.1 RZ11.2
+5V_VBUS1: PQ100.5 US5.13
+5V_VBUS2: PQ111.5 US6.13
+5VALW: C376.1 CP20.1 CP22.1 CP23.1 CP24.1 JCCG1.7 JDEBUG1.1 JDEBUG1.2 JKB1.1 LED2.2 LED3.2 LED4.2 LED5.2 LED6.2 LP1.1 LP2.1 PC2300.1 PJP601.2 PU2300.10 RP118.2 RP119.2 RP141.1 RP142.1 UP1.A1 UP1.C1 UP2.A1 UP2.C1 UPD1.J1 UPD1.L2 UZ3.4 UZ4.4 UZ18.4 UZ23.4
+5VALW_LDO: PC617.2 PU601.6
+5VALW_VCONN1: CP21.1 RP137.2 RP141.2 UP1.B2 UPD1.J2
+5VALW_VCONN2: CP1.1 CP2.1 CP25.1 RP139.2 RP142.2 UP2.B2 UPD1.L9
+5VALWP: PC618.1 PC619.1 PC620.1 PC621.1 PJP601.1 PL603.2 PU601.5
+5VD: C3024.2 CZ5.1 CZ29.1 JIO1.N5 JIO1.N6 JIO1.P5 JIO1.P9 JIO1.P10 JIO1.Q4 JIO1.Q5 JIO1.Q9 JIO1.R4 JIO1.R5 JIO1.R9 JIO1.R10 JIO1.S4 JIO1.S5 JIO1.S6 JIO1.S7 JIO1.S8 JIO1.S9 PJP602.2 RW1.1 U15.10 UZ2.1 UZ2.2 UZ2.4 UZ5.4 UZ7.3 UZ14.3 UZ24.4
+5VD_LDO: PC629.2 PU602.6
+5VDP: PC630.1 PC631.1 PC632.1 PC633.1 PJP602.1 PL605.2 PU602.5
+5VS: CZ7.1 PC1908.1 PC1918.1 PC2008.1 PC2012.1 PR1802.1 PR1838.1 PR1901.2 PR1903.2 PR2001.2 PR2203.2 PR2251.1 PU1900.2 PU1900.15 PU1901.2 PU1901.15 PU2000.2 PU2000.15 PU2201.2 PU2201.15 R5843.1 R5845.1 R5847.1 RE3.1 RE8.1 RE436.1 RZ7.2
+5VS_FAN: JFAN1.1 RE436.2
+VBATT: PC132.1 PC133.1 PC534.1 PD501.2 PL104.1 PL105.1 PL106.1 PQ500.5 PR230.1 PR553.2
+VBUS1_DC_SS: PQ102.5 PQ103.5 PR169.1
+VBUS2_DC_SS: PQ113.5 PQ114.5 PR171.1
+VCC0V9_CIO: C1107.1 C1108.1 CT82.1 CT83.1 CT84.1 UT2.R8 UT2.R9 UT2.R11 UT2.R12
+VCC0V9_DP: C1097.1 C1098.1 CT52.1 CT53.1 CT54.1 CT55.1 CT56.1 CT57.1 CT58.1 UT2.L6 UT2.L8 UT2.L11 UT2.L12 UT2.M6 UT2.M8 UT2.T11 UT2.T12 UT2.V11 UT2.V12 UT2.V13
+VCC0V9_PCIE: C1099.1 C1100.1 CT67.1 CT68.1 CT69.1 CT70.1 UT2.L18 UT2.L19 UT2.M13 UT2.M15 UT2.M16 UT2.M18 UT2.N18 UT2.N19
+VCC0V9_USB: C1103.1 C1104.1 CT66.1 CT71.1 UT2.R15 UT2.R16
+VCC_CORE: CH58.1 PC1400.1 PC1401.1 PC1402.1 PC1403.1 PC1404.1 PC1405.1 PC1406.1 PC1407.1 PC1408.1 PC1409.1 PC1410.1 PC1411.1 PC1412.1 PC1413.1 PC1414.1 PC1415.1 PC1416.1 PC1417.1 PC1418.1 PC1419.1 PC1420.1 PC1421.1 PC1422.1 PC1423.1 PC1424.1 PC1425.1 PC1426.1 PC1427.1 PC1428.1 PC1430.1 PC1431.1 PC1432.1 PC1433.1 PC1434.1 PC1435.1 PC1436.1 PC1437.1 PC1442.1 PC1443.1 PC1444.1 PC1445.1 PC1446.1 PC1447.1 PC1448.1 PC1449.1 PC1450.1 PC1451.1 PC1457.1 PC1458.1 PC1459.1 PC1460.1 PC1461.1 PC1462.1 PC1463.1 PC1464.1 PC1465.1 PC1466.1 PC1467.1 PC1468.1 PC1469.1 PC1470.1 PC1499.1 PL1200.3 PL1200.4 PL1203.3 PL1203.4 PL1204.3 PL1204.4 RH467.1 UC1.BW13 UC1.CA13 UC1.CA14 UC1.CB13 UC1.CB14 UC1.CD13 UC1.CE34 UC1.CE35 UC1.CE36 UC1.CE37 UC1.CE38 UC1.CE39 UC1.CE40 UC1.CE43 UC1.CE44 UC1.CE45 UC1.CE46 UC1.CF13 UC1.CF14 UC1.CF35 UC1.CF36 UC1.CF37 UC1.CF38 UC1.CF39 UC1.CF40 UC1.CF41 UC1.CF42 UC1.CF43 UC1.CF44 UC1.CG33 UC1.CG34 UC1.CG35 UC1.CG36 UC1.CG39 UC1.CG40 UC1.CG41 UC1.CG42 UC1.CG43 UC1.CG44 UC1.CG45 UC1.CG46 UC1.CH13 UC1.CH14 UC1.CJ13 UC1.CJ33 UC1.CJ34 UC1.CJ35 UC1.CJ36 UC1.CJ37 UC1.CJ38 UC1.CJ39 UC1.CJ40 UC1.CJ43 UC1.CJ44 UC1.CJ45 UC1.CJ46 UC1.CK35 UC1.CK36 UC1.CK37 UC1.CK38 UC1.CK39 UC1.CK40 UC1.CK41 UC1.CK42 UC1.CK43 UC1.CK44 UC1.CL13 UC1.CL33 UC1.CL34 UC1.CL35 UC1.CL36 UC1.CL39 UC1.CL40 UC1.CL41 UC1.CL42 UC1.CL43 UC1.CL44 UC1.CL45 UC1.CL46 UC1.CM34 UC1.CM35 UC1.CM36 UC1.CM37 UC1.CM38 UC1.CM39 UC1.CM40 UC1.CM43 UC1.CM44 UC1.CM45 UC1.CM46 UC1.CN35 UC1.CN36 UC1.CN37 UC1.CN38 UC1.CN39 UC1.CN40 UC1.CN41 UC1.CN42 UC1.CN43 UC1.CN44 UC1.CR33 UC1.CR34 UC1.CR35 UC1.CR36 UC1.CR39 UC1.CR40 UC1.CR41 UC1.CR42 UC1.CR43 UC1.CR44 UC1.CR45 UC1.CR46 UC1.CT33 UC1.CT34 UC1.CT35 UC1.CT36 UC1.CT37 UC1.CT38 UC1.CT39 UC1.CT40 UC1.CT43 UC1.CT44 UC1.CT45 UC1.CT46 UC1.CU35 UC1.CU36 UC1.CU37 UC1.CU38 UC1.CU39 UC1.CU40 UC1.CU41 UC1.CU42 UC1.CU43 UC1.CU44 UC1.CV39 UC1.CV40 UC1.CV41 UC1.CV42 UC1.CV43 UC1.CV44 UC1.CV45 UC1.CV46 UC1.CW43 UC1.CW44
+VCCGT: PC2215.1 PC2216.1 PC2217.1 PC2218.1 PC2219.1 PC2222.1 PC2223.1 PC2224.1 PC2225.1 PC2227.1 PC2229.1 PC2230.1 PC2231.1 PC2232.1 PC2235.1 PC2236.1 PC2237.1 PC2238.1 PC2241.1 PC2243.1 PC2249.1 PC2252.1 PC2253.1 PC2256.1 PC2257.1 PC2258.1 PC2259.1 PC2260.1 PC2262.1 PC2263.1 PC2264.1 PC2266.1 PC2267.1 PC2268.1 PC2270.1 PC2272.1 PC2273.1 PC2275.1 PC2276.1 PC2280.1 PC2281.1 PC2283.1 PC2284.1 PC2285.1 PC2286.1 PC2291.1 PC2292.1 PC2293.1 PC2294.1 PC2295.1 PC3288.1 PL1301.3 PL1301.4 PL1303.3 PL1303.4 RH78.1 UC1.CM13 UC1.CM14 UC1.CN13 UC1.CN14 UC1.CT13 UC1.CT14 UC1.CV13 UC1.CV14 UC1.CV33 UC1.CV34 UC1.CV35 UC1.CV36 UC1.CW33 UC1.CW34 UC1.CW35 UC1.CW36 UC1.CW37 UC1.CW38 UC1.CW39 UC1.CW40 UC1.DA16 UC1.DA17 UC1.DA18 UC1.DA19 UC1.DA20 UC1.DA22 UC1.DA23 UC1.DA24 UC1.DA25 UC1.DA26 UC1.DA27 UC1.DA28 UC1.DA30 UC1.DA31 UC1.DA32 UC1.DA35 UC1.DA36 UC1.DA37 UC1.DA38 UC1.DA39 UC1.DA40 UC1.DA41 UC1.DA42 UC1.DA43 UC1.DA44 UC1.DB26 UC1.DB27 UC1.DB28 UC1.DB30 UC1.DB31 UC1.DB32 UC1.DB33 UC1.DB34 UC1.DB35 UC1.DB36 UC1.DB39 UC1.DB40 UC1.DB41 UC1.DB42 UC1.DB43 UC1.DB44 UC1.DB45 UC1.DB46 UC1.DC27 UC1.DC28 UC1.DC31 UC1.DC33 UC1.DC35 UC1.DC37 UC1.DC38 UC1.DC39 UC1.DC40 UC1.DC43 UC1.DC44 UC1.DC45 UC1.DC46 UC1.DD27 UC1.DD28 UC1.DD31 UC1.DD33 UC1.DD35 UC1.DD37 UC1.DD38 UC1.DD39 UC1.DD41 UC1.DD42 UC1.DD43 UC1.DD44 UC1.DE26 UC1.DE27 UC1.DE28 UC1.DE30 UC1.DE31 UC1.DE32 UC1.DE33 UC1.DE35 UC1.DE36 UC1.DE37 UC1.DE38 UC1.DE39 UC1.DE41 UC1.DE42 UC1.DE43 UC1.DE44 UC1.DE45 UC1.DE46 UC1.DF26 UC1.DF27 UC1.DF28 UC1.DF30 UC1.DF31 UC1.DF32 UC1.DF33 UC1.DF35 UC1.DF36 UC1.DF37 UC1.DF38 UC1.DF39 UC1.DF43 UC1.DF45 UC1.DF46 UC1.DG26 UC1.DG28 UC1.DG30 UC1.DG32 UC1.DG33 UC1.DG36 UC1.DG37 UC1.DG39 UC1.DG41 UC1.DG42 UC1.DG43 UC1.DG44 UC1.DG45 UC1.DH26 UC1.DH28 UC1.DH30 UC1.DH32 UC1.DH33 UC1.DH36 UC1.DH37 UC1.DH39 UC1.DH41 UC1.DH42
+VCCIO: CH37.1 CH38.1 CH39.1 PJP1000.2 QE13.1 RH35.1 RH37.2 UC1.BL38 UC1.BL39 UC1.BL40 UC1.BM39 UC1.BM40 UC1.BM41 UC1.BM42 UC1.BM43 UC1.BM44 UC1.BN41 UC1.BN42 UC1.BN43 UC1.BN45 UC1.BN46 UC1.BP33 UC1.BP34 UC1.BP35 UC1.BP36 UC1.BP37 UC1.BP38 UC1.BP39 UC1.BP40 UC1.BP43 UC1.BP44 UC1.BP45 UC1.BP46 UC1.BR13 UC1.BR14 UC1.BR35 UC1.BR36 UC1.BR37 UC1.BR38 UC1.BR39 UC1.BR40 UC1.BR41 UC1.BR42 UC1.BR43 UC1.BR44 UC1.BT33 UC1.BT34 UC1.BT35 UC1.BT36 UC1.BT39 UC1.BT40 UC1.BT41 UC1.BT42 UC1.BT43 UC1.BT44 UC1.BT45 UC1.BT46 UC1.BU13 UC1.BU14 UC1.BV13 UC1.BV14 UC1.BV33 UC1.BV34 UC1.BV35 UC1.BV36 UC1.BV37 UC1.BV38 UC1.BV39 UC1.BV40 UC1.BV43 UC1.BV44 UC1.BV45 UC1.BV46 UC1.BW39 UC1.BW40 UC1.BW41 UC1.BW42 UC1.BW43 UC1.BW44
