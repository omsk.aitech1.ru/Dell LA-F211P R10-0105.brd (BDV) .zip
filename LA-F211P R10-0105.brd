# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V_LDOP: length 6.2
  TOP w0.508: v7(46.61,67.51) 46.65,67.51 47.41,66.75 PQ325.1
  GND2 w0.508: v5(46.58,68.08) 46.58,67.55 v7(46.61,67.51)
  IN2 w0.508: v5(48.51,68.66) 47.93,68.08 v5(46.58,68.08)
  GND3 w0.508: v6(48.95,68.98) 48.64,68.66 v5(48.51,68.66)
  BOTTOM w0.508: v6(48.95,68.98) 48.27,69.67 PR354.2
+3V_PCH: length 375.7
  TOP w0.254: v2(34.95,27.29) 34.95,26.12 34.36,25.53 UZ8.5 ; UZ11.5 39.43,30.51 v2(38.97,30.05) ; RH220.2 RH219.2 RH223.2 36.97,50.72 36.74,50.95 36.74,54.2 36.53,54.41 36.53,56.11
  TOP w0.381: v2(146.58,77.08) 146.58,77.64 146.34,77.88 RC9.1
  TOP w0.508: UZ10.5 35.91,29.83 v2(35.91,29.83) ; v9(2.39,8.62) 2.39,9.48 2.75,9.84 RH155.1 ; CH102.1 30.63,38.08 v9(31.01,37.7) 29.6,36.29 v9(25.4,36.29) ; v9(17.56,7.83) 17.84,7.55 RH191.2 ; 73.64,7.72 73.64,5.28 v7(73.83,5.1) ; RH117.2 18.49,53.38 19.21,53.38 20.12,52.47 v7(20.76,52.47) ; v7(40.56,58.88) 39.37,60.08 v7(37.74,60.08) 37.68,60.01 35.38,60.01 32.42,57.05 32.42,56.66 31.98,56.66 ; 74.06,9.45 74.06,9.99 74.56,10.5 76.23,10.5 76.62,10.88 v9(76.62,11.13)
  IN1 w0.381: 138.47,49.63 137.17,49.63 136.35,50.45 136.35,51.28 135.28,52.36 135.28,69.24 135.97,69.93 136.97,69.93 138.87,71.84 142.78,71.84 143.8,72.85 145.3,72.85 146.38,73.94 v4(146.38,76.13) 146.58,76.33 v2(146.58,77.08)
  IN1 w0.508: v4(76.77,18.87) 77,18.64 87.2,18.64 88.87,16.97 90.61,16.97 91.78,15.8 97.66,15.8 98.35,15.12 99.65,15.12 100.89,16.36 106.53,16.36 106.84,16.05 109.9,16.05 110.4,16.55 115.07,16.55 117.2,14.42 118.6,14.42 119.06,13.96 127.64,13.96 134.96,21.28 134.96,21.72 135.36,22.13 135.97,22.13 137.54,23.69 137.54,25.41 140.98,28.85 145.49,28.85 149.01,32.36 149.01,33.57 150.52,35.09 150.52,37.85 149.6,38.77 149.6,43.82 146.23,47.19 146.23,47.94 144.03,50.14 140.82,50.14 140.31,49.63 138.47,49.63 ; v2(31.72,54.95) 31.72,55.06 v2(32.62,55.96) ; v9(25.4,36.29) 25.4,35.76 27.55,33.61 29.19,33.61 31.46,31.34 37.62,31.34 38.2,30.77 38.2,30.51 ; 38.2,30.51 37.51,29.83 v2(35.91,29.83) ; 38.2,30.51 38.51,30.51 v2(38.97,30.05) 39.01,30.01 39.01,28.81 37.49,27.29 v2(34.95,27.29) ; v9(17.56,7.83) 17.56,9.59 19.71,11.74 19.71,12.43 19.17,12.96 19.17,13.81 21.43,16.07 21.93,16.07 23.33,17.47 v9(23.33,17.93) v9(23.33,20.08) ; v9(24.67,59.33) 22.34,57 22.34,55.16 20.76,53.58 v7(20.76,52.47)
  GND2 w0.305: v7(37.74,60.08) 37.49,60.33 v5(37.49,60.41)
  GND2 w0.508: v7(73.83,5.1) v5(73.21,5.1) ; v5(45.25,3.26) 45.28,3.28 v7(45.69,3.28) ; v5(20.74,52.03) 20.74,52.44 v7(20.76,52.47) ; v4(76.77,18.87) v5(76.38,18.87) ; v5(40.92,58.88) v7(40.56,58.88)
  IN2 w0.381: v5(19.3,49.87) 18.53,49.09 18.53,48.08 v5(18.5,48.05)
  IN2 w0.508: v5(41.06,60.97) 40.92,60.83 v5(40.92,58.88)
  GND3 w0.107: v6(27.82,44.64) v5(27.59,44.87)
  GND3 w0.254: v6(37.9,60.15) 37.65,60.41 v5(37.49,60.41) ; v6(35.45,61.31) v5(35.45,61.68) ; v5(33.88,59.45) 33.69,59.26 v6(33.08,59.26) ; v6(36.38,60.13) 35.99,60.13 v5(35.98,60.14) v6(35.45,60.14) ; v6(34.58,60.57) v5(34.58,61)
  GND3 w0.381: v6(18.7,47.64) 18.5,47.85 v5(18.5,48.05) ; v6(41.06,61.3) v5(41.06,60.97)
  GND3 w0.508: v6(72.86,5.13) 72.9,5.1 v5(73.21,5.1) ; v5(76.38,18.87) v6(76.05,18.87) ; v6(45.06,2.93) 45.25,3.13 v5(45.25,3.26) ; v6(20.72,50.37) v5(20.72,50.91) ; v5(19.3,49.87) 19,49.87 18.94,49.82 v6(18.94,49.42)
  IN3 w0.254: v9(25.27,36.91) 25.97,36.91 26.26,37.2 26.26,37.83 26.49,38.06 27.15,38.06 27.53,37.67 28.07,37.67 29.08,36.66 v3(29.08,34.22)
  IN3 w0.508: v9(17.56,7.83) 18.12,7.27 21.66,7.27 22.7,8.31 23.69,8.31 26.53,5.47 30.51,5.47 32.72,3.26 36.86,3.26 37.45,2.67 44.79,2.67 v6(45.06,2.93)
  BOTTOM w0.127: v9(31.01,37.7) 31.14,37.57 UH4.AN5
  BOTTOM w0.254: RH132.2 28.77,31.02 28.77,32.78 28.92,32.93 28.92,33.7 29.08,33.86 v3(29.08,34.22)
  BOTTOM w0.305: v6(36.38,60.13) 36.58,60.13 37.02,60.13 RH226.2
  BOTTOM w0.356: v9(76.62,11.13) 76.88,10.86 R5855.1 ; RH160.2 RH90.2 RH112.2 35.26,61.5 v6(35.45,61.31) RH161.2 ; RH192.2 v6(33.08,59.26) ; R532.1 25.16,20.5 24.8,20.15 24.8,18.92 24.43,18.55 23.95,18.55 v9(23.33,17.93)
  BOTTOM w0.381: 19.28,46.88 19.28,47.07 v6(18.7,47.64)
  BOTTOM w0.457: v6(45.06,2.93) 46.05,3.92 52.96,3.92 54.94,5.9 58.12,5.9 59.98,7.77 66.58,7.77 68.68,5.67
  BOTTOM w0.508: v6(72.86,5.13) 72.71,5.29 69.06,5.29 68.68,5.67 ; 73.69,18.87 v6(76.05,18.87) ; 73.69,18.87 73.69,17.99 74.14,17.54 74.14,15 76.62,12.53 v9(76.62,11.13) ; 73.69,18.87 72.92,18.87 71.03,16.97 71.03,16.93 70.95,16.86 R208.1 ; v9(2.39,8.62) 2.85,8.16 3.98,8.16 4.78,7.35 9.27,7.35 9.93,6.7 12.61,6.7 13.74,7.83 v9(17.56,7.83) RE14.1
  vias: v9(22.74,20.08) v9(23.47,33.35) v9(23.85,32.93) v9(25.12,59.77) v16(29.69,57.23)
+3V_PCH_AZIO: length 3.1
  TOP w0.127: v7(27.87,42.12) 27.68,42.31 v1(26.9,42.31)
  TOP w0.254: LH2.2 27.79,42.04 v7(27.87,42.12)
  GND2 w0.254: v7(27.87,42.12) 27.83,42.12 v5(27.5,41.79)
  GND3 w0.254: v6(27.82,42.26) 27.5,41.95 v5(27.5,41.79)
+3V_PCH_DSW: length 104.2
  TOP w0.254: v7(28.37,47.4) 28.32,47.45 CC170.1
  TOP w0.381: v7(61.69,15.92) RH582.1 61.2,15.14 60.88,15.46 UC10.5
  TOP w0.508: v9(18.94,42.22) 18.5,42.66 16.67,42.66 v1(16.54,42.53) 16.02,42.01 v9(16.02,38.13)
  IN1 w0.508: v9(76.36,9.62) 75.78,10.21 71,10.21 67.99,13.21 64.87,13.21 62.16,15.92 v7(61.69,15.92)
  GND2 w0.254: v7(28.37,47.4) 28.27,47.3 v5(28.01,47.3) ; v5(38.11,42.75) 38.31,42.55 v6(38.48,42.55)
  GND2 w0.508: v7(15.08,31.55) v5(15.44,31.55) ; v5(29.94,43.08) 30.07,43.08 30.35,42.8 v4(30.5,42.8) ; v7(61.69,15.92) v5(61.36,15.92)
  IN2 w0.508: v9(16.02,38.13) 16.02,37.28 16.71,36.59 16.71,32.82 v5(15.44,31.55) 15.74,31.25 17.62,31.25 18.36,30.51 18.36,27.67 20.99,25.04 22.72,25.04 24.68,23.08 25.36,23.08 27.96,20.48 31.31,20.48 31.87,19.92 33.57,19.92 36.18,17.31 51.2,17.31 51.56,16.96 53.74,16.96 54.45,16.25 61.03,16.25 v5(61.36,15.92)
  GND3 w0.254: v5(38.11,42.75) 38.31,42.55 v6(38.48,42.55) ; v6(27.77,47.03) 27.77,47.06 v5(28.01,47.3) ; v5(28.19,42.78) v8(27.66,42.78)
  IN3 w0.508: v9(18.94,42.22) 19.72,43.01 v6(20.8,43.01) 21.37,43.01 22.22,42.16 23.64,42.16 24.25,42.78 24.97,42.78 25.38,42.37 27.22,42.37 27.63,42.78 v8(27.66,42.78)
  BOTTOM w0.356: R5852.1 76.34,9.61 v9(76.36,9.62) 76.38,9.61 R5854.1
  vias: v6(20.76,42.12)
+3V_PCH_SPI: length 2.6
  BOTTOM w0.127: 22.07,57.99 21.69,57.99 21.56,57.87 21.54,57.87 21.5,57.83 20.44,57.83 v1(19.78,57.17)
+3V_ROM: length 109.5
  IN2 w0.508: v5(18.58,54.69) 18.23,54.69 16.63,53.09 16.63,50.1 17.41,49.32 17.41,48.19 18.1,47.49 21.98,47.49 22.5,46.97 22.5,44.99 21.84,44.33 21.84,42.92 22.21,42.55 22.21,36.82 21.92,36.53 21.92,32.76 28.46,26.22 30.15,26.22 35.84,20.53 36.6,20.53 38.06,19.06 51.93,19.06 52.28,18.71 54.47,18.71 55.18,18 61.71,18 63.73,20.02 69.25,20.02 73.95,15.32 v5(75.66,15.32)
  GND3 w0.254: v5(75.66,15.32) 75.68,15.3 v6(75.68,14.88)
  GND3 w0.508: v5(18.58,54.69) 18.73,54.54 v6(18.94,54.54)
  IN3 w0.508: v3(19.66,58.57) 19.49,58.4 19.49,55.09 v6(18.94,54.54)
  BOTTOM w0.254: RH111.1 19.83,51.9 RH110.1
  BOTTOM w0.305: v6(75.68,14.88) 75.68,14.48 v1(77.89,12.27) 77.99,12.17 77.99,9.37 77.35,8.73 JSPI2.10
  BOTTOM w0.508: v6(18.94,54.54) RH109.1 RH111.1 ; UH6.8 18.83,57.74 v3(19.66,58.57)
+3V_TBT: length 29.5
  GND2 w0.254: v7(35.91,83.14) 35.91,83.01 v5(35.73,82.84)
  GND2 w0.381: v7(31.47,86.47) 31.44,86.44 31.44,86.1 v5(31.39,86.05) ; v7(29.94,86.52) 30.17,86.52 v5(30.36,86.33)
  GND3 w0.254: v6(35.9,82.52) 35.73,82.68 v5(35.73,82.84)
  GND3 w0.381: v6(30.07,86.05) v5(30.36,86.33) ; v6(30.96,86.05) v5(31.39,86.05)
  IN3 w0.381: v6(30.07,86.05) 29.96,86.05 29.18,86.82 27.56,86.82 26.86,87.52 26.86,91.31 27.34,91.79 30.65,91.79 32.5,93.63 34.3,93.63 34.69,93.24 36.83,93.24 38.16,91.9 40.41,91.9 v3(40.61,91.7)
  BOTTOM w0.381: v3(40.61,91.7) 41.32,90.99 42.14,90.99 42.58,90.54 42.58,89.85 RT13.1 RT11.1
  vias: v2(31.02,87.51) v2(31.91,87.51) v2(32.67,86.95) v2(33.25,86.44) v2(35.91,83.78) v16(28.55,87.78)
+3V_TBT_S0: length 13.5
  IN1 w0.508: 29.56,84.85 29.13,85.29 29.13,87.03 30.1,87.99 33.39,87.99 35.13,86.25 36.48,86.25 37.18,85.55 37.18,84.66
  GND2 w0.203: v7(39.18,80.56) 39.07,80.56 38.86,80.35 v5(38.86,80.32)
  GND3 w0.203: v6(39.15,80.57) 38.91,80.32 v5(38.86,80.32)
  vias: v7(29.94,84.28) v7(29.94,83.9)
+3V_VCCPGPPBCDEFGH: length 15.3
  TOP w0.508: v7(35.28,55.66) 34.15,55.66 v1(34.13,55.64) 33.77,55.28 v7(32.74,55.28) 32.36,55.28 32.12,55.52 28.67,55.52 27.97,54.82 v7(26.9,54.82) 26.55,55.17 v6(26.55,55.7)
  GND2 w0.254: v5(32.35,55.51) 32.58,55.28 v7(32.74,55.28) ; v5(35.81,55.53) 35.68,55.66 v7(35.28,55.66) ; v7(26.9,54.82) 26.9,55.14 v5(26.85,55.18)
  GND3 w0.152: v5(26.51,57.53) 26.51,57.41 v6(26.75,57.17) ; v5(27.28,56.79) 27.16,56.66 v6(26.91,56.66) ; v5(27.02,57.47) 27.02,57.4 v6(27.25,57.17) ; v6(27.75,57.17) 27.52,57.41 v5(27.52,57.53) ; v6(36.04,55.3) v5(35.81,55.53) ; v6(33.76,55.3) v5(33.5,55.55) ; v6(32.61,55.25) v5(32.35,55.51)
  GND3 w0.254: v6(26.41,54.81) 26.3,54.92 v5(26.3,55.18) ; v5(26.85,55.18) 26.85,55.38 26.55,55.68 v6(26.55,55.7)
+3VA_TBT: length 52.2
  TOP w0.381: v9(35.47,91.59) RT14.1 35.09,91.05 34.9,90.86 RT20.1 RT84.1 RT31.1 ; C1091.1 34.71,85.59 RT427.1
  TOP w0.508: v9(44.19,86.97) 44.04,87.12 44.04,89.36 v1(43.66,89.74) 43.02,90.38 v9(42.01,90.38)
  IN1 w0.508: v4(46.99,91.29) 44,88.29 44,87.16 v9(44.19,86.97)
  GND2 w0.254: v7(34.71,83.13) 34.73,83.13 v5(35.02,83.42) 34.71,83.74 v7(34.71,83.76)
  GND2 w0.508: v4(46.99,91.29) v5(47.51,91.29)
  IN2 w0.508: v9(53.51,102.28) 53.51,97.39 52.45,96.32 52.45,94.57 52.55,94.47 52.55,93.86 52.12,93.43 49.04,93.43 48.59,92.97 48.59,91.88 48,91.29 v5(47.51,91.29)
  GND3 w0.254: v5(35.02,83.42) 35.02,83.39 v6(35.25,83.17)
  IN3 w0.381: v9(42.01,90.38) 41.88,90.25 v3(41.88,88.51)
  IN3 w0.508: 32.99,85.93 33.37,86.32 33.37,87.84 31.59,89.62 31.59,91.95 32.69,93.05 34.01,93.05 v9(35.47,91.59)
  BOTTOM w0.254: RT29.1 v3(41.88,88.51)
  BOTTOM w0.356: RT10.1 RT46.1
  BOTTOM w0.381: RT46.1 RT45.1 45.34,85.82 v9(44.19,86.97) ; v9(42.01,90.38) 41.22,90.38
  BOTTOM w0.508: UT3.8 50.63,101.84 51.3,101.84
  vias: v3(27.72,86.32) v3(28.93,86.32) v3(28.95,85.43)
+3VA_TBT_LC: length 10.6
  TOP w0.127: RT3.1 v1(41.5,90.44)
  TOP w0.508: RT6.1 RT3.1 RT5.1 v2(39.72,88.93)
  IN1 w0.508: v7(39.79,83.83) 39.79,87.24 39.24,87.79 39.24,88.45 v2(39.72,88.93)
  GND2 w0.254: v7(39.79,83.83) 39.54,83.58 39.52,83.58 39.49,83.56 v5(39.4,83.56)
  GND3 w0.254: v5(39.4,83.56) 39.4,83.6 39.19,83.82 v6(39.15,83.82)
+3VALW: length 460
  TOP w0.203: v9(32.8,101.11) 32.8,101.58 PR156.1 ; U14.4 67.34,85.49 v2(67.13,85.27)
  TOP w0.254: v7(45.26,27.56) 45.26,27.62 46.47,28.82 46.47,30.52 46.29,30.7 UE7.5 ; RE215.1 36.59,11.04 v2(36.5,11.13) ; v2(106.19,29.23) 106.04,29.11 105.89,29.11 105.06,28.29 PU1000.15 ; RE156.2 54.62,10.97 55.04,11.39 55.92,11.39 55.99,11.45 v7(56.05,11.45) ; RC10.1 30.1,21.06 v9(29.74,21.06) ; PR248.2 PR249.2 30.1,73.01 30.32,73.23 30.86,73.23 v7(31.11,73.49) ; v9(32.8,101.11) 32.95,100.97 32.95,100.6 PR178.1 32.66,100.48 32.31,100.83 PR203.2 ; PQ328.1 v7(47.98,68.97)
  TOP w0.356: v9(47.85,6.24) 47.49,5.89 RE203.1 47.49,4.34 47.02,3.87 47.02,3.52
  TOP w0.381: UZ17.5 45.02,26.51 44.55,26.04 44.55,25.1 44.93,24.72 46.66,24.72 47.15,25.21 UZ16.5 ; PR1107.1 135.81,48.8 134.73,47.72 134.73,45.59 v7(135.4,44.91) ; RH606.1 60.96,16.59 61.35,16.99 62.49,16.99 v7(62.63,16.85) ; PR257.2 v7(38.16,107.32) PR256.2 ; PR1105.1 v7(138.53,46.64)
  TOP w0.508: v9(7.18,36.15) 7.18,33.38 v9(6.6,32.8) ; v9(7.18,36.15) 6.02,36.15 5.76,36.4 v9(5.2,36.4) ; v9(7.18,36.15) 7.21,36.18 v7(7.21,37.65) ; 109.57,25.98 v16(109.48,25.89) ; 109.57,25.98 110.69,27.09 v2(110.69,30.41) ; 109.57,25.98 108.92,25.98 108.56,25.61 PR1008.1 ; 109.57,25.98 109.57,24.97 108.38,23.78 v7(106.88,23.78) ; PR219.2 124.2,18.19 v9(123.64,17.64) ; v2(34.01,73.62) 34.4,73.22 UC4.5 ; v2(31.28,10.19) 30.13,10.19 29.31,11 v16(20.93,11) 18.32,11 16.68,9.36 16.68,6 16.34,5.66 v2(16.05,5.66) ; v9(56.58,11.01) 56.56,10.99 56.44,10.87 56.44,10.55 55.74,9.86 RE194.1 ; PR1304.1 106.77,39.37 v7(107.13,39.73) ; PR1300.1 147.68,52.98 148.7,51.96 v9(149.45,51.96)
  IN1 w0.254: v9(56.58,11.01) 56.56,10.99 56.54,10.99 56.37,11.16 56.35,11.16 v7(56.05,11.45) ; v7(47.98,68.97) 49.39,70.37 50.09,70.37 57.91,78.19 57.91,79.9 58.79,80.78 59.92,80.78 62.33,83.19 63.98,83.19 65.53,84.74 66.6,84.74 v2(67.13,85.27) ; 33.44,10.97 33.44,11.89 33.63,12.08 33.94,12.08 34.22,12.36 v7(34.22,13.28) ; 33.44,10.97 33.06,10.97 32.28,10.19 v2(31.28,10.19) ; 33.44,10.97 34.71,10.97 34.87,11.13 v2(36.5,11.13)
  IN1 w0.508: v9(47.85,6.24) 47.85,5.99 47.15,5.29 46.26,5.29 45.16,4.19 45.16,3.12 44.68,2.64 38.48,2.64 v9(37.87,3.26) ; v9(14.83,26.6) 14.83,26.43 14.77,26.37 14.77,24.65 14.09,23.97 14.09,21.62 12.7,20.22 12.7,19.28 11.76,18.34 10.94,18.34 10.28,19.01 9.35,19.01 8.87,18.52 7.72,18.52 5.37,20.87 5.37,25.29 6.34,26.26 6.34,26.66 7.23,27.55 7.23,31.74 6.6,32.37 v9(6.6,32.8) ; v4(29.44,67.16) 29.44,66.05 29.79,65.69 30.32,65.69 30.82,65.19 v2(30.83,65.19) ; v7(31.11,73.49) 31.31,73.29 33.68,73.29 v2(34.01,73.62) ; v9(32.8,4.01) 32.8,4.01 17.7,4.01 v2(16.05,5.66) ; v9(19.73,28.96) 19.4,28.96 18.89,29.47 18.89,30.18 18.96,30.24 18.96,32.78 18.24,33.5 18.24,36.55 17.74,37.05 v2(17.74,37.17) ; v7(47.72,25.23) 47.96,24.99 49.03,24.99 v2(49.75,24.27) ; 107.16,30.41 107.16,31.83 v4(107.41,32.09) ; 107.16,30.41 v2(110.69,30.41) ; 107.16,30.41 106.19,29.44 v2(106.19,29.23) ; v7(107.13,39.73) 108.53,41.13 111.93,41.13 112.67,40.39 v7(112.67,38.26) 113.26,38.26 115.72,40.72 119.12,40.72 119.86,39.99 v2(119.86,38) 120.72,38 123.31,40.6 126.49,40.6 127.16,39.92 v2(127.16,39.53) 128.04,39.53 130.63,42.12 v7(135.4,42.12)
  GND2 w0.254: v7(45.26,27.56) 45.22,27.52 v5(45.22,26.95) ; v4(24.67,79.04) v5(25.02,79.04) ; v7(48.61,22.75) v5(48.61,22.3) ; v5(25.02,79.51) v4(24.64,79.51) ; v5(37.23,14.18) 37.4,14.34 v7(37.4,14.56) ; v5(48.03,87.33) 47.85,87.15 v7(47.7,87.15) ; v5(33.42,69.58) 33.37,69.58 33.2,69.75 v7(33.05,69.75) ; v7(47.98,68.97) v5(47.57,68.97)
  GND2 w0.305: v5(37.52,107) 37.84,107.32 v7(38.16,107.32)
  GND2 w0.508: v7(138.53,46.64) 138.53,46.34 v5(138.6,46.26) ; v5(48.04,25.48) 47.98,25.48 v7(47.72,25.23) ; v7(62.63,16.85) 62.63,16.6 v5(62.84,16.4) ; v5(106.91,39.4) 107.13,39.63 v7(107.13,39.73) ; v5(106.56,23.46) v7(106.88,23.78) ; v4(107.41,32.09) 107.16,32.09 v5(106.91,32.34) ; v7(31.11,73.49) 31.11,73.34 30.83,73.06 v5(30.83,72.98) ; v4(29.44,67.16) 29.44,67.49 v5(29.49,67.54) ; v7(54.96,18.55) 54.96,18.81 v5(55.06,18.91) ; v5(148.6,62.55) 148.38,62.77 v7(148.38,62.88) ; v5(7.21,38.58) v7(7.21,37.65) ; v7(135.4,42.12) v5(135.05,42.12) ; v7(135.4,44.91) v5(135.78,44.91) ; v7(41.96,102.85) v5(41.96,102.19) ; v7(34.22,13.28) 34.22,13.42 v5(34.5,13.7)
  IN2 w0.254: 37.41,67.8 36.93,67.8 36.29,68.43 35.18,68.43 34.13,69.47 33.52,69.47 v5(33.42,69.58) 33.27,69.73 32.76,69.73 32.25,69.22 31.54,69.22 31.2,68.88 v5(30.54,68.88) ; 37.41,67.8 37.69,68.08 v5(37.69,68.92) ; 37.41,67.8 v5(37.41,67.42) 37.41,66.57 v5(37.05,66.21) ; v5(48.04,25.48) 46.16,25.48 45.22,26.42 v5(45.22,26.95) ; v5(47.57,68.97) 47.57,70.34 45.18,72.73 42.26,72.73 40.93,71.39 40.93,70.31 41.6,69.64 41.6,68.13 v5(41.13,67.66)
  IN2 w0.508: v9(32.8,101.11) 33.41,101.11 v5(35.51,99.02) ; v5(135.05,42.12) 135.05,44.18 v5(135.78,44.91) 135.78,46.93 136.43,47.58 138.15,47.58 138.6,47.12 v5(138.6,46.26) 138.93,45.93 v5(140.51,45.93) ; v5(148.6,62.55) 149.4,61.75 150.39,61.75 151.56,60.58 151.56,58.26 149.45,56.15 149.45,55.45 150.06,54.84 150.06,52.57 v9(149.45,51.96) ; v5(106.91,32.34) 106.71,32.34 104.9,34.16 104.9,35.97 105.71,36.78 105.71,38.21 v5(106.91,39.4) ; v5(41.96,102.19) v5(41.96,100.29) ; v5(45.94,90.24) v5(43.78,90.24)
  GND3 w0.254: v6(103.06,18.94) v5(103.53,18.94) ; v6(104.06,19.9) v5(103.67,19.9) ; v5(48.03,87.33) 47.96,87.39 v6(47.7,87.39) ; v6(37.11,67.72) 37.11,67.72 v5(37.41,67.42) ; v6(103.06,17.9) v5(103.06,18.46) ; v5(34.5,13.7) 34.8,13.4 v6(34.8,13.26) ; v6(104.06,18.9) v5(104.06,18.49) ; v5(41.13,67.66) v6(40.73,67.66)
  GND3 w0.305: v6(36.66,66.38) 36.82,66.21 v5(37.05,66.21)
  GND3 w0.381: v8(12.93,63.16) 13.1,63.16 v5(13.5,62.76) ; v5(37.69,68.92) 37.69,68.91 37.69,68.47 v6(37.68,68.46) ; v5(12.61,62.67) 12.52,62.67 v8(12.14,63.04) ; v8(37.51,106.56) 37.52,106.57 v5(37.52,107) ; v6(13.13,49.43) v5(12.72,49.43) ; v8(37.51,100.16) v5(37.08,100.16)
  GND3 w0.508: v5(140.51,45.93) 141.04,45.93 v8(141.27,46.16) ; v8(7.35,39.6) 7.21,39.46 v5(7.21,38.58) ; v8(46.2,89.81) 45.94,90.06 v5(45.94,90.24) ; v5(13.93,54.54) 14.18,54.29 v6(14.18,54.16) ; v8(32.15,87.66) v5(32.58,87.66)
  IN3 w0.381: v8(12.93,63.16) 12.92,63.16 10.22,65.86 10.22,68.62 v3(9.74,69.11) ; v8(12.14,63.04) v3(10.06,65.12)
  IN3 w0.508: v3(29.08,106.51) 29.13,106.56 v8(37.51,106.56) 37.75,106.32 37.75,100.4 v8(37.51,100.16) ; v6(47.7,87.39) 47.15,87.39 45.83,88.72 45.83,89.44 v8(46.2,89.81) 46.26,89.87 v3(47.33,89.87) ; v3(7.48,41.19) 7.48,39.73 v8(7.35,39.6) ; v3(147.42,31.51) 147.42,33.23 149.7,35.51 149.7,41.93 147.24,44.39 142.01,44.39 141.27,45.13 v8(141.27,46.16) 141.8,46.69 142.78,46.69 143.32,46.16 147.65,46.16 149.12,47.63 149.12,51.63 v9(149.45,51.96) ; v3(149.51,29.42) 150.58,28.35 154.44,28.35 155.23,27.57 155.23,26.12 v9(155.93,25.42) ; v8(32.15,87.66) 32.1,87.71 v6(27.72,87.71) ; v9(32.8,4.01) 36.94,4.01 37.69,3.26 v9(37.87,3.26)
  BOTTOM w0.203: v9(32.8,101.11) 32.99,101.3 PR152.1
  BOTTOM w0.254: v6(37.68,68.46) 37.69,68.47 39.21,68.47 39.85,67.84 40.55,67.84 v6(40.73,67.66)
  BOTTOM w0.305: RP85.2 37,66.22 36.82,66.22 v6(36.66,66.38) ; JKB1.3 36.92,8.37 35.59,9.69 35.59,12.46 v6(34.8,13.26)
  BOTTOM w0.356: R1194.1 85.18,7.42 85.18,8.25 85.58,8.65 85.58,9.21 83.35,11.45 v9(81.31,11.45) ; U4253.5 46.77,90.32 47.22,89.87 v3(47.33,89.87) ; v9(75.98,11.13) 75.98,10.32 R5853.1
  BOTTOM w0.381: QH1.5 6.46,32.66 v9(6.6,32.8) 6.74,32.66 QH1.2 ; UE12.2 10.63,67.76 9.74,68.65 v3(9.74,69.11) ; QH2.2 5.41,36.15 5.2,36.35 v9(5.2,36.4) ; RE150.1 v3(10.06,65.12) ; QH2.5 v9(7.18,36.15)
  BOTTOM w0.508: v3(147.42,31.51) v3(149.51,29.42) ; v9(29.74,21.06) 30.02,20.78 30.02,18.95 RE15.1 ; 42.07,6.88 CE46.1 43.3,6.6 CE52.1 CE53.1 43.3,4.57 43.84,4.03 44.57,4.03 45.7,5.16 47.01,5.16 47.85,6 v9(47.85,6.24) ; Q4.2 v3(7.48,41.19)
  vias: v2(15.98,79.11) v2(16.39,74.4) v9(13.66,26.63) v9(14.25,26.63) v9(18.69,18.83) v9(19.35,20.17) v9(19.3,18.83) v9(19.38,19.59) v9(19.74,28.33) v9(19.74,27.69) v9(20.32,28.9) v9(20.32,28.33) v9(20.32,27.76) v9(20.9,28.9) v9(20.9,28.33) v9(20.9,27.76) v9(21.47,28.9) v9(21.47,28.33) v9(21.47,27.76) v9(22.06,28.2) v9(56.79,7.06) v9(78.43,20.73) v9(79.02,21.37) v9(79.02,20.73) v9(79.6,21.37) v9(79.6,20.73) v9(122.88,17.02) v9(122.91,16.36) v9(123.62,17.02) v9(123.62,16.34) v16(20.55,29.86)
+3VALW_DSW_R: length 3.1
  TOP w0.127: R2743.1 16.42,32.43 15.98,32.87 13.92,32.87 v1(13.75,33.04)
+3VALWP: length 20.4
  BOTTOM w0.203: PC606.1 15.47,31.17 15.03,31.6 13.74,31.6 13.53,31.81 13.53,32.19 13.08,32.64 8.91,32.64 8.45,32.19 8.45,29.72 5.81,27.08 5.81,24.31 6.21,23.92 PR628.1 7.58,23.45 8.61,23.45 PU600.5
  vias: v1(10.7,30.82) v9(12.87,30.81)
+3VD: length 263.3
  TOP w0.381: PR2321.1 64.74,52.11 PL2204.1
  TOP w0.508: v7(150.28,88.84) v7(144.86,88.84) ; PR901.1 14.14,23.68 v2(14.14,24.85)
  TOP w0.635: v7(137.64,84.26) 137.46,84.44 135.58,84.44 131.47,88.55 84.31,88.55 83.55,89.31 v7(81.76,89.31)
  IN1 w0.254: v2(85.15,111.26) 84.11,110.22 81.23,110.22 78.86,107.85 v2(78.86,107.78)
  IN1 w0.508: v4(66.19,100.64) 66.21,100.64 66.85,101.28 73.5,101.28 v2(74.09,100.69) ; v4(19.91,70.25) 18.21,70.25 v2(18.09,70.36) ; v2(14.14,24.85) 13.23,23.94 10.57,23.94 10.26,23.63 7.93,23.63 6.92,24.64 6.92,26.42 7.81,27.31 7.81,38.21 7.72,38.3 7.72,39.65 6.85,40.52 6.85,41.48 7.72,42.35 7.72,52.39 8.74,53.4 12.6,53.4 17.8,58.6 v4(18.72,58.6) ; v4(52.27,101.03) 52.27,105.36 52.66,105.75 v9(54.62,105.75)
  GND2 w0.254: v7(69.62,85.35) 69.48,85.35 v5(69.23,85.6) 69.24,85.6 69.45,85.81 v7(69.62,85.81)
  GND2 w0.508: v5(137.35,83.94) 137.64,84.23 v7(137.64,84.26) ; v5(81.38,88.91) 81.76,89.29 v7(81.76,89.31) ; v5(65.63,100.34) 65.88,100.34 v4(66.19,100.64) ; v4(19.91,70.25) v5(20.16,70) ; v7(23.53,90.06) 23.52,90.06 v5(23.09,90.49) ; v4(18.72,58.6) 18.49,58.83 v5(18.25,58.83) ; v5(144.06,88.47) 144.43,88.84 v7(144.86,88.84) ; v5(52.63,100.79) 52.39,101.03 v4(52.27,101.03) ; v5(150.87,88.84) v7(150.28,88.84)
  IN2 w0.508: v9(54.62,105.75) 55.11,105.75 56.36,104.5 56.36,103.42 57.58,102.2 58.98,102.2 59.33,101.85 59.33,101.11 59.76,100.68 60.31,100.68 61.17,99.82 65.12,99.82 65.63,100.32 v5(65.63,100.34) ; v5(52.63,100.79) 48.42,100.79 45.06,97.43 45.06,95.21 44.09,94.24 42.67,94.24 41.74,95.17 35.63,95.17 33.64,97.16 32.73,97.16 32.26,96.69 32.26,95.95 31.37,95.06 27.18,95.06 26.95,94.83 26.64,94.51 23.89,94.51 23.09,93.71 v5(23.09,90.49) 23.09,85.59 23.69,84.98 23.69,81.33 21.82,79.46 21.82,71.66 v5(20.16,70) 19.95,69.8 19.95,63.07 17.24,60.35 17.24,59.18 17.59,58.83 v5(18.25,58.83)
  GND3 w0.254: v5(71.09,82.56) 71.09,82.15 v6(71.14,82.1) ; v5(76.25,90.2) 75.97,90.2 v6(75.92,90.15)
  GND3 w0.508: v5(53.84,69.96) 53.46,70.35 v6(53.35,70.35) ; v6(151.68,88.84) v5(150.87,88.84) ; v8(143.18,88.47) v5(144.06,88.47) ; v8(137.13,84.33) 137.13,84.18 137.35,83.97 v5(137.35,83.94)
  IN3 w0.508: v8(137.13,84.33) 137.13,85.54 140.06,88.47 v8(143.18,88.47)
  BOTTOM w0.254: PU2304.15 150.9,89.32 151.38,88.84 v6(151.68,88.84) ; UZ4.1 55.79,104.31 55.65,104.45 55.37,104.45 55.22,104.3 CZ12.1 54.71,104.63 54.96,104.88 55.85,104.88 56.29,104.45 UZ4.2
  BOTTOM w0.381: v6(75.92,90.15) 76.12,90.35 PR810.1 ; v6(151.68,88.84) 151.9,88.84 152.28,89.22 152.28,90.32 v3(152.11,90.48)
  BOTTOM w0.508: v9(54.62,105.75) 53.92,105.04 53.92,104.66 54.28,104.3 CZ12.1 ; v6(71.14,82.1) 71.14,81.12 PL1500.1
  vias: v5(63.63,53.11) v5(68.93,89.81) v5(69.24,90.19) v5(72.81,92.86) v5(72.81,92.41) v5(73.25,92.86) v5(73.25,92.41) v5(73.69,92.86) v5(73.69,92.41) v5(74.14,92.86) v5(74.14,92.41) v5(74.58,92.86) v5(74.58,92.41) v6(68.87,90.19) v7(63.97,52.53) v7(64.22,52.84) v7(72.87,93.55) v7(72.87,93.24) v7(73.19,93.55) v7(73.19,93.24) v7(73.5,93.55) v7(73.5,93.24) v7(73.82,93.55) v7(73.82,93.24) v7(74.14,93.55) v7(74.14,93.24) v7(74.46,93.55) v7(74.46,93.24) v16(72.87,94.44)
+3VDP: length 13.1
  TOP w0.203: PU603.5 64.18,100.85 64.55,100.48 64.55,99.71 64.87,99.4 66.33,99.4 66.46,99.52 68.68,99.52 71.76,102.6 71.76,104.51 PC643.1
  vias: v1(77.49,104.64) v9(73.17,106.18) v9(73.2,104.81) v9(73.2,104.17) v9(75.79,104.86) v9(75.79,104.29) v9(75.94,106.2) v9(76.43,104.86) v9(76.43,104.29) v9(76.6,106.15) v9(76.76,105.52) v9(77.06,104.86) v9(77.06,104.22) v9(77.19,106.1) v9(77.31,105.52)
+3VLP: length 201.7
  TOP w0.254: RE251.2 38.45,16.19 v9(38.8,15.83)
  IN1 w0.508: v4(155.33,5.75) 155.33,7.1 152.73,9.71 152.73,12.07 151.71,13.09 v4(138.15,13.09)
  GND2 w0.508: v4(138.15,13.09) v5(137.79,13.09) ; v5(155.33,5.38) v4(155.33,5.75)
  IN2 w0.508: v5(163.32,9.28) 165.81,9.28 169.08,6 169.08,3.97 167.66,2.55 156.64,2.55 155.33,3.85 v5(155.33,5.38) ; v5(137.79,13.09) 136.69,14.19 132.18,14.19 131.67,13.67 131.13,13.67 129.71,15.1 129.71,16.72 126.69,19.73 113.9,19.73 113.02,20.61 110.84,20.61 105.87,25.57 103.54,25.57 103.12,26 95.2,26 93.83,27.37 91.39,27.37 89.94,25.92 89.94,24.67 88.85,23.58 87.97,23.58 84.06,19.67 84.06,16.45 82.39,14.79 77.75,14.79 77.11,14.15 66.05,14.15 57.05,14.15 56.4,14.81 53.85,14.81 53.21,15.45 52.15,15.45 51.58,14.88 49.76,14.88 49.29,15.35 47.28,15.35 46.78,14.85 45.66,14.85 45.27,15.23 44.39,15.23 44.24,15.39 42.52,15.39 42.31,15.6 39.04,15.6 v9(38.8,15.83) 38.76,15.87 35.49,15.87 34,17.36 29.04,17.36 25.12,21.29 19.03,21.29 16.77,23.54 v5(13.4,23.54)
  GND3 w0.508: v5(13.4,23.54) 13.21,23.72 v8(12.67,23.72) ; v5(163.32,9.28) 163.09,9.28 162.77,9.59 v6(162.77,9.62)
  IN3 w0.508: v3(7.16,24.72) 7.16,24.25 7.68,23.72 v8(12.67,23.72)
+3VS: length 496.8
  TOP w0.254: RH179.2 35.19,52 35.21,52.03 35.21,53.23 34.24,54.21 v7(34.24,54.59)
  TOP w0.305: v9(33.91,14.75) 33.64,14.75 RE292.2
  TOP w0.356: RH148.1 30.78,53.42 RH176.1 30.71,53.09 v7(30.86,52.94)
  TOP w0.381: v9(18.26,50.35) 18.26,50.09 18.01,49.84 17.27,49.84 16.3,50.81 16.3,52.08 16.86,52.63 RH118.2 ; PU78.5 44.16,52.29 44.66,52.79 44.66,54.57 44.28,54.95 43.61,54.95 40.24,51.58 40.24,50.53 39.86,50.15 36.76,50.15 35.45,51.45 RH179.2 ; UV14.5 55.88,23.72 RZ61.1 56.25,25.12 56.87,25.74 v7(56.87,26.08) ; RH67.2 RH148.1 ; RH657.2 32.51,59.89 v7(32.52,59.9) ; RH102.1 RH103.1 v7(22.18,50.25) 21.92,50.25 21.52,50.64 RH104.1
  TOP w0.508: v7(71.47,16.87) 71.89,17.29 71.89,20.69 73.48,22.28 v16(73.48,24.19) v7(71.8,25.86) ; v2(124.86,7.4) 124.38,6.91 120.6,6.91 119.86,7.65 114.41,7.65 v7(112.56,5.8) ; v2(104.74,25.82) 104.74,25.39 104.5,25.15 PR1013.1 ; C377.1 16.07,9.58 18.08,11.59 29.61,11.59 v9(29.63,11.58) ; v7(129.33,20.52) 128.49,19.69 128.49,17.95 128.62,17.83 128.62,8.41 v9(128.62,8.4) ; v11(134.04,29.29) RE7.1 RE2.1 ; CH89.1 36.5,41.23 v11(36.45,41.28) ; RE1.1 RE6.1 139.19,29.09 v7(139.58,29.48) ; RH66.2 RH67.2
  TOP w1.016: 133.64,28.28 132.62,27.26 131.1,27.26 130.08,26.24 130.08,21.28 v7(129.33,20.52)
  GND1 w0.254: v17(36.14,41.59) v11(36.45,41.28)
  GND1 w0.508: v11(134.04,29.29) v17(134.85,29.29)
  IN1 w0.381: v2(104.74,25.82) 104.74,26.1 v4(106.14,27.5)
  IN1 w0.508: v9(33.91,14.75) 33.44,14.75 31.78,13.1 31.15,13.1 v9(29.63,11.58) ; v9(150.09,6.94) v9(149.45,6.94) 147.32,6.94 146.58,6.2 134.31,6.2 132.12,8.4 v9(128.62,8.4) 125.86,8.4 v2(124.86,7.4) ; v9(18.26,50.35) 18.26,51.29 18.97,52 18.97,54.38 v9(20.55,55.95)
  IN1 w0.762: 148.15,78.54 148.15,76.83 147.96,76.63 147.96,73.52 149.89,71.58 151.55,71.58 152.47,70.66 152.47,53.52 151.8,52.85 151.42,52.85 149.58,51.01 v4(149.58,49.29)
  IN1 w1.016: 148.81,79.55 151.08,79.55 152.03,80.5 152.03,93.61 149.79,95.84 149.79,97.51 150.42,98.14 v2(150.49,98.14)
  GND2 w0.107: v5(35.79,41.48) 35.83,41.48 35.93,41.59 v17(36.14,41.59)
  GND2 w0.254: v7(32.52,59.9) 32.56,59.9 v5(32.79,59.67) ; v7(34.24,54.59) v5(34.24,55.02)
  GND2 w0.305: v5(34.62,86.01) 34.62,86.26 34.34,86.54 v7(34.16,86.54) 33.85,86.54 v7(33.75,86.44) 33.63,86.32 33.63,85.91 v5(33.73,85.81) 33.75,85.78 33.8,85.78 v7(34.16,86.14)
  GND2 w0.356: v5(30.88,53.27) 30.86,53.24 v7(30.86,52.94)
  GND2 w0.381: v7(22.18,50.25) v5(21.84,50.25) ; v4(106.14,27.5) 106.14,27.7 v5(106.02,27.83)
  GND2 w0.508: v5(71.15,17.16) 71.44,16.87 v7(71.47,16.87) ; v7(139.58,29.48) v5(139.58,30.56) ; v7(71.8,25.86) 71.62,26.04 v5(70.91,26.04) ; v7(112.56,5.8) v5(112.18,5.8) ; v7(56.87,26.08) v5(56.87,26.5)
  IN2 w0.508: v9(33.91,14.75) 31.77,14.75 30.45,16.07 27.33,16.07 25.75,17.65 25.75,18.5 24.99,19.26 v9(22.51,19.26)
  IN2 w1.016: 141.26,44.72 139.3,42.77 139.3,37.67 136.42,34.79 136.42,31.3 ; 128.05,20.28 127.73,20.28 127.44,20.57 115.44,20.57 113.21,22.8 113.21,24.85 112.25,25.81 110.19,25.81 108.44,27.57 107.03,27.57 ; 56.87,27.45 58.16,27.45 59.78,25.83 70.7,25.83 v5(70.91,26.04) 73.27,28.4 76.39,28.4 77.72,27.08 85.16,27.08 85.36,26.88 88.68,26.88 90.74,28.94 95.9,28.94 97.27,27.57 104.42,27.57
  GND3 w0.254: v5(19.03,48.09) v6(19.36,48.09) ; v6(36.04,41.23) v5(35.79,41.48) ; v6(30.01,59.84) v5(30.32,60.15) 30.58,59.9 v6(30.58,59.84) ; v6(21.24,54.49) 21.31,54.49 v5(21.54,54.26) 21.26,53.99 v6(21.24,53.99) ; v6(39.4,60.22) v5(39.4,60.83) ; v6(17.1,47.64) v5(17.4,47.33) ; v6(21.24,52.99) 21.28,52.99 v5(21.56,53.27) 21.34,53.49 v6(21.24,53.49)
  GND3 w0.305: v6(20.72,48.09) 21.08,48.09 v5(21.1,48.06)
  GND3 w0.508: v6(112.06,4.9) 112.18,5.02 v5(112.18,5.8) ; v6(70.77,17.54) 70.77,17.54 v5(71.15,17.16) ; v8(45.34,86.47) v5(45.34,86.14) ; v6(33.91,15.69) v9(33.91,14.75)
  IN3 w0.254: v8(147.8,79.1) 147.8,77.77 147.39,77.36 147.39,71.63 147.24,71.48 147.24,67.84 150.8,64.28 150.8,63.9 150.72,63.82 150.72,63.2 151.99,61.93 151.99,56.45 150.62,55.08 150.62,51.89 149.58,50.85 149.58,49.61 149.83,49.36
  IN3 w0.508: v9(25.4,30.1) 25.4,29.88 26.75,28.52 26.85,28.52 30.09,25.28 30.09,22.97 v3(29.56,22.44) 29.07,21.95 29.07,20.4 30,19.47 30,17.67 32.91,14.75 v9(33.91,14.75) ; v8(45.34,86.47) 45.48,86.61 45.48,87.8 44.96,88.32 44.96,90.29 44.45,90.8 43.85,90.8 42.94,91.7 42.94,93.26 42.33,93.87 42.33,97 46.34,101.02 55.89,101.02 56.36,100.55 58.7,100.55 59.57,99.68 67.74,99.68 69.57,101.5 76.22,101.5 77.59,102.88 77.59,103.73 77.92,104.06 77.92,107.65 80.13,109.86 81.25,109.86 v6(81.43,110.04)
  IN3 w0.762: 151.08,6.92 153.31,6.92 154.43,5.8 154.43,5.01
  BOTTOM w0.254: v9(20.55,55.95) 20.71,55.78 RP4.1 ; RP2.1 16.77,47.97 v6(17.1,47.64) ; RP4.4 20.67,57.28 v9(20.47,57.08) ; v3(29.56,22.44) 29.07,22.92 R531.1 R530.1 ; RH584.2 RH586.2 17.55,34.87 18.01,35.32 20.41,35.32 v9(20.52,35.44)
  BOTTOM w0.305: JKB1.4 36.42,8.33 35.21,9.54 35.21,12.31 34.39,13.13 34.39,14.28 v9(33.91,14.75)
  BOTTOM w0.356: v9(30.51,60.94) 30.6,60.94 30.62,60.92 RH640.2 ; R207.1 C225.1
  BOTTOM w0.381: v6(33.91,15.69) 33.92,15.69 34.65,15.69 34.87,15.91 37.5,15.91 38.14,16.55 39.1,16.55 39.4,16.26 42.76,16.26 43.03,16.53 45.8,16.53 47.17,15.16 49.51,15.16 QC125.2 ; RP2.1 RP2.2 RP2.3 RP2.4 16.35,49.63 17.08,50.36 18.25,50.36 v9(18.26,50.35) 18.28,50.37 RH182.1
  BOTTOM w0.508: JIO1.R3 v6(112.06,4.9) ; v6(81.43,110.04) 81.61,109.86 RH59.1 ; RE12.1 RE272.1 30.13,12.08 v9(29.63,11.58) ; v6(70.77,17.54) 69.82,16.59 69.82,16.26 R207.1
  vias: v4(147.59,79.21) v4(147.93,79.2) v5(29.94,30.44) v5(29.94,29.93) v5(29.94,29.42) v5(29.94,28.91) v5(30.45,30.44) v5(30.45,29.93) v5(30.45,29.42) v5(30.45,28.91) v5(56.49,28.95) v5(56.92,28.95) v5(129,20.52) v5(129,19.99) v5(134.85,29.93) v5(135.35,29.93) v5(141.88,45.81) v5(141.89,45.36) v5(147.35,79.58) v5(147.8,79.58) v5(149.89,49.17) v5(150.15,48.79) v6(164.43,3.5) v6(164.42,3.13) v6(164.76,3.14) v6(164.76,3.51) v7(29.69,30.69) v7(29.69,30.18) v7(29.69,29.67) v7(29.69,29.17) v7(30.2,30.69) v7(30.2,30.18) v7(30.2,29.67) v7(30.2,29.17) v7(141.64,46.07) v8(142.19,45.68) v8(149.96,48.47) v9(20.09,56.41) v9(20.65,56.53) v9(26.03,30.1)
+3VS_CAM:
  vias: v9(146.15,101.58) v9(146.15,101) v16(147.17,96.75)
+3VS_CR: length 6.9
  IN2 w1.016: 22.63,61.52 23.35,62.24 23.35,68.1
  vias: v1(21.94,59.52) v5(23.36,70.07) v5(23.36,69.58) v5(23.36,69.09) v7(22.96,70.11) v7(22.95,69.61) v9(21.35,61.07) v9(21.92,61.07)
+3VS_FP: length 35.4
  TOP w0.127: v16(158.89,4.28) v9(159.1,4.78)
  IN1 w0.508: v2(158.04,19.77) 158.04,16.45 160.26,14.23 160.76,14.23 162.5,12.49 163.21,12.49 165.86,9.84 165.86,9 170.6,4.27 170.6,3.26 170.18,2.84 167.78,2.84 166.16,4.45 159.43,4.45 v9(159.1,4.78)
+3VS_SENSOR: length 282.5
  TOP w0.508: v7(150.04,36.15) 150.04,35.62 147.92,33.49 v2(147.92,32.1) ; v9(36.74,6.75) 36.94,6.54 38.58,6.54 v2(38.58,6.55) ; v9(71.92,15.45) v16(71.92,16.47) 72.48,17.02 72.48,20.45 74.14,22.12 v9(74.14,22.56)
  IN1 w0.508: v2(147.92,32.1) 145.25,29.43 140.74,29.43 136.81,25.51 136.81,23.8 135.73,22.71 135.12,22.71 134.38,21.97 134.38,21.52 127.4,14.55 119.3,14.55 118.84,15.01 117.44,15.01 114.44,18.01 113.77,18.01 113.53,18.24 110.41,18.24 108.53,20.13 106.55,20.13 105.67,19.24 105.67,19.1 103.65,17.08 98.72,17.08 98.31,16.67 92.14,16.67 90.86,17.94 89.74,17.94 87.67,20.01 86.73,20.01 85.98,20.76 81.46,20.76 80.4,19.7 78.1,19.7 76.87,20.94 75.26,20.94 74.14,22.05 v9(74.14,22.56) ; v9(71.92,15.45) 70.71,15.45 69.05,17.11 68.43,17.11 63.19,22.35 58.6,22.35 58.4,22.55 58,22.55 57.62,22.93 54.19,22.93 53.48,23.64 49.55,23.64 48.79,24.4 47.66,24.4 47.35,24.72 45.19,24.72 43.4,26.52 40.98,26.52 39.75,25.29 37.97,25.29 33.49,20.81 33.49,19.86 32,18.36 30.08,18.36 27.79,16.08 27.79,15.57 23.5,11.28 23.5,9.63 21.8,7.94 21.8,6.38 22.43,5.76 36.17,5.76 36.56,6.15 37.68,6.15 38.08,6.55 v2(38.58,6.55)
  GND2 w0.254: v5(147.2,99.18) 147.16,99.15 v7(147.16,98.77)
  GND2 w0.508: v5(150.69,36.15) v7(150.04,36.15)
  IN2 w0.508: v5(150.69,36.15) 150.69,37.9 150.68,37.96 150.6,42.5 150.6,42.74 150.69,43.17 150.86,43.57 151.1,43.94 151.41,44.25 151.77,44.49 152.18,44.66 152.58,45.06 152.58,70.13 150.96,71.75 149.59,71.75 148.08,73.26 148.08,76.88 152.23,81.03 152.23,93.23 147.2,98.26 v5(147.2,99.18)
  GND3 w0.254: v5(147.2,99.18) 147.15,99.18 v6(146.74,99.6)
  BOTTOM w0.254: v6(146.74,99.6) 146.49,99.84 145.64,99.84 144.93,100.55 JCAM1.14
  BOTTOM w0.305: v9(36.74,6.75) 36.86,6.75 37.42,7.31 JKB1.2
  BOTTOM w0.508: C185.1 68.07,15.04 68.32,14.79 R207.2 R208.2 71.41,14.79 71.92,15.3 v9(71.92,15.45) ; v9(74.14,22.56) 74.02,22.44 74.02,21.3 72.51,19.79 R1207.2 68.18,20.96 67.67,21.47 66.58,21.47 66.07,20.96 R1090.2
+3VS_TPM: length 33
  IN1 w0.508: v9(19.85,13.48) 19.85,13.61 21.46,15.22 22.86,15.22 24.51,16.87 v9(24.51,17.54)
  IN2 w0.508: v9(30.13,14.5) 28.08,14.5 25.14,17.43 v9(25.14,18.22)
  IN3 w0.508: v9(19.85,13.48) 19.76,13.39 19.76,11.33 21.05,10.04 v9(21.05,8.76)
  BOTTOM w0.254: RE272.2 30.67,13.8 30.96,13.51 30.96,12.14 29.85,11.03 29.49,11.03 RE10.1 ; UE2.22 20.22,13.11 19.95,12.85 19.41,12.85 CE6.1 ; CE5.1 22.51,8.53 22.59,8.6 UE2.14
  BOTTOM w0.508: v9(19.85,13.48) 19.59,13.48 19.28,13.16 CE6.1 ; CE5.1 21.29,7.84 21.05,8.08 v9(21.05,8.76) ; RE272.2 v9(30.13,14.5) 29.5,14.5 29.18,14.18 RE27.1
  vias: v1(25.69,17.74)
+3VS_TPM_VSB: length 6
  BOTTOM w0.254: UE2.1 26.32,14.11 26.5,14.29 26.5,14.59 26.26,14.83 26.26,15.32 v1(27.02,16.08) CE8.1 27.96,16.99 CE9.1 RE15.2
+3VS_TS: length 22.4
  TOP w0.381: v16(55.41,99.08) 55.57,99.24 RR44.1
  TOP w0.432: QV11.2 QV11.5 55.63,101.16 RR44.1
  GND2 w0.508: v5(54.9,94.63) 55.11,94.85 v7(55.11,94.98) ; v7(55.65,98.63) 55.65,98.74 v5(55.85,98.94)
  IN2 w0.508: v5(55.73,99.93) 55.73,99.06 v5(55.85,98.94)
  GND3 w0.508: v6(55.73,100.31) v5(55.73,99.93) ; v6(54.91,94.24) 54.91,94.62 v5(54.9,94.63)
  BOTTOM w0.305: v6(54.91,94.24) 54.91,95.01 55.42,95.52
  BOTTOM w0.356: 64.35,98.13 64.42,98.2 RR43.1 64.42,99.7 QV10.2
  BOTTOM w0.508: RZ11.2 54.71,100.31 v6(55.73,100.31) ; 64.35,98.13 61.74,95.52 55.42,95.52
+5V_VBUS1: length 14.9
  TOP w0.127: v2(33.33,73.98) v16(33.33,74.69)
  IN1 w0.508: v4(27.03,72.62) 28.13,72.62 28.6,73.09 30.28,73.09 30.5,73.31 30.5,73.83 30.78,74.11 31.37,74.11 31.52,73.96 33.31,73.96 v2(33.33,73.98)
  GND2 w0.508: v4(27.03,72.62) 26.85,72.44 v5(26.85,72.23)
  GND3 w0.508: v5(26.85,72.23) v8(26.85,72.64)
  IN3 w0.508: v3(21.56,74.36) 25.12,74.36 v8(26.85,72.64)
+5V_VBUS2: length 25
  TOP w0.127: v2(27.85,89.55) v16(28.55,89.55)
  IN1 w0.508: v2(27.85,89.55) 27.29,88.99 19.45,88.99 16.16,92.28 16.16,94.43 16.68,94.95 20.89,94.95 23.24,97.3 23.24,97.96
  vias: v5(21.79,99.52) v5(21.76,99.1) v5(22.32,99.87) v5(22.6,99.52) v5(22.6,99.04) v5(22.86,100.35) v5(22.86,99.88) v5(23.36,100.4) v5(23.89,99.69) v5(23.89,99.21) v5(24.36,99.68) v5(24.36,99.19) v6(23.21,100.04) v6(23.21,99.73) v6(23.76,100.79) v6(23.75,100.42) v6(23.75,100.08) v6(24.05,100.79) v6(24.04,100.42) v6(24.02,100.08) v6(24.34,100.79) v6(24.36,100.41) v6(24.34,100.08) v6(24.62,100.6) v7(22.2,99.38) v7(22.2,99.08) v7(22.2,98.76) v7(23,99.31) v7(23,99.03) v7(23,98.71) v7(23.5,99.56) v7(23.5,99.28) v7(23.5,98.98) v7(23.5,98.66)
+5VALW: length 340.4
  TOP w0.127: v9(54.33,84.79) v16(54.9,84.79)
  TOP w0.254: UZ18.4 116.68,99.16 115.05,97.53 115.05,93.97 114.93,93.85 114.93,93.48 115.28,93.14 v7(117.02,93.14)
  TOP w0.381: LED6.2 v9(5.74,46.34)
  TOP w0.508: LED3.2 5.67,35.54 v9(6.4,34.82) ; LED4.2 v9(5.69,39.14) ; LED5.2 5.42,42.74 v9(5.74,43.06) ; LED2.2 5.2,31.94 v9(5.74,31.4) 6.96,31.4 10.23,34.68 v16(12.49,34.68) 13.13,34.68 14.52,33.28 19.95,33.28 20.74,32.49 20.74,31.77 19.61,30.64 v9(19.61,29.85)
  IN1 w0.381: v4(24.02,74.68) 25.51,76.17 25.51,78.03 26.44,78.96 30.32,78.96 v4(30.95,78.34) ; v9(19.61,29.85) 21.64,29.85 22.74,28.75 22.74,27.91 22.87,27.78 v2(23.51,27.78)
  IN1 w0.508: v9(37.06,4.85) 35.64,3.42 16.23,3.42 v2(15.96,3.69) 15.23,3.69 11.52,7.4 v9(10.87,7.4) ; v4(18.75,59.51) 15.99,59.51 13.61,57.13 11.02,57.13 8.96,55.07 7.92,55.07 5.58,52.73 5.58,46.5 v9(5.74,46.34) v9(5.74,43.06) 5.18,42.5 5.18,39.65 v9(5.69,39.14) 5.69,36.91 5.79,36.81 5.79,35.43 v9(6.4,34.82)
  GND2 w0.381: v5(116.58,93.49) 116.66,93.49 v7(117.02,93.14) ; v5(30.57,78.34) v4(30.95,78.34)
  GND2 w0.457: v5(23.64,74.73) 23.97,74.73 v4(24.02,74.68)
  GND2 w0.508: v5(19.26,59.51) v4(18.75,59.51) ; v7(80.84,106.11) 80.81,106.15 80.32,106.15 v5(80.3,106.18)
  IN2 w0.381: v5(31.85,69.67) 31.66,69.86 v5(31.66,70.5) 31.66,73.11 30.64,74.12 30.64,78.26 v5(30.57,78.34)
  IN2 w0.508: v5(116.58,93.49) 116.35,93.72 115.55,93.72 115.03,93.2 112.7,93.2 111.81,94.09 107.2,94.09 106.65,93.54 95.93,93.54 91.6,97.87 91.6,99.92 88.59,102.93 86.89,102.93 83.64,106.18 v5(80.3,106.18) 78.08,103.96 78.08,102.24 76.4,100.56 68.14,100.56 67.92,100.34 v9(66.98,100.34) ; 23.19,72.41 23.17,72.4 23.17,70.82 21.95,69.6 v5(21.95,68.34) 21.95,67.13 21.48,66.66 v5(21.48,64.85) 21.48,63.12 19.26,60.9 v5(19.26,59.51) ; v9(51.91,84.73) 51.91,84.07 52.56,83.42 52.56,77.74 53.84,76.47 54.95,76.47 56.95,74.47 56.95,73.72 57.5,73.17 58.58,73.17 59.03,72.73 59.03,70.82 56.41,68.2 56.41,64.78 54.43,62.79 53.24,62.79 51.46,61.01 51.46,55.38 55.29,51.55 55.29,45.92 v5(56.93,44.28)
  GND3 w0.254: v6(21.82,68.66) 21.82,68.48 v5(21.95,68.34) ; v5(31.14,96.29) v6(30.59,96.29) ; v6(31.18,70.53) 31.63,70.53 v5(31.66,70.5)
  GND3 w0.508: v6(57.38,44.28) v5(56.93,44.28) ; v5(21.48,64.85) v6(22.01,64.85) ; v8(55.22,103.96) v5(54.71,103.96)
  IN3 w0.254: v6(31.18,70.53) 31.19,70.53 31.45,70.27 31.45,70.26 31.54,70.17 31.54,69.88 31.18,69.53 v3(30.68,69.53)
  IN3 w0.508: v3(59.95,23.67) 59.95,23.67 54.39,29.23 53.4,29.23 52.41,30.22 52.41,35.23 v3(52.45,35.28) ; v9(10.87,7.4) 6.99,7.4 3.81,10.57 3.81,14.32 5.62,16.13 5.62,20.86 5.31,21.18 5.31,27.03 5.69,27.41 5.69,31.35 v9(5.74,31.4) 5.69,31.45 5.69,32.85 6.31,33.47 6.31,34.73 v9(6.4,34.82) ; v8(55.22,103.96) v3(57.29,103.96) 57.77,103.96 58.65,103.08 58.65,101.43 59.79,100.29 66.93,100.29 v9(66.98,100.34)
  BOTTOM w0.254: UP1.C1 23.57,68.38 22.1,68.38 v6(21.82,68.66) ; UZ3.4 20.11,29.98 19.99,29.85 v9(19.61,29.85)
  BOTTOM w0.305: v9(37.06,4.85) 37.44,5.22 37.44,6.78 37.92,7.27 JKB1.1 ; v3(59.95,23.67) 59.95,22.53 59.36,21.94 JCCG1.7
  BOTTOM w0.508: v3(52.45,35.28) 52.6,35.28 55.34,38.02 55.34,38.82 55.98,39.45 ; v6(57.38,44.28) 56.42,43.33 56.42,41.1
  vias: v5(23.13,74.72) v5(23.15,74.19) v5(23.15,73.63) v5(23.64,74.19) v5(23.65,73.65) v5(28.29,99.94) v5(28.77,99.95) v5(29.24,100.42) v5(29.27,99.97) v5(29.66,100.23) v5(29.99,100.56) v6(23.17,75.41) v6(23.17,75.1) v6(23.46,75.41) v6(23.46,75.1) v6(23.82,75.41) v6(23.82,75.1) v6(28.55,100.29) v6(28.93,100.29) v6(29.24,100.79) v6(29.63,100.67) v7(28.51,100.3) v7(28.67,100.5) v7(28.86,100.3) v9(52.04,85.93) v9(52.04,85.36) v9(52.61,85.93) v9(52.61,85.36) v9(52.61,84.79) v9(53.18,85.93) v9(53.18,85.36) v9(53.18,84.79) v9(53.76,85.93) v9(53.76,85.36) v9(53.76,84.79) v9(54.33,85.93) v9(54.33,85.36) v16(80.74,104.73)
+5VALW_LDO: length 2.7
  BOTTOM w0.127: v1(53.72,82.6) PC617.2
  BOTTOM w0.203: PU601.6 54.38,81.03 54.09,81.32
  BOTTOM w0.508: PC617.2 54.09,81.32
+5VALW_VCONN1: length 9
  BOTTOM w0.127: v1(24.16,63.9) 24.81,64.55 RP141.2
  BOTTOM w0.508: v3(29.05,68.22) 28.65,68.62 28.36,68.62 28.36,68.62 27.96,68.62 27.95,68.62 27.52,68.62 27.15,68.25 27.15,68.22 27.07,68.14 RP137.2 26.83,67.4 26.32,66.9 CP21.1 25.73,67.23 25.4,67.23 25.22,67.05 25.22,66.51 24.81,66.1 RP141.2
  vias: v3(31.78,66.76)
+5VALW_VCONN2: length 42.6
  TOP w0.127: v1(42.98,73.34) 42.42,72.78 CP1.1
  TOP w0.508: CP1.1 41.32,72.28 CP2.1 39.09,72.28 39.01,72.36 v2(37.58,72.36)
  IN1 w0.508: v2(37.58,72.36) 37.47,72.47 36.42,72.47 35.16,71.22 v4(34.83,71.22)
  GND2 w0.508: v4(34.83,71.22) 34.83,70.91 v5(34.79,70.88)
  IN2 w0.508: v5(34.79,70.88) 34.8,70.88 34.8,71.89 33.82,72.88 33.82,74.16 v5(32.69,75.28)
  GND3 w0.457: v5(34.79,70.88) 34.79,70.64 v6(34.68,70.53)
  GND3 w0.508: v8(32.46,75.52) v5(32.69,75.28)
  IN3 w0.508: v8(32.46,75.52) 32.37,75.61 30.88,75.61 29.82,76.67 29.82,83.81 29.13,84.5 27.78,84.5 25.28,87 25.28,91.04 24.75,91.57 24.75,92.12 24.76,92.13 24.76,92.13 25.16,92.54 25.25,92.54 25.95,93.24 27.35,93.24 27.72,93.6 28.11,93.6 28.93,94.42 v3(28.93,94.87)
+5VALWP: length 13.1
  BOTTOM w0.203: PC621.1 52.47,89.03 51.91,88.47 51.51,88.47 50.75,87.71 50.75,84.08 v1(51.53,83.29) 52.31,82.52 52.31,80.73 52.51,80.53 PU601.5
+5VD: length 202.3
  TOP w0.254: UZ7.3 113.1,23.41 113.09,23.4
  TOP w0.508: RW1.1 100.94,17.1 100.95,17.09
  IN1 w0.508: v2(155.37,23.22) 155.17,23.42 155.17,26.76 153.95,27.99 151.2,27.99 150.48,28.71 v4(147.16,28.71)
  GND2 w0.508: v5(146.97,29.04) 146.97,28.9 v4(147.16,28.71)
  IN2 w0.254: v5(77.99,28.38) 76.96,29.41 72.85,29.41 70.28,26.84 60.2,26.84 55.02,32.02 55.02,33.72 53.42,35.32 53.42,43.71 54.66,44.94 54.66,51.28 50.77,55.17 50.77,61.3 52.15,62.69 52.15,63.39 55.77,67.01 55.77,70.17 56.97,71.36 v5(56.97,72.57)
  IN2 w0.508: v5(79.22,24.11) 86.37,24.11 88.15,25.89 89.09,25.89 91.15,27.95 94.91,27.95 v5(95.69,27.18) 96.28,26.58 103.36,26.58 103.78,26.16 107.55,26.16 v9(110.5,23.2)
  GND3 w0.254: v6(57.32,72.57) v5(56.97,72.57)
  GND3 w0.305: v5(77.99,28.38) v6(77.66,28.05)
  GND3 w0.508: v5(79.22,24.11) 79.22,24.28 78.98,24.52 v6(78.97,24.52) ; v6(95.69,26.83) v5(95.69,27.18) ; v5(146.97,29.04) 146.87,29.14 v8(146.87,29.41)
  IN3 w0.508: v3(77.61,24.54) 78.91,24.54 78.94,24.52 v6(78.97,24.52) ; v8(146.87,29.41) 143.11,29.41 141.7,30.82 141.7,31.27 140.92,32.06 140.92,33.46 139.21,35.16 137.16,35.16 136.37,34.37 136.37,30.96 134.46,29.06 128.2,29.06 127.61,28.47 127.61,26.5 125.51,24.4 125.51,22.62 126.27,21.86 126.27,21.31 125.01,20.05 116.19,20.05 114.48,21.76 v9(112.81,21.76)
  BOTTOM w0.254: U15.10 53.53,71.7 C3024.2 53.21,71.74 52.93,72.01 52.93,72.5 53.21,72.78 55.55,72.78 55.75,72.57 v6(57.32,72.57) ; v6(78.97,24.52) 78.94,24.52 78.86,24.44 78.86,23.6 79.09,23.37 UZ5.4
  BOTTOM w0.305: CZ29.1 78.35,27.33 UZ14.3
  BOTTOM w0.508: v3(77.61,24.54) 76.59,25.57 76.59,27.81 76.83,28.05 v6(77.66,28.05) 77.66,27.74 78.1,27.31 CZ29.1
  BOTTOM w1.143: 109.19,23.64 108.52,24.31 99.5,24.31
  vias: v5(110.22,7.59) v5(110.44,8.02) v5(110.73,7.55) v6(110.06,7.9) v7(111.16,7.9) v7(111.35,7.48) v7(111.47,7.78) v9(103.83,3.19) v9(104.23,2.79) v9(104.38,3.33) v9(104.52,3.88) v9(104.83,2.76) v9(104.96,3.33) v9(105.1,3.88) v9(105.55,3.33) v9(105.48,2.76) v9(105.69,3.88) v9(106.13,3.33) v9(106.08,2.76) v9(109.95,22.75) v9(110.5,22.62) v9(110.53,22.04) v9(111.1,23.21) v9(111.1,22.62) v9(111.1,22.04) v9(111.67,23.21) v9(111.67,22.62) v9(111.67,22.04) v9(112.24,23.21) v9(112.24,22.62) v9(112.24,22.04) v16(108.91,22.9)
+5VD_LDO: length 3.8
  BOTTOM w0.127: PC629.2 124.44,20.92 123.97,20.45 123.05,20.45 v1(122.53,20.97)
  BOTTOM w0.254: PU602.6 124.7,22.01 124.45,21.76 124.45,21.43 124.44,21.42 PC629.2
+5VDP: length 17.4
  IN3 w0.254: v3(113.45,26.82) 113.45,23.44 116.38,20.51 123.9,20.51 v3(124.94,21.55)
  BOTTOM w0.254: PU602.5 125.2,21.93 124.94,21.67 v3(124.94,21.55)
  vias: v1(116.94,20.97)
+5VS: length 240.5
  TOP w0.356: 51.28,54.63 R5847.1
  TOP w0.508: v2(74.14,15.23) 76.07,17.16 76.07,21.83 77.06,22.82 77.06,26.63 75.31,28.38 v16(74.27,28.38) 70.05,28.38 67.79,30.64 v2(67.79,32.28) ; v9(144.03,31.9) 144.03,30.6 143.42,29.99 141.66,29.99 140.18,28.5 140.18,26.24 139.35,25.42 138.12,25.42 137.08,26.46 137.08,28.25 RE3.1 RE8.1 ; v7(64.42,41.04) 64.41,41.04 PR1838.1 ; 59.53,77.81 60.12,78.39 62.38,78.39 62.91,77.86 62.91,75.19 63.92,74.19 67.73,74.19 68.74,73.17 71.89,73.17 v7(74.01,75.3) ; v2(51.29,25.1) 51.29,28.83 PR1802.1 ; 51.28,54.63 51.7,54.63 52.35,53.98 52.35,51.88 56.03,48.19 58.06,48.19 59.01,49.15 60.55,49.15 61.12,48.57 63.26,48.57 63.62,48.93 63.62,49.92 v7(63.39,50.15) 63,50.15 62.69,49.84 62.3,49.84 62.08,49.62 61.37,49.62 60.99,49.99 PR2251.1
  TOP w1.016: 89.38,28.91 94.71,28.91 96.81,31.01 96.81,32.98 98.02,34.18 98.33,34.18 98.84,34.69
  IN1 w0.508: v2(51.29,25.1) 51.33,25.1 52.15,24.28 54.21,24.28 54.98,23.51 63.65,23.51 68.6,18.56 70.81,18.56 v2(74.14,15.23) ; v2(67.79,32.28) 72.58,32.28 v9(73.54,33.24)
  GND2 w0.508: v7(63.39,50.15) v5(63.39,49.69) ; v5(73.94,74.95) 74.01,75.02 v7(74.01,75.3) ; v5(64.56,40.75) 64.42,40.89 v7(64.42,41.04)
  IN2 w0.508: 66.15,35.95 66.14,35.94 64.87,35.94 64.45,36.37 64.45,40.63 v5(64.56,40.75) 64.56,45.65 63.15,47.06 63.15,49.45 v5(63.39,49.69) 63.39,49.85 65.95,52.41 68.42,52.41 68.81,52.03 73.57,52.03 74.84,53.3 74.84,64.54 73.94,65.45 v5(73.94,74.95)
  IN3 w1.016: 101.17,35.71 101.17,34.91 101.78,34.31 103.4,34.31 103.92,33.79 103.92,30.56 105.55,28.94 111.72,28.94 112.69,29.9 134.12,29.9 135.53,31.31 135.53,34.72 136.81,36 139.56,36 141,34.56 142.59,34.56 143.39,33.77
  BOTTOM w0.254: v9(82.56,35.64) 82.47,35.55 PU2000.15 ; PU1901.15 73.86,35.54 v9(73.99,35.67) ; PU1900.15 v9(91.32,35.53)
  vias: v9(74.13,33.24) v9(82.14,33.25) v9(82.72,33.25) v9(87.4,28.43) v9(87.98,28.43) v9(88.57,28.43) v9(90.89,33.29) v9(91.47,33.29) v9(100.17,36.25) v9(100.17,35.63) v9(144.62,31.9)
+5VS_FAN: length 1.7
  BOTTOM w0.127: RE436.2 144.33,33.18 v1(144.68,33.53)
+VBATT: length 38.3
  IN3 w0.508: v3(136.97,6.69) 136.97,6.85 137.87,7.75 145.06,7.75 145.46,7.35 147.06,7.35 148.41,8.69 153.79,8.69 154.63,7.85 158.82,7.85 159.17,7.51 159.17,6.98 159.84,6.31 162.66,6.31 164.49,8.13 v3(164.49,10.84)
  BOTTOM w0.254: v3(136.97,6.69) 136.08,7.58 PC133.1 PC534.1 PR230.1
  BOTTOM w0.508: PR553.2 164.46,11.76 164.59,11.64 PD501.2
  vias: v9(138.9,1.55)
+VBUS1_DC_SS: length 29.5
  TOP w0.127: v1(29.5,91.08) 29.63,91.2 v7(30.39,91.2)
  IN1 w0.508: v4(24.14,85.72) 25.68,85.72 30.39,90.43 v7(30.39,91.2)
  GND2 w0.508: v4(24.14,85.72) v5(23.77,86.09)
  IN2 w0.508: v5(23.77,86.09) 24.28,85.58 24.28,81.09 23.42,80.24 22.4,79.21 22.4,71.17 21.03,69.79 v5(21.03,69.12)
  GND3 w0.508: v6(20.9,68.66) 20.9,68.99 v5(21.03,69.12)
+VBUS2_DC_SS: length 15.7
  GND2 w0.508: v7(35.53,105.01) v5(35.18,105.01)
  IN2 w0.508: v5(26.58,97.43) 27.44,98.28 27.44,99.88 28.54,100.98 29.37,100.98 30.63,102.24 30.63,103.03 31.55,103.95 33.23,103.95 34.29,105.01 v5(35.18,105.01)
  GND3 w0.508: v6(25.5,97.36) 25.5,97.37 26.52,97.37 v5(26.58,97.43)
  BOTTOM w0.127: v1(26.51,94.7) 25.88,95.33 25.69,95.33
  vias: v3(21.94,93.94) v3(21.94,93.49) v3(22.39,93.94) v3(22.39,93.49) v3(22.83,93.94) v3(22.83,93.49) v3(23.78,96.73) v3(23.78,96.28) v3(24.23,96.73) v3(24.23,96.28) v3(24.67,96.73) v3(24.67,96.28)
+VCC0V9_CIO: length 7.3
  TOP w0.203: CT82.1 39.15,82.57
  GND2 w0.203: v5(38.71,82.91) 38.95,83.15 v7(39.15,83.15) 39.15,83.13 v5(39.46,82.82) ; v7(39.15,81.22) 39.13,81.22 v5(38.81,81.54) ; v7(39.15,81.86) v5(38.81,82.2)
  GND3 w0.203: 39.14,81.87 39.13,81.87 v5(38.81,81.54) 39.13,81.22 v6(39.15,81.22) ; 39.14,81.87 v6(39.15,81.87) ; 39.14,81.87 v5(38.81,82.2) 39.12,82.52 v6(39.15,82.52) v5(39.46,82.82) 39.15,83.13 v6(39.15,83.17) 38.96,83.17 v5(38.71,82.91)
  BOTTOM w0.203: v6(39.15,83.17) v6(39.15,82.52) v6(39.15,81.87) v6(39.15,81.22)
+VCC0V9_DP: length 11.7
  TOP w0.127: CT54.1 v1(42.2,81.18)
  GND2 w0.203: v5(37.59,81.21) 37.58,81.22 v7(37.19,81.22) ; v7(39.8,81.87) 39.82,81.87 v5(40.13,82.17) 40.43,81.87 v7(40.46,81.87)
  GND2 w0.254: v7(37.86,83.81) v5(37.59,84.08) 37.59,84.13 v7(37.86,84.4) ; v7(37.21,83.81) 37.21,83.78 37.49,83.5 v5(37.51,83.5) 37.84,83.17 v7(37.86,83.17) 37.52,82.84 v5(37.51,82.84)
  GND3 w0.203: v5(37.59,81.21) 37.58,81.22 v6(37.2,81.22) ; v6(40.45,81.87) 40.44,81.87 v5(40.13,82.17) 39.82,81.87 v6(39.8,81.87)
  GND3 w0.254: v6(37.2,83.17) 37.2,83.18 v5(37.51,83.5) ; v6(37.85,83.17) 37.84,83.17 v5(37.51,82.84) ; v6(37.85,83.82) 37.85,83.82 v5(37.59,84.08) 37.47,84.08 v6(37.2,83.82)
  BOTTOM w0.203: v6(39.8,81.87) v6(40.45,81.87) UT2.V12 ; v6(39.8,81.87) 39.8,81.89 ; v6(39.8,81.87) UT2.T12 UT2.V12 ; UT2.V12 UT2.V13 ; v6(37.2,81.22) UT2.L11
+VCC0V9_PCIE: length 9
  GND2 w0.203: v7(37.21,77.97) 37.21,77.96 v5(37.46,77.7) ; v7(37.86,80.56) v5(37.54,80.24) 37.86,79.93 v7(37.86,79.91) 37.82,79.91 v5(37.51,79.61) v7(37.86,79.27)
  GND3 w0.203: v6(37.85,80.57) 37.85,80.56 v5(37.54,80.24) 37.85,79.93 v6(37.85,79.92) 37.82,79.92 v5(37.51,79.61) 37.85,79.27 v6(37.85,79.27) ; v6(37.2,77.97) v5(37.46,77.7)
  BOTTOM w0.203: UT2.N19 UT2.N18 UT2.M18 ; v6(37.85,80.57) v6(37.85,79.92) v6(37.85,79.27) UT2.M18 ; UT2.M18 UT2.L18 v6(37.2,77.97)
+VCC0V9_USB: length 2.3
  GND2 w0.203: v5(39.44,79) 39.42,79 v6(39.15,79.27) ; v7(39.15,79.91) 39.11,79.91 v5(38.83,79.63)
  GND3 w0.203: v5(39.44,79) 39.18,79.27 v6(39.15,79.27) ; v6(39.15,79.92) 39.11,79.92 v5(38.83,79.63)
  BOTTOM w0.203: v6(39.15,79.92) v6(39.15,79.27)
+VCC_CORE: length 121
  GND2 w0.203: v4(118.37,47.72) v5(118.37,47.24) ; v4(118.37,48.86) v5(118.37,48.38) ; v4(118.37,46.58) v5(118.37,46.09) ; v4(119.96,47.72) v5(119.96,47.24) ; v4(119.96,48.86) v5(119.96,48.38) ; v4(119.96,46.58) v5(119.96,46.09)
  GND2 w0.254: v4(123.73,48.13) v5(124.25,48.13) ; v7(121.97,62.57) v5(122.19,62.17) v7(122.18,61.68) ; v5(133.36,47.2) v7(133.58,46.95) ; v4(122.16,48.13) v5(121.71,48.13) ; v7(119.02,74.5) v5(119.4,74.5) ; v5(132.22,47.2) v7(132.43,46.95) ; v7(118.16,62.57) v5(118.25,62.17) v7(117.93,61.68) ; v5(120.48,51.26) v7(120.15,51.26) ; v5(131.2,47.2) v7(131.42,46.95) ; v7(118.65,67.9) v5(118.27,67.9) ; v7(122.34,65.11) v5(122.01,65.11) ; v14(122.95,48.92) v5(123.29,48.92) ; v7(119.8,67.9) v5(119.47,67.9) ; v5(132.53,48.98) v7(132.75,48.72) ; v7(119.8,66.5) v5(119.47,66.5) ; v4(123.73,48.92) v5(124.28,48.92) ; v7(118.78,51.52) v5(119.03,51.26) ; v7(118.72,50.06) 119.03,50.37 v5(119.03,50.48) ; v4(132.19,49.99) v5(132.42,50.23) ; v7(120.98,60.97) v5(120.61,60.87) ; v7(117.9,60.89) v5(118.25,60.87) ; v7(118.67,64.93) v5(119.04,64.82) ; v7(124.61,61.22) v5(124.55,60.87) ; v4(122.16,48.92) v5(121.69,48.92) ; v5(120.08,72.63) v7(120.32,72.4) ; v7(123.12,61.68) v5(122.98,62.17) v7(122.96,62.57) ; v5(132.85,46.18) v7(133.07,45.93) ; v7(120.37,70.41) 120.37,70.42 v5(120.13,70.65) ; v7(119.81,65.18) v5(119.83,64.82) ; v7(122.34,66.5) v5(122.01,66.5) ; v7(118.16,63.81) v5(118.25,63.47) ; v7(118.65,66.5) v5(118.27,66.5) ; v7(120.85,61.63) v5(120.61,62.17) ; v5(120.48,49.69) v7(120.15,49.69) ; v5(119.03,49.69) v7(119.36,49.69) ; v7(118.03,75.52) v5(118.41,75.52) ; v5(118.48,71.69) v7(118.72,71.46) ; v7(118.03,74.5) v5(118.41,74.5) ; v7(114.35,75.52) v5(114.68,75.52) ; v7(115.34,74.5) v5(115.72,74.5) ; v7(115.34,75.52) v5(115.72,75.52) ; v5(119.29,70.62) v7(119.53,70.39) ; v5(120.11,71.72) v7(120.34,71.48) ; v5(119.27,71.69) v7(119.5,71.46) ; v5(123.26,47.78) 123.26,47.81 v4(122.95,48.13) ; v5(120.48,50.48) v7(120.15,50.48) ; v7(119.15,63.81) v5(119.04,63.47) ; v5(118.51,70.62) v7(118.74,70.39) ; v7(119.02,75.52) v5(119.4,75.52) ; v5(118.46,72.6) v7(118.69,72.37) ; v5(119.24,72.6) v7(119.48,72.37)
  GND3 w0.254: v5(119.27,71.69) v8(119.04,71.92) ; v5(114.68,75.52) v8(115.01,75.52) ; v5(120.48,51.26) 120.13,51.26 v14(120.1,51.29) ; v5(118.46,72.6) v8(118.22,72.84) ; v5(118.48,71.69) v8(118.25,71.92) ; v5(119.47,66.5) v8(119.14,66.5) ; v5(123.29,48.92) v14(122.95,48.92) ; v5(119.4,75.52) v15(119.78,75.52) ; v5(119.96,46.09) v6(119.48,46.09) ; v5(118.51,70.62) v8(118.27,70.86) ; v5(119.96,47.24) v6(119.48,47.24) ; v5(118.27,67.9) v15(117.89,67.9) ; v14(120.1,49.69) v5(120.48,49.69) ; v5(118.37,48.38) v6(117.89,48.38) ; v5(118.41,75.52) v15(118.79,75.52) ; v14(119.45,49.69) v5(119.03,49.69) ; v5(115.72,74.5) v15(116.1,74.5) ; v5(119.96,48.38) v6(119.48,48.38) ; v14(120.1,50.48) v5(120.48,50.48) ; v5(118.27,66.5) v15(117.89,66.5) ; v5(120.08,72.63) v8(119.85,72.86) ; v5(118.37,46.09) v6(117.89,46.09) ; v5(119.03,51.26) 119.06,51.29 v14(119.45,51.29) ; v5(119.4,74.5) v15(119.78,74.5) ; v5(122.01,66.5) v8(121.68,66.5) ; v5(119.47,67.9) v8(119.14,67.9) ; v5(115.72,75.52) v15(116.1,75.52) ; v5(119.29,70.62) v8(119.06,70.86) ; v5(118.41,74.5) v15(118.79,74.5) ; v5(120.13,70.65) v8(119.9,70.88) ; v5(120.11,71.72) v8(119.87,71.95) ; v5(118.37,47.24) v6(117.89,47.24) ; v14(119.45,50.48) v5(119.03,50.48) ; v5(122.01,65.11) v8(121.68,65.11) ; v5(119.24,72.6) v8(119.01,72.84)
  IN3 w0.254: v14(122.72,58.59) v8(122.98,58.6) ; v14(119.57,61.2) v8(119.83,61.2) ; v14(125.09,61.2) v8(125.34,61.2) ; v14(118,61.2) v8(118.25,61.2) ; v14(125.87,57.29) v8(126.13,57.3) ; v14(121.94,63.15) v8(122.19,63.14) ; v14(124.3,64.5) v8(124.55,64.49) ; v14(120.36,62.5) v8(120.61,62.5) ; v14(119.57,57.94) v8(119.83,57.94) ; v14(123.51,61.2) v8(123.76,61.2) ; v14(119.57,64.5) v8(119.83,64.49) ; v14(125.09,59.24) v8(125.34,59.24) ; v14(120.36,57.94) v8(120.61,57.94) ; v14(123.51,63.8) v8(123.76,63.8) ; v14(121.15,57.29) v8(121.4,57.3) ; v14(124.3,58.59) v8(124.55,58.6) ; v14(122.72,59.24) v8(122.98,59.24) ; v14(121.15,59.89) v8(121.4,59.9) ; v14(122.72,62.5) v8(122.98,62.5) ; v14(118.79,63.15) v8(119.04,63.14) ; v14(119.57,57.29) v8(119.83,57.3) ; v14(119.57,60.55) v8(119.83,60.54) ; v14(121.15,56.64) v8(121.4,56.64) ; v14(125.87,60.55) v8(126.13,60.54) ; v14(126.66,57.94) v8(126.91,57.94) ; v14(125.09,61.85) v8(125.34,61.84) ; v14(125.09,63.8) v8(125.34,63.8) ; v14(120.36,58.59) v8(120.61,58.6) ; v14(122.72,60.55) v8(122.98,60.54) ; v14(123.51,59.89) v8(123.76,59.9) ; v14(117.21,63.8) v8(117.47,63.8) ; v14(121.94,61.2) v8(122.19,61.2) ; v14(119.57,65.15) v8(119.83,65.15) ; v14(118,63.8) v8(118.25,63.8) ; v14(119.57,58.59) v8(119.83,58.6) ; v14(120.36,60.55) v8(120.61,60.54) ; v14(123.51,58.59) v8(123.76,58.6) ; v14(123.51,60.55) v8(123.76,60.54) ; v14(122.72,59.89) v8(122.98,59.9) ; v14(125.87,59.89) v8(126.13,59.9) ; v14(117.21,62.5) v8(117.47,62.5) ; v14(117.21,57.29) v8(117.47,57.3) ; v14(121.15,59.24) v8(121.4,59.24) ; v14(123.51,64.5) v8(123.76,64.49) ; v14(118.79,57.29) v8(119.04,57.3) ; v14(123.51,57.94) v8(123.76,57.94) ; v14(124.3,62.5) v8(124.55,62.5) ; v14(123.51,59.24) v8(123.76,59.24) ; v14(121.15,63.8) v8(121.4,63.8) ; v14(119.57,62.5) v8(119.83,62.5) ; v14(118.79,58.59) v8(119.04,58.6) ; v14(125.87,61.2) v8(126.13,61.2) ; v14(117.21,60.55) v8(117.47,60.54) ; v14(117.21,61.85) v8(117.47,61.84) ; v14(121.15,58.59) v8(121.4,58.6) ; v14(118,57.94) v8(118.25,57.94) ; v14(125.09,63.15) v8(125.34,63.14) ; v14(118.79,65.15) v8(119.04,65.15) ; v14(124.3,65.15) v8(124.55,65.15) ; v14(124.3,57.94) v8(124.55,57.94) ; v14(120.36,63.8) v8(120.61,63.8) ; v14(125.09,59.89) v8(125.34,59.9) ; v14(123.51,56.64) v8(123.76,56.64) ; v14(125.09,60.55) v8(125.34,60.54) ; v14(118,62.5) v8(118.25,62.5) ; v14(122.72,57.94) v8(122.98,57.94) ; v14(125.87,59.24) v8(126.13,59.24) ; v14(117.21,63.15) v8(117.47,63.14) ; v14(121.15,63.15) v8(121.4,63.14) ; v14(122.72,61.2) v8(122.98,61.2) ; v14(124.3,61.85) v8(124.55,61.84) ; v14(121.94,62.5) v8(122.19,62.5) ; v14(118,60.55) v8(118.25,60.54) ; v14(124.3,57.29) v8(124.55,57.3) ; v14(118,59.24) v8(118.25,59.24) ; v14(117.21,56.64) v8(117.47,56.64) ; v14(120.36,61.85) v8(120.61,61.84) ; v14(121.94,60.55) v8(122.19,60.54) ; v14(123.51,63.15) v8(123.76,63.14) ; v14(118.79,61.2) v8(119.04,61.2) ; v14(122.72,61.85) v8(122.98,61.84) ; v14(118.79,59.89) v8(119.04,59.9) ; v14(125.87,58.59) v8(126.13,58.6) ; v14(122.72,63.8) v8(122.98,63.8) ; v14(121.15,57.94) v8(121.4,57.94) ; v14(118,59.89) v8(118.25,59.9) ; v14(118.79,60.55) v8(119.04,60.54) ; v14(118.79,64.5) v8(119.04,64.49) ; v14(120.36,59.89) v8(120.61,59.9) ; v14(119.57,63.15) v8(119.83,63.14) ; v14(124.3,63.15) v8(124.55,63.14) ; v14(121.94,63.8) v8(122.19,63.8) ; v14(122.72,63.15) v8(122.98,63.14) ; v14(126.66,58.59) v8(126.91,58.6) ; v14(124.3,56.64) v8(124.55,56.64) ; v14(118,58.59) v8(118.25,58.6) ; v14(124.3,63.8) v8(124.55,63.8) ; v14(119.57,63.8) v8(119.83,63.8) ; v14(125.09,62.5) v8(125.34,62.5) ; v14(118,63.15) v8(118.25,63.14) ; v14(121.94,58.59) v8(122.19,58.6) ; v14(118,61.85) v8(118.25,61.84) ; v14(121.15,61.2) v8(121.4,61.2) ; v14(117.21,57.94) v8(117.47,57.94) ; v14(119.57,61.85) v8(119.83,61.84) ; v14(121.15,60.55) v8(121.4,60.54) ; v14(121.94,57.94) v8(122.19,57.94) ; v14(121.94,61.85) v8(122.19,61.84) ; v14(124.3,61.2) v8(124.55,61.2) ; v14(121.91,57.29) v8(122.16,57.3) ; v14(123.51,57.29) v8(123.76,57.3) ; v14(125.09,57.94) v8(125.34,57.94) ; v14(118.79,63.8) v8(119.04,63.8) ; v14(118.79,57.94) v8(119.04,57.94) ; v14(125.87,56.64) v8(126.13,56.64) ; v14(118.79,59.24) v8(119.04,59.24) ; v14(119.57,56.64) v8(119.83,56.64) ; v14(117.21,61.2) v8(117.47,61.2) ; v14(118.79,56.64) v8(119.04,56.64) ; v14(120.36,61.2) v8(120.61,61.2) ; v14(120.36,59.24) v8(120.61,59.24) ; v14(125.09,58.59) v8(125.34,58.6) ; v14(121.91,56.64) v8(122.16,56.64) ; v14(117.21,58.59) v8(117.47,58.6) ; v14(123.51,65.15) v8(123.76,65.15) ; v14(124.3,60.55) v8(124.55,60.54) ; v14(125.87,57.94) v8(126.13,57.94) ; v14(120.36,63.15) v8(120.61,63.14)
  BOTTOM w0.127: v14(118.79,65.15) 119.05,64.89 ; v14(118.79,65.15) 118.78,65.15 118.51,65.42 ; v14(118.79,65.15) 119.06,65.42 ; v14(118.79,65.15) 118.49,64.85 ; UC1.CM34 122.2,64.77 ; UC1.CM34 122.2,64.24 ; UC1.CM34 121.93,64.5 121.66,64.77 ; UC1.CM34 121.64,64.2 ; 118.83,77.67 UC1.CH14 ; UC1.CH14 119.12,77.96 118.84,78.24 ; UC1.CH14 119.39,78.23 ; UC1.CH14 119.38,77.7 ; 118.84,78.89 119.12,78.61 UC1.CH13 ; 117.91,78.32 UC1.CF13 ; UC1.CF13 118.2,78.61 117.93,78.89 ; UC1.CF13 118.47,78.35 ; UC1.CF13 118.48,78.88 ; UC1.CL33 121.41,64.89 ; UC1.CL33 121.42,65.42 ; UC1.CL33 120.85,64.85 ; UC1.CL33 121.15,65.15 120.87,65.42 ; v14(119.57,64.5) 119.84,64.24 ; v14(119.57,64.5) 119.84,64.77 ; v14(119.57,64.5) 119.28,64.2 ; v14(119.57,64.5) 119.57,64.5 119.29,64.77 ; 116.92,63.5 v14(117.21,63.8) ; v14(117.21,63.8) 117.48,64.07 ; v14(117.21,63.8) 117.47,63.53 ; v14(117.21,63.8) 117.21,63.8 116.93,64.07 ; 123.22,63.5 v14(123.51,63.8) ; v14(123.51,63.8) 123.51,63.8 123.23,64.07 ; v14(123.51,63.8) 123.77,63.53 ; v14(123.51,63.8) 123.78,64.07 ; v14(120.36,63.8) 120.36,63.8 120.08,64.07 ; v14(120.36,63.8) 120.62,63.53 ; v14(120.36,63.8) 120.63,64.07 ; v14(120.36,63.8) 120.07,63.5 ; 120.67,78.89 120.95,78.61 UC1.CL13 120.66,78.32 ; v14(121.15,63.8) 121.15,63.8 120.87,64.07 ; v14(121.15,63.8) 121.42,64.07 ; v14(121.15,63.8) 121.41,63.53 ; v14(121.15,63.8) 120.85,63.5 ; v14(124.3,63.8) 124.57,64.07 ; v14(124.3,63.8) 124.3,63.8 124.02,64.07 ; v14(124.3,63.8) 124.56,63.53 ; v14(124.3,63.8) 124,63.5 ; UC1.CB14 115.73,78.23 ; UC1.CB14 115.46,77.96 115.19,78.24 ; UC1.CB14 115.17,77.67 ; UC1.CB14 115.73,77.7 ; UC1.CH13 119.39,78.88 ; UC1.CH13 118.83,78.32 ; UC1.CH13 119.38,78.35 ; v14(118,63.8) 118,63.8 117.72,64.07 ; v14(118,63.8) 118.26,63.53 ; v14(118,63.8) 117.71,63.5 ; v14(118,63.8) 118.27,64.07 ; v14(119.57,63.8) 119.84,64.07 ; v14(119.57,63.8) 119.57,63.8 119.29,64.07 ; v14(119.57,63.8) 119.28,63.5 ; v14(119.57,63.8) 119.84,63.53 ; v14(124.3,64.5) 124.3,64.5 124.02,64.77 ; v14(124.3,64.5) 124.56,64.24 ; v14(124.3,64.5) 124,64.2 ; UC1.CD13 116.38,78.61 116.1,78.89 ; UC1.CD13 116.65,78.88 ; UC1.CD13 116.09,78.32 ; UC1.CD13 116.64,78.35 ; 123.23,65.42 123.51,65.15 v14(123.51,65.15) ; UC1.CA14 114.55,77.96 114.27,78.24 ; UC1.CA14 114.82,78.23 ; UC1.CA14 114.81,77.7 ; UC1.CA14 114.26,77.67 ; UC1.BW13 113.63,78.61 113.36,78.89 ; UC1.BW13 113.9,78.35 ; UC1.BW13 113.34,78.32 ; UC1.BW13 113.91,78.88 ; 118.51,64.77 118.78,64.5 v14(118.79,64.5) ; v14(122.72,63.8) 122.72,63.8 122.44,64.07 ; v14(122.72,63.8) 122.99,64.07 ; v14(122.72,63.8) 122.43,63.5 ; v14(122.72,63.8) 122.99,63.53 ; UC1.CJ13 120.03,78.61 119.76,78.89 ; UC1.CJ13 120.31,78.88 ; UC1.CJ13 120.3,78.35 ; UC1.CJ13 119.74,78.32 ; 124.81,64.07 125.08,63.8 v14(125.09,63.8) 124.79,63.5 ; 120.87,64.77 121.15,64.5 UC1.CL34 ; v14(123.51,64.5) 123.77,64.24 ; v14(123.51,64.5) 123.22,64.2 ; v14(123.51,64.5) 123.51,64.5 123.23,64.77 ; v14(123.51,64.5) 123.78,64.77 ; v14(123.51,65.15) 123.22,64.85 ; v14(123.51,65.15) 123.78,65.42 ; v14(123.51,65.15) 123.77,64.89 ; 115.17,78.32 UC1.CB13 ; UC1.CB13 115.73,78.35 ; UC1.CB13 115.73,78.88 ; UC1.CB13 115.46,78.61 115.19,78.89 ; v14(118.79,63.8) 119.06,64.07 ; v14(118.79,63.8) 118.78,63.8 118.51,64.07 ; v14(118.79,63.8) 119.05,63.53 ; v14(118.79,63.8) 118.49,63.5 ; UC1.CE34 116.92,64.2 ; UC1.CE34 117.48,64.77 ; UC1.CE34 117.47,64.24 ; v14(121.94,63.8) 121.93,63.8 121.66,64.07 ; v14(121.94,63.8) 121.64,63.5 ; v14(121.94,63.8) 122.2,63.53 ; v14(121.94,63.8) 122.2,64.07 ; 117.93,78.24 118.2,77.96 UC1.CF14 ; v14(118.79,64.5) 119.05,64.24 ; v14(118.79,64.5) 119.06,64.77 ; v14(118.79,64.5) 118.49,64.2 ; UC1.CF14 118.47,77.7 ; UC1.CF14 118.48,78.23 ; UC1.CF14 117.91,77.67 ; v14(119.57,65.15) 119.57,65.15 119.29,65.42 ; v14(119.57,65.15) 119.84,64.89 ; v14(119.57,65.15) 119.28,64.85 ; v14(119.57,65.15) 119.84,65.42 ; 124.02,65.42 124.3,65.15 v14(124.3,65.15) 124,64.85 ; UC1.CA13 114.82,78.88 ; UC1.CA13 114.55,78.61 114.27,78.89 ; UC1.CA13 114.81,78.35 ; UC1.CA13 114.26,78.32 ; UC1.CL34 120.85,64.2 ; UC1.CL34 121.42,64.77 ; UC1.CL34 121.41,64.24
  vias: v2(119.06,60.92) v2(119.15,62.57) v2(119.12,61.68) v2(121.97,63.71) v2(122.18,60.92) v2(122.96,63.71) v2(123.12,60.92) v2(124.9,62.19) v5(117.47,63.47) v5(117.47,62.17) v5(117.47,60.87) v5(117.47,58.27) v5(117.47,56.97) v5(118.25,59.57) v5(118.25,58.27) v5(119.04,60.87) v5(119.04,59.57) v5(119.04,58.27) v5(119.04,56.97) v5(119.83,63.47) v5(119.83,62.17) v5(119.83,60.87) v5(119.83,58.27) v5(119.83,56.97) v5(120.61,63.47) v5(120.61,59.57) v5(120.61,58.27) v5(121.4,63.47) v5(121.4,60.87) v5(121.4,59.57) v5(121.4,58.27) v5(121.4,56.97) v5(122.19,63.47) v5(122.19,60.87) v5(122.19,58.27) v5(122.16,56.97) v5(122.98,63.47) v5(122.98,60.87) v5(122.98,59.57) v5(122.98,58.27) v5(123.76,64.82) v5(123.76,63.47) v5(123.76,60.87) v5(123.76,59.57) v5(123.76,58.27) v5(123.76,56.97) v5(124.55,64.82) v5(124.55,63.47) v5(124.55,62.17) v5(124.55,58.27) v5(124.55,56.97) v5(125.34,60.87) v5(125.34,59.57) v5(125.34,58.27) v5(126.13,60.87) v5(126.13,59.57) v5(126.13,58.27) v5(126.13,56.97) v5(126.92,58.27) v7(124.9,62.82) v9(114.09,78.28) v9(114.09,77.63) v9(115.01,78.28) v9(115.01,77.63) v9(115.92,78.28) v9(115.92,77.63) v9(116.43,50.91) v9(116.43,49.23) v9(116.43,48.53) v9(116.84,78.28) v9(116.84,77.63) v9(117.2,49.23) v9(117.2,48.53) v9(117.38,55.85) v9(117.38,55.01) v9(117.38,53.9) v9(117.38,53.07) v9(117.38,52.23) v9(118.22,55.85) v9(118.22,55.01) v9(118.22,53.9) v9(118.22,53.07) v9(118.22,52.38) v9(118.67,78.28) v9(118.67,77.63) v9(119.06,55.85) v9(119.06,55.01) v9(119.06,53.9) v9(119.06,53.07) v9(119.06,52.38) v9(119.58,77.63) v9(119.9,55.85) v9(119.9,55.01) v9(119.9,53.9) v9(119.9,53.07) v9(119.9,52.38) v9(120.74,55.85) v9(120.74,55.01) v9(120.74,53.9) v9(120.74,53.07) v9(120.74,52.23) v9(121.57,55.85) v9(121.57,55.01) v9(121.57,53.9) v9(121.57,53.07) v9(121.57,52.23) v9(121.57,51.39) v9(121.57,50.55) v9(121.57,49.71) v9(122.41,55.85) v9(122.41,55.01) v9(122.41,53.9) v9(122.41,53.07) v9(122.41,52.23) v9(122.41,51.39) v9(122.41,50.55) v9(122.41,49.71) v9(123.25,55.85) v9(123.25,55.01) v9(123.25,53.9) v9(123.25,53.07) v9(123.25,52.23) v9(123.25,51.39) v9(123.25,50.55) v9(123.25,49.71) v9(123.88,49.71) v9(124.09,55.85) v9(124.09,55.01) v9(124.09,53.9) v9(124.09,53.07) v9(124.09,52.36) v9(124.93,55.85) v9(124.93,55.01) v9(124.93,53.9) v9(124.93,53.07) v9(124.93,52.36) v9(125.76,55.85) v9(125.76,55.01) v9(125.76,53.9) v9(125.76,53.07) v9(125.76,52.36) v9(126.6,53.9) v9(126.6,53.07) v9(126.6,52.36) v16(133.58,49.68)
