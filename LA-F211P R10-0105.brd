# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V0.9_VR_EN: length 24.3
  TOP w0.254: v7(64.1,45.67) 67.65,45.67 68,46.02 PR2309.1 ; v7(66.83,31.25) 66.83,29.72 68.16,28.39
  GND2 w0.254: v5(66.64,31.6) 66.83,31.41 v7(66.83,31.25) ; v7(64.1,45.67) v5(63.58,45.67)
  IN2 w0.254: v5(63.58,45.67) 63.58,45.37 64.11,44.84 64.11,40.95 63.99,40.84 63.99,33.66 66.05,31.6 v5(66.64,31.6)
  vias: v1(68.55,28.66)
VBUS1_ECOK: length 151.5
  TOP w0.127: v2(40.74,74.38) 39.6,74.38 38.88,75.1 31.25,75.1 PR119.2 ; v1(44.04,3.32) 43.8,3.56 v7(43.8,3.98) 43.8,3.98 43.74,4.04 43.74,4.86 44.42,5.55 44.42,6.46 44.52,6.56 44.52,7.5 44.36,7.66 44.36,8.2 UE3.M6
  IN1 w0.064: v4(23.55,14.53) 23.55,14.69 27.26,18.4 28.06,18.4 31.38,21.72 31.38,26.28 29.29,28.37 29.29,31.97 28.74,32.52 26.1,32.52 24.04,34.58 24.04,36.21 23.66,36.59 23.66,41.19 23.29,41.56 23.29,44.26 24,44.97 24,54.02 29.34,59.36 31.16,59.36 31.96,60.16 33.02,60.16 33.68,60.82 36.47,60.82 37.12,61.47 38.02,61.47 39.26,62.71 39.26,68.01 39.43,68.18 39.43,70.77 40.35,71.69 40.35,74.05 40.68,74.38 v2(40.74,74.38) 40.74,80.32 42.12,81.71 42.12,89.44 41.6,89.96 41.6,90.53 v4(41.98,90.91)
  GND2 w0.102: v5(33.78,99.09) 33.5,98.81 v7(33.37,98.81) ; v4(41.98,90.91) 41.94,90.87 v5(41.6,90.87) ; v4(23.55,14.53) 23.69,14.4 v5(23.69,14.11) ; v5(43.47,4.02) 43.51,3.98 43.8,3.98 v7(43.8,3.98)
  GND3 w0.102: v5(43.47,4.02) 43.41,4.02 43.13,4.3 v8(43.13,4.38) ; v5(41.6,90.87) 41.56,90.87 v8(41.25,91.19) ; v8(23.69,13.7) v5(23.69,14.11) ; v8(34.13,99.09) v5(33.78,99.09)
  IN3 w0.064: v8(34.13,99.09) 34.13,99.07 34.57,98.63 34.57,98.05 35.95,96.67 36.86,96.67 40.66,92.87 40.66,92.61 41.38,91.89 41.38,91.32 v8(41.25,91.19) ; v8(23.69,13.7) 23.85,13.7 25.86,11.69 25.86,11.69 29.61,7.94 32.43,7.94 33.98,6.39 38.53,6.39 40.7,4.22 42.97,4.22 v8(43.13,4.38)
VBUS2_ECOK: length 136.4
  TOP w0.127: PR143.2 30.37,100.91 30.9,101.43 30.9,102.44 30.74,102.6 v7(28.99,102.6) ; v7(42.2,6.12) 42.35,6.27 UE3.N3
  GND2 w0.102: v5(28.6,102.53) 28.93,102.53 v7(28.99,102.6) ; v7(42.2,6.12) v5(42.5,6.42)
  IN2 w0.074: v5(26.51,24.14) 26.51,25.99 18.11,34.39 18.11,38.62 16.32,40.41 16.32,46.77 15.7,47.4 15.7,49.21 15.38,49.54 14.61,49.54 11.26,52.89 11.26,68.32 13.05,70.11 16.11,70.11 18.89,72.89 18.89,78.08 17.83,79.13 17.83,88.43 20.02,90.62 20.02,94.79 22.67,97.44 24.83,97.44 26.18,98.8 26.18,100.39 28.32,102.53 v5(28.6,102.53)
  GND3 w0.102: v5(26.51,24.14) 26.51,23.76 v8(26.7,23.58) ; v5(42.5,6.42) v8(42.11,6.42) ; v5(28.6,102.53) 28.55,102.58 v6(28.2,102.58)
  IN3 w0.064: v8(42.11,6.42) 41.36,7.16 40.33,7.16 39.32,8.17 36.5,8.17 35.82,8.84 33.41,8.84 32.93,9.31 31.4,9.31 30.41,10.3 30.41,12.29 28.1,14.61 28.1,15.03 26.81,16.32 26.81,17.27 25.83,18.24 25.83,18.65 26.01,18.83 26.01,22.26 26.7,22.95 v8(26.7,23.58)
  BOTTOM w0.127: v6(28.2,102.58) 28.03,102.76 28.03,104.02 28.85,104.84 PR165.1
VBUS3_ECOK: length 196.9
  TOP w0.127: v7(76.35,26.12) v1(76.35,25.36) 76.35,22.66 75.67,21.99 75.67,17.53 73.71,15.56 73.71,13.92 71.28,11.49 v7(71.28,11.32) 71.16,11.2 71.16,7.85 v2(70.28,6.97) ; v2(52.32,14.68) 52.21,14.57 52.21,13.47 51.57,12.83 51.12,12.83 50.56,13.39 UE3.F13
  IN1 w0.064: v2(52.32,14.68) 52.53,14.46 53.76,14.46 54.76,13.47 55.01,13.47 56.58,11.9 59.72,11.9 62.06,9.56 64.85,9.56 65.45,8.97 67.86,8.97 69.85,6.97 v2(70.28,6.97)
  GND2 w0.102: v5(71.54,10.81) 71.54,11.07 v7(71.28,11.32) ; v7(42.66,102.46) v5(42.66,102.02) ; v7(76.35,26.12) v5(76.35,26.65)
  IN2 w0.074: v5(76.35,26.65) 76.3,26.7 73.79,26.7 72.3,25.21 59.52,25.21 58.6,26.13 55.96,26.13 55.42,26.67 55.42,26.93 54.5,27.85 54.5,31.26 52.78,32.98 52.78,43.94 54.07,45.22 54.07,51 50.18,54.89 50.18,61.61 51.61,63.05 51.61,63.61 55.21,67.21 55.21,70.36 56.29,71.44 56.29,74.19 54.7,75.77 53.51,75.77 51.84,77.44 51.84,83.12 50.78,84.19 50.78,88.44 48.6,90.62 46.65,90.62 46.38,90.89 43.26,90.89 41.5,92.65 v5(41.5,93.02)
  GND3 w0.102: v8(41.75,92.68) 41.75,92.77 v5(41.5,93.02) ; v8(71.54,10.12) v5(71.54,10.81) ; v5(42.66,102.02) v8(42.66,101.61)
  IN3 w0.064: v8(71.54,10.12) 71.54,10.12 73.71,10.12 74.56,9.26 77.98,9.26 78.44,9.73 79.75,9.73 80.14,9.33 87.09,9.33 87.37,9.06 94.02,9.06 94.57,9.61 98.21,9.61 v3(99.35,10.75) ; v8(42.66,101.61) 42.66,98.88 41.27,97.5 41.27,93.16 v8(41.75,92.68)
  BOTTOM w0.102: 100.55,11.41 102.58,11.41 103.06,11.9 JIO1.J12
  BOTTOM w0.127: v3(99.35,10.75) 100.01,11.41 100.55,11.41
VBUS4_ECOK: length 204.5
  GND2 w0.102: v7(50.35,15.79) 50.09,15.79 v5(50.03,15.73) ; v7(36.08,97.73) 35.73,97.73 v5(35.66,97.81)
  IN2 w0.074: v5(35.66,97.81) 35.66,97.81 35.3,97.45 34.29,97.45 33.92,97.83 32.46,97.83 31.6,96.97 31.6,96.23 31.1,95.73 26.91,95.73 26.36,95.18 23.61,95.18 22.34,93.9 22.34,89.72 20.1,87.48 20.1,85.09 20.88,84.31 21.96,84.31 23.03,83.24 23.03,81.61 21.15,79.73 21.15,71.94 19.28,70.07 19.28,64.35 16.66,61.73 16.08,61.73 15.21,60.86 15.21,59.95 16.81,58.35 21.71,58.35 23.92,56.14 23.92,55 24.36,54.56 24.36,50.99 24.84,50.51 24.84,43.59 25.69,42.74 25.69,42.37 25.37,42.05 25.16,42.05 24.7,41.59 24.7,38.13 27.5,35.33 29.81,35.33 32.03,33.11 32.03,28.01 34.01,26.03 35.3,26.03 36.06,25.27 v5(36.32,25.27)
  GND3 w0.102: v5(36.32,25.27) 36.13,25.46 v8(35.76,25.46) ; v8(49.68,15.79) 49.96,15.79 v5(50.03,15.73)
  IN3 w0.064: v3(82.59,3.23) 81.85,3.97 78.36,3.97 77.81,4.52 75.74,4.52 75.15,5.1 74.56,5.1 74.12,4.66 61.58,4.66 60.01,6.23 57,6.23 55.52,7.71 54.57,7.71 50.26,12.02 50.26,14.94 49.68,15.52 v8(49.68,15.79) 49.56,15.91 48.7,15.91 48.28,16.33 48.16,16.33 46.69,17.8 38.19,17.8 36.13,19.86 36.13,25.08 v8(35.76,25.46) ; v3(84.93,5.26) 85.09,5.26 85.67,4.68 90.89,4.68 91.78,3.79 93.24,3.79 94.46,5.01 102.59,5.01 102.84,5.26 103.28,5.26 103.57,5.55 104.48,5.55 105.44,6.51 105.44,6.93 107.23,8.72 108.69,8.72 109,8.4 v6(111.56,8.4)
  BOTTOM w0.127: v6(111.56,8.4) 111.56,10.4 JIO1.K3 ; v3(84.93,5.26) 84.93,4.78 v1(84.27,4.11) 83.38,3.23 v3(82.59,3.23)
VBUS_C_CTRL_P1: length 231.2
  TOP w0.254: PR275.1 48.19,105.23 v2(48.5,105.53) 48.36,105.67 PU102.4
  IN1 w0.064: v9(41.15,103.13) 41.27,103.24 42.6,103.24 43.68,102.16 47.61,102.16 48.49,101.29 49.55,101.29 49.86,101.6 49.86,105.52 v2(50.43,106.09) 50.22,106.29 49.26,106.29 v2(48.5,105.53) ; v4(79.88,15.93) 80.27,15.93 80.72,15.49 84.19,15.49 84.71,14.97 90.1,14.97 91.82,13.25 97.58,13.25 98.1,13.78 101.93,13.78 102.73,14.58 105.2,14.58 105.4,14.78 105.79,14.78 106.13,14.44 110.21,14.44 111.01,15.24 111.17,15.24 111.47,14.94 112.1,14.94 112.62,14.42 112.62,12.21 v4(112.05,11.64)
  GND2 w0.102: v4(79.88,15.93) v5(79.88,16.36) ; v5(112.39,11.82) 112.22,11.64 v4(112.05,11.64)
  IN2 w0.074: v9(41.15,103.13) 40.13,104.15 36.92,104.15 35.69,105.38 32.34,105.38 30.26,103.3 30.26,102.39 29.22,101.35 28.39,101.35 27.07,100.03 27.07,98.43 25.2,96.56 23.04,96.56 20.94,94.46 20.94,90.27 18.72,88.05 18.72,79.49 19.77,78.44 19.77,72.51 17.63,70.37 17.63,66.67 15.68,64.71 15.68,63.62 13.64,61.58 13.64,58.36 16.25,55.75 18.44,55.75 19.22,54.97 19.22,51.92 23.07,48.07 23.07,43.79 22.39,43.11 22.39,42.89 22.58,42.7 22.58,36.67 22.28,36.38 22.28,33.02 24.47,30.84 26.37,30.84 29.7,27.51 30.83,27.51 33.58,24.77 34.57,24.77 35.34,24 35.34,22.31 38.22,19.43 52.08,19.43 52.26,19.25 55.35,19.25 56.23,18.37 61.55,18.37 63.57,20.39 72.68,20.39 75.35,17.72 78.53,17.72 v5(79.88,16.36)
  GND3 w0.102: v5(112.39,11.82) 112.31,11.9 v6(112.06,11.9)
  BOTTOM w0.254: PD107.3 40.76,103.53 v9(41.15,103.13) 41.15,101.78 40.61,101.24 PR189.2
VBUS_C_CTRL_P1#: length 85.4
  TOP w0.127: PR267.1 43.68,106.22 v2(43.71,106.19) ; PR186.1 36.94,100.44 36.71,100.67 v7(36.31,100.67) 35.92,100.67 35.16,101.42 35.16,102.17 35.37,102.38 36.48,102.38 36.8,102.7 36.8,103.9 37.76,104.86 v2(38.56,104.86) ; v2(18.98,71.48) 18.57,71.08 PR120.1
  IN1 w0.064: v2(18.98,71.48) 19.1,71.35 22.84,71.35 24.47,72.98 24.47,73.48 25.41,74.42 26.34,74.42 26.68,74.76 26.68,77.67 27.34,78.33 v4(29,78.33) ; v2(43.71,106.19) 43.5,106.41 40.38,106.41 38.84,104.86 v2(38.56,104.86)
  GND2 w0.102: v7(36.31,100.67) 36.31,100.39 v5(36.41,100.29) ; v4(29,78.33) v5(29.51,78.33)
  IN2 w0.074: v5(40.36,90.79) 39.36,90.79 39.11,91.04 32.71,91.04 32.19,91.56 31.73,91.56 31.25,91.08 29.38,91.08 27.99,89.68 27.99,87.87 28.7,87.15 28.7,79.43 29.51,78.62 v5(29.51,78.33) 29.51,78.04 30.19,77.36 30.19,73.1 28.94,71.85 28.94,70.09 v5(28.87,70.02)
  GND3 w0.102: v8(36.27,99.9) 36.41,100.04 v5(36.41,100.29) ; v5(28.87,70.02) 28.76,69.91 v6(28.76,69.7) ; v8(40.94,90.79) v5(40.36,90.79)
  IN3 w0.064: v8(36.27,99.9) 36.36,99.82 36.36,97.39 40.8,92.95 40.8,92.67 41.52,91.95 41.52,91.09 41.22,90.79 v8(40.94,90.79)
  BOTTOM w0.076: 30.07,69.42 30.13,69.42 30.49,69.78 31.93,69.78 UPD1.K4
  BOTTOM w0.127: 30.07,69.42 29.11,69.42 28.93,69.61 28.93,69.61 28.84,69.7 v6(28.76,69.7) 28.03,70.44 RP92.2 v1(26.96,70.5)
VBUS_C_CTRL_P2: length 224.8
  TOP w0.127: v7(81.45,17.54) 81.76,17.23 81.76,11.26 v1(82.43,10.59) 82.84,10.18 82.84,7.9 82.19,7.26 82.19,4.03 82.82,3.4 v2(82.82,3.03)
  TOP w0.254: v7(40,103.54) 39.1,102.64 PU2301.4
  IN1 w0.064: v4(101.75,5.03) 98.76,5.03 98.37,4.64 95.66,4.64 94.05,3.03 91.91,3.03 91.8,3.14 89.26,3.14 89.17,3.23 87.19,3.23 87.08,3.13 85.01,3.13 84.84,2.95 82.9,2.95 v2(82.82,3.03) ; v7(40,103.54) 42.5,103.54 43.74,102.3 47.67,102.3 48.54,101.43 49.49,101.43 49.72,101.66 49.72,102.49 v2(49.39,102.83)
  IN1 w0.254: v2(43.27,101.68) 41.86,101.68 v7(40,103.54)
  GND2 w0.102: v5(102.15,4.9) 101.88,4.9 v4(101.75,5.03) ; v7(81.45,17.54) 80.95,17.03 v5(80.95,16.9)
  GND2 w0.254: v7(40,103.54) v5(40,103.07)
  IN2 w0.074: v5(40,103.07) 38.52,101.58 v5(37.33,101.58) 36.5,101.58 35.49,102.59 32.44,102.59 31.26,101.41 31.26,98.73 29.34,96.81 26.46,96.81 25.91,96.26 23.16,96.26 21.24,94.34 21.24,90.15 19.02,87.93 19.02,79.62 20.07,78.57 20.07,72.38 17.93,70.24 17.93,66.54 15.98,64.59 15.98,63.49 13.95,61.46 13.95,59.1 16.16,56.89 17.98,56.89 20.42,54.46 20.42,53.5 22.86,51.06 22.86,50.45 23.37,49.94 23.37,42.51 22.88,42.01 22.88,36.55 22.58,36.25 22.58,33.15 24.59,31.14 27.36,31.14 27.53,30.97 28.7,30.97 29.36,31.63 30.22,31.63 31.13,30.71 31.13,27.64 33.7,25.07 34.76,25.07 37.48,22.35 37.48,20.59 38.34,19.73 52.21,19.73 52.38,19.55 55.47,19.55 56.36,18.67 61.43,18.67 63.45,20.69 72.8,20.69 75.27,18.22 79.62,18.22 v5(80.95,16.9)
  GND3 w0.102: v5(37.33,101.58) 37.33,101.48 37.22,101.36 v6(37.22,101.24) ; v5(102.15,4.9) v6(103.06,4.9)
  BOTTOM w0.254: v6(37.22,101.24) 37.22,101.64 37.35,101.77 37.35,103.29 37.12,103.53 PD109.3
VBUS_C_CTRL_P2#: length 65.9
  TOP w0.127: PR258.1 v2(39.48,97.44)
  TOP w0.254: v2(41.51,101.22) RP93.2
  IN1 w0.064: v4(33.36,105.2) 33.36,105.23 34.03,105.9 36.7,105.9 38.98,103.61 39.3,103.61 41.51,101.4 v2(41.51,101.22) 41.51,100.02 39.48,97.99 v2(39.48,97.44) 39.48,97.41 39.56,97.33 39.56,95.67 38.52,94.63 31.28,94.63 31.02,94.38 v4(31.02,92.72)
  GND2 w0.102: v4(33.36,105.2) 33.23,105.07 v5(33.23,104.83) ; v5(30.59,92.5) 30.81,92.72 v4(31.02,92.72)
  IN2 w0.074: v5(32.46,66.4) 31.58,66.4 31.43,66.25 29.89,66.25 27.8,68.35 27.8,68.66 27.44,69.01 27.44,71.52 27.73,71.81 27.73,72.09 27.47,72.36 27.3,72.36 26.66,73 26.66,73.48 26.66,73.49 26.66,77.54 27.49,78.38 27.49,86.56 26.78,87.28 26.78,90.19 29.08,92.5 v5(30.59,92.5)
  GND3 w0.102: v6(32.68,66.03) 32.68,66.18 v5(32.46,66.4) ; v6(32.93,104.53) v5(33.23,104.83)
VBUS_C_CTRL_P3: length 25.1
  TOP w0.127: v7(39.77,98.67) 39.78,98.67 PU2302.4 PR272.1 ; v2(49.36,101.76) 49.36,100.74 v1(49.5,100.6)
  IN1 w0.064: v2(49.36,101.76) 48.46,101.76 47.77,102.44 47.55,102.44 44.68,105.31 42.76,105.31 42.2,105.87 41.34,105.87 v4(40.99,105.53)
  GND2 w0.102: v7(39.77,98.67) 39.76,98.68 v5(39.76,99.17) ; v5(40.66,105.53) v4(40.99,105.53)
  GND3 w0.102: v5(39.76,99.17) 39.76,99.55 v8(39.79,99.57) ; v5(40.66,105.53) v6(40.66,105.87)
  IN3 w0.064: v8(39.79,99.57) 39.79,100.07 40.66,100.95 v6(40.66,105.87)
  BOTTOM w0.254: v6(40.66,105.87) 40.41,106.13 PD106.3 PD108.3
VBUS_C_CTRL_P3#: length 209.3
  TOP w0.127: PR271.1 38.45,97.84 v2(38.8,98.19) ; PR209.1 39.65,105.82 39.65,103.71 v2(39.2,103.27)
  IN1 w0.064: v2(38.8,98.19) 38.8,98.36 39.17,98.72 39.17,101.45 v4(39.33,101.61) 39.37,101.64 39.37,102.63 39.2,102.8 v2(39.2,103.27) ; v4(113.1,14.63) 113.1,15.11 112.61,15.6 110.86,15.6 109.98,14.72 106.48,14.72 105.9,15.3 102.3,15.3 101.05,14.06 97.99,14.06 97.46,13.53 91.94,13.53 90.08,15.39 84.9,15.39 84.49,15.79 82.08,15.79 v4(81.45,16.41)
  GND2 w0.102: v5(39.38,101.24) 39.38,101.55 v4(39.33,101.61) ; v4(81.45,16.41) v5(81.45,16.9) ; v4(113.1,14.63) 113.36,14.38 v5(113.36,14.25)
  IN2 w0.074: v5(39.38,101.24) 36.63,101.24 35.45,102.41 32.48,102.41 31.41,101.34 31.41,98.67 29.4,96.66 26.52,96.66 25.97,96.11 23.23,96.11 21.4,94.28 21.4,90.09 19.17,87.87 19.17,79.68 20.22,78.63 20.22,72.32 18.15,70.25 18.15,66.34 16.28,64.46 16.28,63.24 14.25,61.21 14.25,59.23 16.28,57.19 18.28,57.19 20.35,55.13 21.47,55.13 23.19,53.41 23.19,50.54 23.67,50.06 23.67,42.37 23.3,41.99 23.3,41.38 23.92,40.76 23.92,36.8 23.57,36.44 23.57,34.84 26.43,31.98 30.07,31.98 31.28,30.78 31.28,27.7 33.76,25.22 34.86,25.22 37.63,22.45 37.63,20.65 38.4,19.88 52.27,19.88 52.45,19.7 55.54,19.7 56.42,18.82 61.37,18.82 63.39,20.84 72.87,20.84 75.31,18.4 79.96,18.4 v5(81.45,16.9)
  GND3 w0.102: v5(113.36,14.25) 112.82,14.25 v6(112.74,14.33)
  BOTTOM w0.102: JIO1.G2 v6(112.74,14.33)
VBUS_C_CTRL_P4: length 18.1
  TOP w0.127: v2(48.13,102.76) v1(48.13,101.68)
  TOP w0.254: PU2303.4 47.9,102.99 v2(48.13,102.76)
  IN1 w0.254: v4(40.24,105.8) 40.56,106.11 42.3,106.11 42.86,105.54 44.78,105.54 47.56,102.76 v2(48.13,102.76) 49.32,103.96 v2(49.32,104.04)
  GND2 w0.254: v5(39.98,105.53) v4(40.24,105.8)
  GND3 w0.254: v6(39.98,104.83) 39.98,104.83 v5(39.98,105.53)
  BOTTOM w0.254: v6(39.98,104.83) PD108.2
VBUS_C_CTRL_P4#: length 208.2
  IN1 w0.064: v4(80.36,16.39) 81.1,15.65 84.22,15.65 84.77,15.11 90.16,15.11 91.88,13.39 97.52,13.39 98.05,13.92 101.11,13.92 102.35,15.16 105.64,15.16 106.22,14.58 110.12,14.58 110.94,15.4 111.5,15.4 111.67,15.24 v4(111.71,15.24)
  GND2 w0.102: v5(112.06,15.24) v4(111.71,15.24) ; v5(43.38,103.04) 43.56,102.86 v7(43.75,102.86) ; v4(80.36,16.39) v5(80.36,16.9)
  IN2 w0.074: v5(80.36,16.9) 79.37,17.89 75.39,17.89 72.74,20.54 63.51,20.54 61.49,18.52 56.29,18.52 55.41,19.4 52.32,19.4 52.14,19.58 38.28,19.58 35.49,22.37 35.49,24.09 34.66,24.92 33.64,24.92 30.98,27.58 30.98,30.59 30.75,30.82 27.47,30.82 27.29,30.99 24.53,30.99 22.43,33.09 22.43,36.32 22.73,36.61 22.73,42.07 23.22,42.57 23.22,48.33 21.48,50.07 21.48,52.08 20.24,53.32 20.24,54.39 17.91,56.72 16.08,56.72 13.79,59.01 13.79,61.52 15.83,63.55 15.83,64.65 17.78,66.6 17.78,70.31 19.92,72.44 19.92,78.51 18.87,79.56 18.87,87.99 21.09,90.21 21.09,94.4 23.1,96.41 25.79,96.41 26.39,97.01 29.33,97.01 31.11,98.79 31.11,101.47 32.38,102.74 33.57,102.74 v5(34.7,103.87) 35.17,103.4 39.72,103.4 39.98,103.65 40.11,103.65 41.01,102.75 43.09,102.75 v5(43.38,103.04)
  GND3 w0.102: v5(34.7,103.87) 34.72,103.88 v8(34.72,104.2) ; v6(112.06,15.9) v5(112.06,15.24)
  IN3 w0.064: v3(34.72,100.48) v8(34.72,104.2)
VCC0V9_LVR_OUT: length 7
  GND2 w0.203: v7(36.56,81.87) 36.7,81.87 v5(36.9,81.67)
  GND2 w0.305: v7(35.25,78.62) 35.25,78.64 35.48,78.87 v5(35.61,78.87) 35.86,78.62 v7(35.9,78.62)
  IN2 w0.381: v5(35.61,78.87) 36.31,78.87 36.7,79.27 36.7,81.46 v5(36.9,81.67)
  GND3 w0.203: v6(36.55,81.87) 36.7,81.87 v5(36.9,81.67)
  GND3 w0.254: v5(35.61,78.87) 35.64,78.87 v6(35.9,78.62)
  GND3 w0.305: v5(35.61,78.87) 35.35,78.62 v6(35.25,78.62)
  BOTTOM w0.203: UT2.H11 v6(36.55,81.87)
  vias: v1(33.6,79.5)
VCC0V9_SVR: length 13.3
  GND2 w0.203: v7(37.21,82.51) 37.26,82.51 v5(37.54,82.23) 37.82,82.51 v7(37.84,82.51) ; v7(36.62,83.14) 36.62,83.09 36.82,82.89 v5(36.82,82.78)
  GND2 w0.254: v7(35.25,80.56) 35.24,80.56 v5(34.92,80.24) ; v7(34.6,80.56) 34.6,80.59 v5(34.92,80.9) ; v5(35.51,80.96) 35.26,81.2 v7(35.26,81.22) ; v7(35.26,81.86) 35.16,81.86 v5(34.9,81.59) 34.6,81.3 v7(34.6,81.22)
  GND3 w0.203: v6(37.2,82.52) 37.25,82.52 v5(37.54,82.23) 37.83,82.52 v6(37.85,82.52) ; v5(36.82,82.78) v6(36.55,82.52)
  GND3 w0.254: v6(35.25,81.22) 35.25,81.21 v5(35.51,80.96) ; v6(34.6,81.22) 34.6,81.3 v5(34.9,81.59) ; v6(35.25,80.57) 35.25,80.58 v5(34.92,80.9) ; v6(34.6,80.57) v5(34.92,80.24)
  BOTTOM w0.127: CT79.1 v1(29.01,87.35)
  BOTTOM w0.203: v6(35.25,80.57) v6(34.6,80.57) v6(34.6,81.22) v6(35.25,81.22) ; v6(35.25,80.57) v6(35.25,81.22) ; v6(35.25,80.57) UT2.F15 ; v6(35.25,81.22) UT2.F11 ; v6(37.85,82.52) v6(37.2,82.52) v6(36.55,82.52)
  vias: v5(29.18,89.43) v5(29.55,89.73) v5(29.51,88.86) v5(29.99,89.57) v5(29.99,89.1) v6(29,90.19) v6(29,89.82) v6(29,89.07) v6(29,88.7) v6(29.52,89.24)
VCC_3V3_PCIE: length 0.9
  GND2 w0.203: v7(37.19,79.27) 37.36,79.1 v5(37.36,78.9)
  GND3 w0.203: v6(37.2,79.27) 37.2,79.26 37.36,79.1 v5(37.36,78.9)
VCC_3V3_USB2: length 1.5
  GND2 w0.305: v7(36,79.34) 35.71,79.63 v5(35.66,79.63)
  GND3 w0.203: v8(36.06,79.61) 35.68,79.61 v5(35.66,79.63)
  IN3 w0.203: v8(36.06,79.61) 36.21,79.61 v3(36.55,79.27)
VCC_SENSE: length 30.9
  TOP w0.127: PR1137.2 143.11,33.21 143.11,32.87 143.44,32.54 145.21,32.54 v9(145.34,32.42)
  IN3 w0.064: v14(130.32,52.49) 130.53,52.28 130.53,51.45 132.11,49.87 132.94,49.87 136.69,46.12 137.51,46.12 137.64,46.25 138.06,46.25 138.15,46.15 138.15,45.04 139.27,43.92 139.27,40.54 144.81,34.99 144.81,32.94 v9(145.34,32.42)
VCCDSW_EN: length 85.7
  TOP w0.127: v7(44.34,3.56) 44.1,3.8 44.1,4.1 43.94,4.26 43.94,4.78 44.62,5.47 44.62,6.37 44.73,6.47 44.73,7.22 45.21,7.7 45.21,8.29 45.51,8.59 UE3.M7 ; U736.3 16.92,26.77 R2741.1 16.94,26.6 16.53,26.19 14.4,26.19 13.61,25.41 13.61,23.58 14.35,22.84 14.35,19.63 v1(13.61,18.89) 10.83,16.11 8.3,16.11 6.88,17.53 v9(6.55,17.53)
  GND2 w0.102: v7(44.34,3.56) v5(44.34,3.23)
  GND3 w0.102: v5(44.34,3.23) 44.1,3.23 v8(44.02,3.16)
  IN3 w0.064: v3(42.26,3.15) 44.02,3.15 v8(44.02,3.16)
  BOTTOM w0.127: v9(6.55,17.53) 5.58,16.56 5.58,16.26 4.25,14.93 4.25,13.57 3.44,12.77 2.34,12.77 1.9,12.32 1.9,8.55 2.7,7.74 3.84,7.74 4.62,6.96 9.11,6.96 9.77,6.3 12.88,6.3 14.6,4.59 17.12,4.59 20.46,1.25 40.36,1.25 v3(42.26,3.15)
VCCGT_B+:
  vias: v1(151.36,53.3) v9(145.89,55.28) v9(146.48,65.06) v9(150.21,55.84) v9(150.29,50.69) v9(150.29,50.08) v9(150.78,65.55) v9(150.87,56.52) v9(151.15,54.58) v9(151.15,53.98) v9(151.2,64.75) v9(151.23,63.71) v9(151.25,51.64) v9(151.25,50.91) v9(151.25,50.08) v9(151.61,66.12) v9(151.76,64.75) v9(151.76,63.96) v9(151.76,63.1) v9(151.74,55.2) v9(151.74,54.58) v9(151.74,53.98) v9(151.89,51.98) v9(151.89,51.14) v9(151.89,50.3)
VCCGT_SENSE: length 28.5
  TOP w0.127: v9(148.3,34.94) 148.17,35.07 147.62,35.07 PR1145.2
  IN3 w0.064: v14(132.32,52.49) 132.66,52.15 132.66,51.73 133.58,50.81 133.58,50.13 136.53,47.18 138.2,47.18 138.79,46.59 138.79,45.36 141.32,42.83 144.41,42.83 144.9,42.34 144.9,37.77 147.63,35.05 148.2,35.05 v9(148.3,34.94)
VCCIO_PG: length 2.4
  TOP w0.127: v1(99.35,22.88) 99.79,22.88 100.61,23.69 RE296.2 PR1002.2
VCCIO_SENSE: length 32.5
  TOP w0.127: PR1006.2 108.81,30.04 107.61,30.04 v1(105.8,31.85) v7(105.09,31.85)
  IN1 w0.064: v14(108.55,56.64) 108.55,53.16 108.12,52.73 108.12,42.4 105.34,39.62 105.34,36.36 105.04,36.05 105.04,34.19 105.09,34.14 v7(105.09,31.85)
  GND2 w0.102: v5(108.78,56.41) v14(108.55,56.64)
  GND3 w0.102: v14(108.55,56.64) v5(108.78,56.41)
VCCSA_B+:
  vias: v1(107.54,33.74) v9(107.92,39.05) v9(107.97,34.68) v9(108.58,34.8)
VCCSA_SENSE: length 45.4
  GND2 w0.102: v5(148.76,38.92) 148.61,38.92 v8(148.38,38.69)
  GND3 w0.102: v8(148.38,38.69) 148.61,38.92 v5(148.76,38.92)
  IN3 w0.064: v8(148.38,38.69) 148.7,39.01 148.7,39.89 144.73,43.86 141.79,43.86 139.74,45.9 139.74,47.73 139.14,48.34 136.72,48.34 134.59,50.46 134.59,52.27 133.18,53.68 130.21,53.68 129.29,54.6 116.78,54.6 115.19,53.01 115.19,52.63 115.14,52.58 v3(114.91,52.58)
VCCST_PWRGD_CPU: length 8.3
  BOTTOM w0.127: UC1.H40 80.52,60.22 81.23,60.22 81.43,60.03 81.43,54.84 81.51,54.77 RH52.2 81.4,54.46 v1(80.55,53.61)
VDD: length 36.6
  TOP w0.127: v1(170.91,1.54) 170.1,2.36 v7(169.8,2.36)
  TOP w0.203: PC529.2 162.1,3.02 PR509.1 ; PC529.2 162.29,3.83 PU501.18 ; PC529.2 161.57,4.17 160.17,4.17 159.89,3.89 159.89,2.55 160.14,2.29 160.96,2.29 161.98,1.27 169.24,1.27 169.8,1.82 v7(169.8,2.36)
  TOP w0.254: PR507.2 159.47,12.02 160.17,12.02 160.73,11.46 v7(160.91,11.46)
  GND2 w0.254: v7(160.91,11.46) 161.18,11.46 v5(161.26,11.54) ; v7(169.8,2.36) v5(169.8,2.69)
  IN2 w0.254: v5(161.26,11.54) 161.68,11.96 164.14,11.96 169.8,6.31 v5(169.8,2.69)
VDD12_FB_H: length 74.9
  TOP w0.127: v7(53.98,29.55) 54.24,29.29 54.24,29.06 54.53,28.77 PR1870.1
  IN1 w0.064: v4(76.17,68.66) 78.91,65.92 78.91,64.98 78.61,64.67 78.61,62.64 80.41,60.84 81.63,60.84 83.12,59.35 83.12,58.95 84.14,57.92 84.14,56.8 82.65,55.3 79.46,55.3 78.56,54.4 70.6,54.4 70.42,54.58 64.25,54.58 61.36,51.69 v4(61.36,51.06)
  GND2 w0.102: v4(76.17,68.66) v5(76.17,69.02) ; v5(53.49,29.56) 53.5,29.55 v7(53.98,29.55) ; v4(61.36,51.06) 61.19,51.06 v5(60.98,50.86)
  IN2 w0.074: v5(60.98,50.86) 60.5,50.37 60.5,43.87 60.17,43.54 v5(60.17,42.75)
  GND3 w0.102: v5(76.17,69.02) 76.17,68.97 v6(75.92,68.72) ; v5(60.17,42.75) 60.17,42.27 v6(60.09,42.2) ; v6(53.38,29.93) 53.49,29.82 v5(53.49,29.56)
  BOTTOM w0.127: PR1865.2 73.12,69.12 74.24,69.12 75.03,68.33 75.54,68.33 v6(75.92,68.72) ; v6(53.38,29.93) 52.59,30.72 52.59,31.94 53.56,32.91 56.44,32.91 58.52,34.99 58.52,37.84 60.09,39.42 v1(60.09,41.42) v6(60.09,42.2)
VDD12_LG: length 4.8
  TOP w0.635: 59.18,54.79 v1(60.42,54.79) 61.19,54.79 61.64,55.25 61.64,56.2 62.14,56.69 PQ2200.6
VDD12_LX: length 6.2
  TOP w0.254: PU2200.7 57.54,55.04
  IN1 w0.762: 58.14,56.47 58.14,57.23 59.92,59.01 59.92,59.52 61.03,60.64 61.24,60.64
  vias: v1(63.92,59.26) v2(57.74,55.37) v2(57.77,55.67) v2(58.05,55.67) v2(58.07,55.34) v9(62.84,59.92) v9(62.84,58.98) v9(62.91,60.92) v9(62.86,57.97) v9(63.09,57.41) v9(63.17,60.38) v9(63.17,59.47) v9(63.17,58.48) v9(63.32,61.35) v9(63.62,60.86) v9(64.13,61.22) v9(64.28,60.61) v9(64.87,60.53) v9(66.04,58.07) v9(66.39,57.61) v9(66.65,58.12)
VDD12_UG: length 9
  IN1 w0.762: 56.71,56.06 56.71,59.72 58.77,61.78 58.77,64.22
  vias: v1(57.63,63.77) v2(56.71,55.33) v2(56.71,55) v2(56.69,54.67) v2(56.66,54.34) v2(58.71,64.37) v2(58.71,64.04) v2(59.01,64.37) v2(59.01,64.04)
VDD12_UG_R: length 3
  TOP w0.508: PQ2200.1 62.14,63.75 v1(61.97,63.92) 61.69,64.19 PR2201.2
VDD18_PWR_OK: length 60.5
  TOP w0.127: v7(59.22,24.7) 59.58,24.34 RH572.2 ; RH572.2 60,24.81 v1(60.49,25.29) ; RH572.2 60,23.81 60.06,23.75 UC9.4 60.06,22.23 60.17,22.12 60.99,22.12 61.26,22.39 UZ22.1 62.19,22.39 62.35,22.22 R5827.1
  GND2 w0.102: v5(58.95,24.88) 59.13,24.7 v7(59.22,24.7)
  IN2 w0.074: v5(58.95,24.88) 58.93,24.88 58.12,25.69 55.76,25.69 54.97,26.47 54.97,26.74 52.18,29.53 52.18,34.42 52.08,34.52 52.08,44.23 52.55,44.69 52.55,51.81 49.68,54.68 49.68,62.11 50.86,63.29 50.86,64.25 53.31,66.71 v5(53.31,67.44)
  GND3 w0.102: v6(52.9,67.39) 52.96,67.44 v5(53.31,67.44)
  BOTTOM w0.127: v6(52.9,67.39) 52.9,67.93 53.15,68.17 R1323.1
VDDC_FB_H: length 45.6
  TOP w0.127: PR1840.1 51.27,47.45 54.41,47.45 55.26,46.61 59.39,46.61 60.11,47.33 v1(60.3,47.33) v2(60.74,47.33)
  IN1 w0.064: v2(60.74,47.33) 60.74,49.05 62.26,50.57 62.26,51.59 64.55,53.87 70.01,53.87 70.19,53.69 78.85,53.69 79.73,54.57 85.98,54.57 86.69,53.85 v4(87.45,53.85)
  GND2 w0.102: v4(87.45,53.85) v5(87.45,54.18)
  GND3 w0.102: v5(87.45,54.18) 87.59,54.18 v6(87.79,54.39)
  BOTTOM w0.127: UC1.Y46 88.08,55.3 87.79,55.01 v6(87.79,54.39)
VDDC_FB_L: length 66.9
  TOP w0.127: PR1842.1 50.76,47.9 v1(53.82,47.9) 54.26,47.9 55.34,46.81 59.06,46.81 60.14,47.89 v2(60.3,47.89)
  IN1 w0.064: v4(86.97,55.07) 84.59,55.07 84.47,55.18 ; 84.47,55.18 84.47,57.86 83.45,58.88 83.45,59.51 81.76,61.19 80.52,61.19 78.94,62.78 78.94,64.54 79.24,64.84 79.24,66.1 v4(75.92,69.42) ; 84.47,55.18 84.24,54.95 79.6,54.95 78.7,54.04 70.39,54.04 70.21,54.22 64.4,54.22 61.91,51.73 61.91,50.72 60.3,49.1 v2(60.3,47.89)
  GND2 w0.102: v4(86.97,55.07) v5(86.97,54.74) ; v4(75.92,69.42) v5(75.59,69.42)
  GND3 w0.102: v6(75.59,69.09) v5(75.59,69.42) ; v6(86.97,54.39) v5(86.97,54.74)
  BOTTOM w0.127: UC1.Y45 87.99,57.29 87.68,56.98 87.68,55.91 86.97,55.2 v6(86.97,54.39) ; v6(75.59,69.09) 75.27,68.78 UC1.A28
VDDCI_EN:
  vias: v1(69.35,47.75)
VDDCI_FB_H: length 20.9
  TOP w0.203: PR2316.2 67.81,54.06 73.12,54.06 75.28,56.22 v1(79.54,56.22) 85.75,56.22 86.05,56.51 86.05,56.96 v6(85.72,57.29)
  GND2 w0.254: v5(85.38,57.37) v6(85.72,57.29)
  GND3 w0.254: v6(85.72,57.29) v5(85.38,57.37)
VDDCI_FB_L: length 22.2
  TOP w0.203: PR2315.2 65.78,54 66.19,54.41 72.98,54.41 75.21,56.64 v1(77.44,56.64) v6(85.72,56.64)
  GND2 w0.254: v5(85.38,56.57) v6(85.72,56.64)
  GND3 w0.254: v6(85.72,56.64) v5(85.38,56.57)
VDDCI_VIN: length 5
  TOP w0.127: PL2204.2 v1(62.76,51.01)
  TOP w0.254: PL2204.2 64.15,50.17 PC3262.1 65.04,49.28 PU4255.1
VDDCIP_LX: length 3.3
  GND2 w0.254: v7(68.48,50.05) 68.32,50.21 v5(68.14,50.21) ; v5(68.08,49.69) 68.4,49.69 v7(68.47,49.62) ; v5(67.65,49.26) 67.67,49.28 v7(68.18,49.28) ; v7(68.18,48.78) v5(67.76,48.78)
  GND3 w0.254: v5(68.08,49.69) v6(67.71,49.69) ; v5(67.76,48.78) v6(67.37,48.78) ; v6(67.25,49.34) 67.56,49.34 v5(67.65,49.26) ; v5(68.14,50.21) v6(68.14,50.57)
  vias: v1(66.84,49.36) v9(68.93,50.47) v9(68.93,49.88) v9(68.93,49.3)
VSS_SENSE: length 30.9
  TOP w0.127: PR1140.2 143.48,33.22 143.48,33.04 143.59,32.92 145.51,32.92 145.59,32.85 v9(145.79,32.85)
  IN3 w0.064: v9(145.79,32.85) 145.35,32.85 145.13,33.07 145.13,35.13 139.59,40.67 139.59,44.06 138.47,45.17 138.47,46.28 138.19,46.56 137.51,46.56 137.38,46.44 136.82,46.44 133.07,50.19 132.24,50.19 130.84,51.59 130.84,52.22 131.12,52.49 v14(131.46,52.49)
VSSGT_SENSE: length 28.5
  TOP w0.127: v9(148.3,35.52) 148.23,35.45 147.56,35.45 PR1147.2
  IN3 w0.064: v14(133.47,52.49) 133.29,52.67 133.1,52.67 132.97,52.54 132.97,51.86 133.89,50.95 133.89,50.26 136.66,47.5 138.34,47.5 139.11,46.73 139.11,45.49 141.45,43.15 144.54,43.15 145.22,42.47 145.22,37.9 147.76,35.36 148.15,35.36 v9(148.3,35.52)
VSSIO_SENSE: length 32.9
  TOP w0.127: v7(105.09,31.47) 105.64,31.47 v1(106.73,30.38) 107.45,29.66 108.39,29.66 PR1011.2
  IN1 w0.064: v7(105.09,31.47) 105.16,31.47 105.41,31.72 105.41,34.27 105.36,34.32 105.36,35.92 105.66,36.23 105.66,39.49 108.44,42.27 108.44,52.6 108.87,53.03 108.87,56.98 v14(108.55,57.29)
  GND2 w0.102: v5(108.78,57.06) v14(108.55,57.29)
  GND3 w0.102: v14(108.55,57.29) v5(108.78,57.06)
VSSSA_SENSE: length 44.2
  GND2 w0.102: v7(148.38,39.64) 148.42,39.64 148.64,39.43 v5(148.74,39.43)
  GND3 w0.102: v5(148.74,39.43) 148.69,39.43 148.46,39.66 v8(148.38,39.66)
  IN3 w0.064: v8(148.38,39.66) 148.38,39.25 148.32,39.19 148.09,39.19 148.03,39.25 148.03,40.11 144.6,43.54 141.66,43.54 139.42,45.77 139.42,47.6 139,48.02 136.59,48.02 134.27,50.33 134.27,52.14 133.05,53.36 130.08,53.36 129.15,54.29 116.91,54.29 115.51,52.88 115.51,52.64 115.57,52.58 v3(115.8,52.58)
1.05_VMMP_ALW_FB: length 5.2
  TOP w0.203: PR905.1 18.31,25.8 PC902.2 PR904.2 18.37,24.22 18.07,23.92 16.95,23.92 16.76,23.73 16.76,23.46 16.88,23.35 PU900.1
1.05_VMMP_ALW_LX:
  vias: v1(21.94,19.89) v2(19.02,22.43) v2(19.4,22.5) v2(19.66,23.01) v2(19.72,22.31) v2(19.78,22.62) v2(23.15,22.05) v2(23.15,21.67) v2(23.53,22.05) v2(23.53,21.67) v2(23.91,22.05) v2(23.91,21.67)
1.05_VMMP_ALW_ON: length 6.5
  TOP w0.127: v1(14.73,25.88) 14.73,25.8 PR900.2
  TOP w0.203: PU900.2 16.72,22.9 16.47,23.15 16.47,23.88 16.86,24.28 17.18,24.28 17.37,24.47 PC900.1 16.65,24.83 PR902.1 16.14,24.87 PR900.2
1.05_VMMP_ALW_PG: length 1.9
  TOP w0.127: v1(14.79,20.28) RE297.2 14.88,21.51 PR907.1
3S_BATT+:
  vias: v1(144.05,4.27)
08_VR_EN: length 198.3
  TOP w0.127: v2(80.43,26.78) 80.43,28.52 v1(79.78,29.17) 70.02,29.17 68.37,30.82 68.37,32.31 67.93,32.76 67.14,32.76 66.36,31.98 DV13.1 66.36,27.09 65.76,26.48 65.76,25.42 64.68,24.34 RH576.2 64.45,23.62 65.27,22.79 65.27,20.02 64.9,19.64 64.22,19.64 RH575.2 R5827.2 62.94,19.6 63.21,19.33 DV15.2 63.21,18.61 62.72,18.13 DV10.2
  IN1 w0.064: v4(141.75,89.01) 141.63,89.01 139.42,86.8 139.42,85.52 139.18,85.28 137.66,85.28 137.38,85 137.38,82.72 138.09,82.02 138.09,77.97 136.75,76.63 136.75,76.06 133.99,73.3 133.99,73.13 132.26,71.39 129.58,71.39 127.96,69.77 127.96,66.63 126.95,65.61 126.95,60.97 127.28,60.64 128.24,60.64 128.75,60.13 128.75,53.24 131.69,50.3 132.38,50.3 135,47.68 135,46.37 136.71,44.65 136.71,43.63 136.89,43.45 143.06,43.45 144.73,41.79 144.73,36.97 143.73,35.97 138.5,35.97 137.64,35.11 137.11,35.11 136.8,34.8 136.8,32.84 133.46,29.5 114.19,29.5 113.15,28.46 108.37,28.46 104.8,24.89 104.38,24.89 103.35,23.85 97.48,23.85 94.67,26.65 80.55,26.65 v2(80.43,26.78)
  GND2 w0.102: v5(142.19,89.01) v4(141.75,89.01)
  GND3 w0.102: v5(142.19,89.01) 142.19,89.08 v6(142.44,89.34)
  IN3 w0.064: v3(152.13,91.68) 152.06,91.75 152.06,93.3 150.37,95 147.25,95 143.46,91.21 143.46,90.36 v6(142.44,89.34)
32KHZ_OUT: length 4.8
  TOP w0.127: CE57.1 v1(39.05,13.7) 39.23,13.7 39.75,14.22 40.17,14.22 40.55,13.84 41.91,13.84 UE3.F3
+1.05_VMM_ALW: length 74.2
  IN2 w0.508: v9(25.9,24.33) 25.9,23.84 27.31,22.42 29.51,22.42 30.62,21.32 33.33,21.32 36.1,18.55 36.93,18.55 37.58,17.9 51.44,17.9 51.8,17.54 53.99,17.54 54.69,16.83 62.19,16.83 64.21,18.86 67.55,18.86 70.36,16.04 72.4,16.04 73.71,14.74 76.87,14.74 77.51,15.37 82.15,15.37 83.47,16.7 83.47,19.91 88.03,24.47 88.24,24.47
  vias: v9(24.76,24.41) v9(25.32,24.41) v9(88.68,25.02) v9(88.93,24.49) v9(89.24,25) v16(26.58,25.04)
+1.05_VMMP_ALW: length 5.8
  TOP w0.203: PC904.1 22.89,26.78 22.46,27.21 20.56,27.21 v1(20.32,26.97) 19.85,26.5 19.85,26.29 PC902.1 PR904.1
+CCG_VBUS1: length 136.3
  TOP w0.508: v2(113.52,11.78) 113.52,12.03 v1(113.52,16.27) 113.52,17.15 v7(113.48,17.19) ; v7(89.19,15.93) 89.19,17.93 88.3,18.81 88.3,23.08 v7(86.38,25)
  IN1 w0.508: v4(104.42,6.02) 104.52,6.12 104.52,7.41 106.82,9.71 109.06,9.71 109.26,9.51 109.84,9.51 110.33,9.03 111.8,9.03 112.37,9.6 112.37,10.88 113.27,11.78 v2(113.52,11.78)
  GND2 w0.508: v4(104.42,6.02) 104.34,5.94 v5(104.34,5.69) ; v7(89.19,15.93) 89.51,15.93 v5(89.52,15.93) ; v7(113.48,17.19) 113.48,17.24 v5(113.05,17.67) ; v5(86.38,25.48) v7(86.38,25)
  IN2 w0.508: v5(89.52,15.93) 89.98,16.39 96.54,16.39 97.12,16.97 101.51,16.97 101.6,17.05 104.31,17.05 106.32,19.05 106.45,19.25 106.71,19.51 107.01,19.71 107.35,19.85 107.71,19.92 108.07,19.92 108.43,19.85 108.77,19.71 109.71,19.09 111.12,17.67 v5(113.05,17.67) ; v5(50.34,63.38) 50.34,63.33 49.28,62.27 49.28,54.52 52.17,51.64 52.17,45.24 51.69,44.76 51.69,34.29 51.82,34.17 51.82,28.19 54.68,25.32 57.72,25.32 58.71,24.32 72.56,24.32 73.55,25.3 75.76,25.3 76.04,25.58 76.84,25.58 77.07,25.35 79.18,25.35 79.65,24.87 85.77,24.87 v5(86.38,25.48)
  GND3 w0.508: v5(104.34,5.69) 103.94,5.29 v6(103.67,5.29) ; v6(49.93,63.15) 50.11,63.15 v5(50.34,63.38)
  BOTTOM w0.508: v6(49.93,63.15) 50.26,63.15 50.69,63.58 50.69,64.8 50.07,65.42 PD306.2 ; JIO1.S11 v6(103.67,5.29)
+CCG_VBUS2: length 134.7
  TOP w0.508: v7(114.13,17.13) 114.13,14.02 v1(114.1,13.99) 114.1,12.27 114.1,11.47 113.7,11.07 v2(113.51,11.07) ; v7(86.42,23.44) 87.64,22.22 87.64,18.36 88.26,17.74 v7(88.26,15.93)
  IN1 w0.508: v2(113.51,11.07) 113.38,11.07 112.96,10.65 112.96,9.37 112.04,8.44 110.09,8.44 109.6,8.93 109.01,8.93 108.82,9.12 107.06,9.12 105.32,7.38 105.32,5.96 v4(105.48,5.8)
  GND2 w0.508: v5(114.1,17.86) 114.13,17.83 v7(114.13,17.13) ; v7(86.42,23.44) v5(86.03,23.44) ; v4(105.48,5.8) 105.48,5.41 v5(105.42,5.34) ; v5(88.26,16.26) v7(88.26,15.93)
  IN2 w0.508: v5(114.1,17.86) 113.64,18.32 111.3,18.32 110.08,19.54 109.04,20.23 108.6,20.41 108.13,20.51 107.65,20.51 107.18,20.41 106.74,20.23 106.67,20.19 106.34,19.96 106,19.62 105.86,19.42 105.33,18.89 104.07,17.63 98.5,17.63 97.4,18.73 90.73,18.73 v5(88.26,16.26) ; v5(86.03,23.44) 78.98,23.44 78.13,24.29 73.36,24.29 72.81,23.74 58.47,23.74 57.47,24.73 54.44,24.73 51.23,27.94 51.23,33.61 51.08,33.76 51.08,45.12 51.56,45.6 51.56,51.38 48.7,54.24 48.7,62.55 v5(49.18,63.02)
  GND3 w0.508: v5(49.18,63.02) 49.17,63.03 v6(49.17,63.35) ; v5(105.42,5.34) 105.06,4.98 v6(105.06,4.9)
  BOTTOM w0.508: v6(49.17,63.35) 50.03,64.22 PD307.2
+CHG_SRC_20V:
  vias: v1(154.59,15.45) v9(153.49,10.85) v9(153.64,15.58) v9(153.64,14.94) v9(153.64,11.46)
+CHG_VIN_20V: length 89
  TOP w0.127: v16(114.76,10.94) v9(114.76,10.31)
  TOP w0.381: PR109.1 25.14,74.19 PR106.1
  TOP w0.508: v9(146.22,1.45) 147.44,1.45 147.96,1.97 147.96,4.88 147.76,5.09 147.76,6.01 148.27,6.52 149.02,6.52 149.55,5.99 149.55,3.56 150.29,2.83 153.34,2.83 153.77,3.26 153.77,4.02 PR506.1 ; v7(25.73,72.09) 24.88,72.94 24.88,73.23 24.81,73.3 PC112.1 PR109.1 ; v2(43.81,56.85) 43.81,56.96 39.5,61.27 37.06,61.27 36.59,60.8 31.32,60.8 30.02,59.5 29.03,59.5 26.58,61.96 26.58,63.07 28.32,64.81 28.32,67.57 27.81,68.08 v2(25.12,68.08)
  IN1 w0.254: v9(146.22,1.45) 153.56,1.45 154.41,2.3 163.06,2.3 v2(163.31,2.05)
  IN1 w0.508: v4(45.72,61.45) 45.72,60.83 44.37,59.48 44.37,58.94 43.81,58.38 v2(43.81,56.85) ; v4(20.96,65.42) 22.19,65.42 22.29,65.52 23.65,65.52 24.09,65.96 24.09,65.98 24.1,66 24.1,66.1 25.12,67.11 v2(25.12,68.08) 25.48,68.44 25.48,71.85 v7(25.73,72.09)
  GND2 w0.508: v7(24.44,90.96) 24.28,91.13 v5(24.28,92) ; v5(20.78,65.04) 20.96,65.23 v4(20.96,65.42) ; v5(46.05,61.98) 46.05,61.77 v4(45.72,61.45)
  GND3 w0.508: v5(46.05,61.98) 46.29,62.22 v6(46.29,63) ; v5(20.78,65.04) v6(20.78,64.64)
  vias: v5(14.06,65.77) v5(14.04,65.31) v5(13.99,64.83) v5(14.44,63.96) v5(14.5,65.79) v5(14.49,65.33) v5(14.46,64.88) v5(14.46,64.41) v5(14.96,65.33) v5(14.93,64.88) v5(14.93,64.41) v5(14.91,63.96) v5(14.97,65.79) v5(24,93.83) v5(24,93.25) v5(24.01,92.49) v5(24.52,92.5) v5(24.66,93.9) v5(24.66,93.24) v5(25.03,92.5) v5(25.43,93.41) v5(25.45,92.92) v5(25.93,93.92) v5(25.93,93.43) v5(107.54,2.88) v6(15.27,65.17) v6(15.27,64.86) v6(15.27,64.56) v6(15.27,64.26) v6(15.27,63.95) v6(15.27,63.65) v6(15.43,65.42) v6(15.58,65.17) v6(15.58,64.86) v6(15.58,64.56) v6(15.58,64.26) v6(15.58,63.95) v6(15.58,63.65) v6(23.66,94.1) v6(23.66,93.67) v6(23.66,93.36) v6(23.66,93.03) v6(23.66,92.7) v6(23.68,94.44) v6(24.15,94.21) v6(24.15,92.89) v6(24.19,93.55) v6(24.3,94.65) v6(24.51,94.21) v6(24.55,93.55) v6(24.51,92.89) v6(24.61,94.65) v6(24.93,94.65) v6(25.05,94.05) v6(25.05,93.69) v6(25.05,93.34) v6(25.05,93.02) v6(25.08,94.37) v6(25.24,94.65) v6(25.33,93.86) v6(25.4,94.37) v6(25.55,94.65) v7(24.44,93.6) v7(25.03,93.85) v7(25.03,93.45) v7(25.03,93.06) v7(25.41,93.85) v9(2.77,7.09) v9(2.77,6.52) v9(3.02,6.01) v9(3.27,60.66) v9(3.27,60.03) v9(3.27,59.39) v9(3.34,7.09) v9(3.34,6.52) v9(3.59,6.01) v9(3.91,60.66) v9(3.91,60.03) v9(3.91,59.39) v9(3.91,7.09) v9(3.91,6.52) v9(4.54,60.66) v9(4.54,60.03) v9(5.18,60.66) v9(5.18,60.03) v9(113.55,10.39) v9(113.55,9.43) v9(113.55,8.42) v9(114.76,9.74) v9(114.76,9.17) v9(114.76,8.59) v9(115.33,10.31) v9(115.33,9.74) v9(115.33,9.17) v9(115.9,9.74) v9(115.9,9.17) v9(143.8,3.19) v9(143.8,2.62) v9(143.8,2.05) v9(143.79,1.45) v9(144.37,3.19) v9(144.37,2.62) v9(144.37,2.05) v9(144.37,1.45) v9(144.94,3.19) v9(144.94,2.62) v9(144.94,2.05) v9(144.98,1.45) v9(145.59,1.45)
+DC_IN_1: length 12.6
  TOP w0.508: v2(24.18,76.24) 25.26,76.24 PR108.1 PC111.1
  IN1 w0.508: v2(24.18,76.24) 23.63,76.79 22.45,76.79 20.04,74.38 v7(20.04,73.97) 19.73,73.67 18.75,73.67 17.7,72.61 v9(16.02,72.61)
  vias: v1(15.91,73.36) v9(15.44,72.61)
+DC_IN_2:
  vias: v1(17.75,97.36) v9(18.26,99.31) v9(18.89,97.36) v9(18.89,96.73)
+DCPRTC: length 2.2
  TOP w0.127: v1(26.83,48.41) 27.02,48.22 v7(27.83,48.22)
  GND2 w0.305: v7(27.83,48.22) 27.43,48.22 v5(27.35,48.29)
  GND3 w0.305: v5(27.35,48.29) 27.56,48.08 v6(27.82,48.08)
+EC_DEBUG_VCC: length 5.6
  GND2 w0.254: v5(55.22,7.07) v7(54.84,7.07)
  GND3 w0.254: v6(54.89,7.07) v5(55.22,7.07)
  BOTTOM w0.305: RE200.2 v6(54.89,7.07) 53.71,7.07 52.39,5.74 JDEG1.1
+EVDDC: length 15.3
  IN1 w0.508: v4(84.96,57.74) 85.14,57.92 87.52,57.92 87.98,58.38 87.98,59.81 87.15,60.65 ; 87.31,61.75 87.19,61.87 87.19,62.21 87.5,62.51 87.5,64.16 87.16,64.51 87.16,68.17 86.09,69.23 v2(85.7,69.23)
  GND2 w0.381: v4(84.96,57.74) 84.79,57.57 v5(84.67,57.57)
  GND3 w0.254: v5(84.67,57.57) 84.93,57.31 v6(84.93,57.29)
+EVDDQ: length 9.9
  TOP w0.127: v7(84.92,58.59) 84.92,58.23 v1(85.28,57.87)
  IN1 w0.508: 85.01,60.19 85.01,58.68 v7(84.92,58.59) ; 84.38,61.6 83.98,61.99 v2(83.98,63.61)
  GND2 w0.254: v7(84.92,58.59) v5(84.68,58.83)
  GND3 w0.254: v6(84.93,58.59) 84.92,58.59 v5(84.68,58.83)
  BOTTOM w0.254: 84.53,57.04 84.53,58.19 v6(84.93,58.59) 85.32,58.21 85.32,57.03 UC1.T46 84.53,57.04
+INV_PWR_SRC:
  vias: v9(64.94,93.35) v9(65.82,92.73) v16(66.1,92.26)
+LCDVDD: length 7.3
  TOP w0.127: v16(62.49,88.75) 62.77,89.03 v9(62.77,90.44) ; v16(63.41,90.23) 63.41,91.24 v9(63.25,91.4)
  GND2 w0.254: v7(57.22,95.13) 57.22,94.67 v5(57.15,94.6) 56.79,94.95 v7(56.79,95.13) ; v7(56.03,95.13) 56.03,94.77 v5(56.21,94.6) 56.38,94.77 v7(56.38,95.13)
  GND3 w0.254: v6(56.41,94.24) 56.41,94.39 v5(56.21,94.6) 55.91,94.3 v6(55.91,94.24) ; v6(56.91,94.24) 56.91,94.36 v5(57.15,94.6) 57.41,94.33 v6(57.41,94.24)
  vias: v9(62.75,91.1) v16(56.87,95.71)
+ODR_PWR: length 6.8
  TOP w0.127: v16(19.34,67.9) 19.67,67.57 v2(19.67,67.54)
  TOP w0.203: UR1.12 v2(22.69,67.77)
  IN1 w1.016: 17.17,66 18.71,67.54 v2(19.67,67.54) 20.2,67.01 21.88,67.01
  vias: v2(16.84,65.26) v2(16.84,64.98) v2(17.29,65.26) v2(17.29,64.98) v2(22.69,68.15)
+PECI_VREF: length 6
  TOP w0.254: v7(49.35,10.59) 49.15,10.59 UE3.J11
  TOP w0.305: v2(52.98,8.72) 53.08,8.62 CE56.1
  IN1 w0.508: v7(49.35,10.59) 50.03,10.59 50.76,9.86 50.95,9.86 51.2,9.61 52.09,9.61 v2(52.98,8.72)
+RTC_CELL_VBAT: length 5
  TOP w0.254: v2(38.81,18.6) 38.58,18.37 38.05,18.37 CE42.1 37.94,18.75 38.02,18.83 38.02,19.01 RE106.1 ; UE3.A2 v7(41.15,17.79)
  IN1 w0.254: v7(41.15,17.79) 39.61,17.79 v2(38.81,18.6)
+RTCBATT: length 13.3
  TOP w0.127: v1(159.61,14.24) 160.03,14.24 v2(160.6,14.81)
  IN1 w0.508: v2(160.6,14.81) 161.21,14.81 161.58,15.18 v4(162.06,15.18)
  GND2 w0.508: v4(162.06,15.18) 162.53,15.18 v5(162.54,15.17)
  GND3 w0.508: v8(162.54,14.73) v5(162.54,15.17)
  IN3 w0.508: v3(164.55,6.67) 165.33,7.45 165.33,10.89 162.54,13.67 v8(162.54,14.73)
+RTCVCC: length 159.1
  TOP w0.508: QRTC.1 69.99,22.82 70.14,22.66 R276.1 71.09,22.68 C3.1 71.95,22.15 70.9,21.1 70.9,17.75 70.39,17.23 v7(70.39,16.94) 70.39,13.59 v16(69.88,13.08) v7(67.87,11.07) ; v7(27.83,46.56) CH105.1
  GND2 w0.381: v7(27.83,46.56) 27.83,46.41 27.43,46.01 v5(27.43,45.9)
  GND2 w0.508: v7(70.39,16.94) 70.08,17.25 v5(70.08,17.3) ; v5(68.46,10.98) 68.37,11.07 v7(67.87,11.07)
  IN2 w0.508: v5(68.46,10.98) 69.23,11.75 78.2,11.75 78.87,12.42 84.34,12.42 85.78,10.98 88.29,10.98 93.09,15.78 96.82,15.78 97.42,16.38 105.49,16.38 105.66,16.21 108.26,16.21 v5(109.06,15.41) ; v5(70.08,17.3) 67.94,19.44 63.97,19.44 61.95,17.42 54.93,17.42 54.23,18.12 52.04,18.12 51.69,18.48 37.82,18.48 37.17,19.13 36.34,19.13 32.47,23.01 28.51,23.01 27.81,23.7 27.81,25.21 19.83,33.19 19.83,35.8 18.75,36.88 18.75,39.32 16.91,41.16 v5(16.91,42.44)
  GND3 w0.254: v6(109.55,15.41) v5(109.06,15.41)
  GND3 w0.381: v5(27.43,45.9) 27.56,45.9 v6(27.77,45.69)
  GND3 w0.508: v5(16.91,42.44) 16.91,42.67 v6(16.7,42.88)
  IN3 w0.508: v3(16.35,45.68) 17.6,46.92 20.74,46.92 21.42,47.6 22.17,47.6 22.51,47.26 23.8,47.26 25.37,45.69 v6(27.77,45.69)
  BOTTOM w0.254: v6(109.55,15.41) 109.06,14.93 JIO1.F6
  BOTTOM w0.508: 15.73,41.03 15.74,41.04 RH131.1 ; 15.73,41.03 15.73,39.34 16.25,38.82 RH135.1 ; 15.73,41.03 15.73,42.88 ; v6(16.7,42.88) 15.73,42.88 ; 15.73,42.88 15.73,45.05 v3(16.35,45.68)
+RTCVCC_R: length 178
  TOP w0.356: RE184.1 RE142.2 RE137.2 RE244.2
  TOP w0.381: v2(34.43,18.89) 34.43,18.32 34.59,18.15 34.59,17.33 34.82,17.1 RE184.1
  TOP w0.508: v7(161.08,15.6) 161.29,15.4 RTCR1.2 ; v2(68.85,16.11) 68.85,16.54 70.32,18.01 70.32,19.46 69.66,20.12 QRTC.3 ; v2(153.76,9.66) 149.13,9.66 146.88,7.41 137.47,7.41 136.56,6.5 129.17,6.5 127.96,5.29 120.54,5.29 118.76,7.07 114.65,7.07 111.71,4.12 109.32,4.12 108.95,4.05 108.6,3.9 108.28,3.69 108.02,3.43 107.81,3.11 107.66,2.76 106.82,1.92 101.32,1.92 99.16,4.08 v1(96.05,4.08) 95.16,4.08 93.89,5.35 93.89,7.58 91.22,10.24 v2(91.22,12.78)
  IN1 w0.508: 36.23,20.92 35.54,20.92 34.83,20.21 34.83,19.3 v2(34.43,18.89) ; 36.23,20.92 36.23,21.29 37.11,22.17 37.11,22.93 38.46,24.28 40.16,24.28 40.43,24.55 43.94,24.55 44.98,23.51 46.13,23.51 46.36,23.28 48.76,23.28 49.13,22.92 53.18,22.92 53.89,22.21 56.37,22.21 57.72,20.86 60.42,20.86 61.19,21.62 62.89,21.62 68.4,16.11 v2(68.85,16.11) 69,16.11 70.61,14.5 78.81,14.5 79.44,13.87 90.09,13.87 91.18,12.78 v2(91.22,12.78) ; 36.23,20.92 37.23,19.92 v2(37.23,19.13) ; v2(153.76,9.66) 153.76,10.01 154.31,10.57 160.22,10.57 161.31,9.48 v4(161.69,9.48)
  GND2 w0.508: v5(165.85,10.9) 165.85,10.57 v5(165.31,10.03) ; v5(162.25,9.02) 161.78,9.48 v4(161.69,9.48) ; v7(161.08,15.6) v5(161.08,16.02)
  IN2 w0.508: v5(165.31,10.03) 163.18,10.03 162.25,9.09 v5(162.25,9.02) ; v5(165.85,10.9) 163.91,12.83 162.99,12.83 161.96,13.86 161.96,15.22 161.16,16.02 v5(161.08,16.02)
  GND3 w0.508: v6(162.89,8.65) 162.61,8.65 v5(162.25,9.02)
  BOTTOM w0.508: v6(162.89,8.65) 163.24,8.65 163.65,9.06 CH241.1
+SD_VDD2: length 19.4
  TOP w0.203: UR1.13 v2(22.29,67.77)
  IN1 w0.762: 21.62,68.03 20.55,68.03 19.42,69.15 17.8,69.15 16.4,70.54 8.07,70.54 7.97,70.44
  BOTTOM w0.762: 6.96,69.74 5.9,68.69 5.9,66.25
  vias: v1(5.05,63.96) v2(22.29,68.15) v9(3.21,64.53) v9(3.21,63.95) v9(6.64,70.48) v9(7.22,70.48)
+TBT_VBUS1: length 72.3
  TOP w0.127: v7(12.37,74.86) v16(12.37,76.21)
  TOP w0.305: JUSBC1.B4 7.8,81.27 JUSBC1.A9 v7(9.31,81.27) ; v7(9.31,83.77) JUSBC1.A4 7.8,83.77 JUSBC1.B9
  TOP w0.508: v9(41.14,65.21) 41.25,65.11 41.25,63.84 39.91,62.5 v16(38.45,62.5) 35.34,62.5 34.39,61.55 28.1,61.55 27.47,62.18 27.47,62.84 29.1,64.48 29.1,68.48 v7(28.8,68.79) PT100.1
  GND2 w0.381: v7(28.8,68.79) v5(28.47,68.79)
  IN2 w0.508: v5(49.3,67.32) 48.18,66.2 46.1,66.2 45.41,66.88 45.41,71.52 44.74,72.19 42.82,72.19 42.31,71.68 42.31,66.38 v9(41.14,65.21)
  GND3 w0.254: v6(17.28,74.55) 17.17,74.55 v5(16.96,74.76) 17.17,74.96 v6(17.28,74.96) ; v6(17.93,74.96) 17.84,74.96 v5(17.64,74.76) 17.84,74.55 v6(17.93,74.55) ; v6(28.16,69.1) v5(28.47,68.79) ; v6(16.61,74.96) 16.48,74.96 v5(16.28,74.76) 16.48,74.55 v6(16.61,74.55)
  GND3 w0.508: v5(49.3,67.32) 49.98,66.63 v6(50.03,66.63)
  IN3 w0.381: v6(28.16,69.1) 27.66,69.6 23.39,69.6 22.91,70.08 20.13,70.08 17.93,72.28 v6(17.93,74.55)
  BOTTOM w0.254: v6(28.16,69.1) 29.06,69.1 29.88,68.28 29.88,67.52 30.37,67.03 UPD1.D1
  BOTTOM w0.508: v9(41.14,65.21) 40.56,65.79 RP110.1
  vias: v5(9.24,84.59) v5(9.24,84.15) v5(9.25,80.89) v5(9.25,80.45) v5(9.69,84.59) v5(9.69,84.15) v5(9.7,80.89) v5(9.7,80.45) v5(12.75,75) v5(12.75,74.5) v5(12.76,72.85) v5(12.76,72.36) v5(13.22,75) v5(13.22,74.5) v5(13.23,72.85) v5(13.23,72.36) v5(13.7,74.97) v5(13.7,74.48) v5(13.71,72.83) v5(13.71,72.33) v6(11.45,73.56) v6(11.81,74.77) v6(11.82,74.4) v6(11.96,73.69) v6(11.96,73.35) v6(12.54,74.11) v6(12.54,73.6) v6(12.54,73.26) v6(12.86,74.11) v6(12.86,73.6) v6(12.86,73.26) v6(13.2,74.11) v6(13.2,73.6) v6(13.2,73.25) v6(13.55,74.11) v6(13.55,73.6) v6(13.55,73.25) v7(9.68,83.77) v7(9.67,81.27) v7(12.37,73.97) v7(12.37,73.08) v7(18.53,74.5) v7(18.93,74.5) v8(9.31,83.77) v8(9.31,81.27) v8(9.67,83.77) v8(9.67,81.27)
+TBT_VBUS2: length 64
  TOP w0.127: v1(16.35,101.36) 16.06,101.66 v9(16.06,101.76)
  TOP w0.254: v9(13.93,103.82) 13.93,104.23 PT101.1
  TOP w0.305: v7(9.31,99.97) JUSBC2.A4 7.8,99.97 JUSBC2.B9 ; v7(9.31,97.47) JUSBC2.A9 7.8,97.47 JUSBC2.B4
  IN1 w0.508: v4(37.94,72.85) 37.68,73.12 35.57,73.12 34.26,71.81 v4(32.23,71.81)
  GND2 w0.508: v4(32.23,71.81) 32.23,71.42 v5(32.15,71.34) ; v4(37.94,72.85) 38.45,72.35 v5(38.45,72.17)
  IN2 w0.508: v5(18.06,91.32) 18.06,92.77 17.24,93.58 17.24,96.35 ; v5(38.45,72.17) 40.25,72.17 41.56,73.49 45.5,73.49 48.65,70.34 v5(49.4,70.34)
  GND3 w0.381: v6(31.91,70.95) 32.15,71.19 v5(32.15,71.34)
  GND3 w0.508: v6(49.88,70.36) 49.86,70.34 v5(49.4,70.34) ; v5(38.45,72.17) 38.97,71.65 v15(39.2,71.65) ; v5(18.06,91.32) v8(18.06,90.96)
  IN3 w0.508: v8(18.06,90.96) 20.07,88.94 21.97,88.94 23.09,87.82 23.09,86.19 25.42,83.85 25.42,83.81 28.12,81.11 28.12,76.07 32.17,72.02 32.17,71.21 v6(31.91,70.95)
  GND4 w0.508: v14(38.9,70.77) 38.9,71.34 v15(39.2,71.65)
  BOTTOM w0.305: v6(31.91,70.95) 31.68,70.72 UPD1.L3
  BOTTOM w0.508: PD305.2 50.03,70.21 v6(49.88,70.36)
  vias: v3(16.13,100.46) v3(17.01,100.48) v3(18.07,101.05) v3(18.26,100.54) v3(18.26,100.03) v3(18.64,101.68) v3(18.64,101.17) v3(18.77,100.54) v3(18.77,100.03) v3(19.07,102.24) v3(19.45,101.56) v3(19.91,101) v3(19.91,100.54) v3(19.91,100.03) v3(20.42,101) v3(20.42,100.54) v3(20.42,100.03) v3(21.64,101.25) v3(21.56,99.52) v5(9.24,100.79) v5(9.24,100.35) v5(9.25,97.09) v5(9.25,96.65) v5(9.69,100.79) v5(9.69,100.35) v5(9.7,97.09) v5(9.7,96.65) v5(20.79,98.68) v5(20.8,98.23) v7(9.67,99.97) v7(9.68,97.47) v7(21.15,98.68) v7(21.15,98.3) v8(9.31,99.97) v8(9.31,97.47) v8(9.66,99.97) v8(9.68,97.47) v9(13.36,103.82) v9(13.36,103.24) v9(13.93,103.24) v9(14.5,103.82) v9(14.5,103.24) v9(15.02,103.02) v9(15.02,102.44) v9(15.54,102.67) v9(15.54,102.1) v9(16.06,102.33) v9(21.19,100.79) v9(21.19,100.08) v16(21.75,98.12)
+TPM_VDD: length 5.6
  BOTTOM w0.254: RE12.2 RE10.2 CE10.1 28.1,10.61 CE11.1 27.54,9.48 v1(27.12,9.9) 26.41,10.61 UE2.8
+VDP_ZVDD_08: length 5.6
  TOP w0.127: v7(79.46,81.11) v1(79.46,79.95)
  GND2 w0.305: v7(79.46,81.11) 79.46,81.13 v5(79.19,81.39)
  GND3 w0.305: v5(79.19,81.39) v8(78.85,81.39)
  IN3 w0.305: v8(78.85,81.39) 77.66,81.39 77.05,82 77.05,82.3 76.84,82.51 76.31,82.51 v6(75.92,82.89)
+VGA_CORE: length 219.3
  GND2 w0.254: v15(92.94,63.46) v5(93.27,63.46) ; v8(95.47,72.14) v5(95.8,72.14) ; v8(90.31,75.65) v5(90.64,75.65) v7(90.99,75.65) ; v8(97.29,75.65) v5(97.62,75.65) ; v5(89.4,60.87) 89.37,60.87 89.13,61.08 v7(89.1,61.08) ; v8(91.68,74.79) v5(92.01,74.79) ; v8(86.69,72.7) v5(87.02,72.7) ; v8(91.39,70.71) v5(91.72,70.71) ; v15(92.94,66.25) v5(93.27,66.25) ; v7(99.6,64.47) v5(99.27,64.47) ; v8(88.2,75.65) v5(87.87,75.65) ; v8(88.61,69.78) v5(88.28,69.78) ; v5(98.85,62.23) 98.74,62.12 v7(98.5,62.12) ; v8(95.47,71.76) v5(95.14,71.76) ; v5(93.34,62.23) 93.29,62.19 v7(92.96,62.19) ; v7(95.48,63.46) v5(95.81,63.46) ; v7(95.48,63.07) v5(95.14,63.07) ; v7(100.94,64.85) v5(101.27,64.85) ; v8(88.62,68.8) v5(88.29,68.8) ; v8(99.09,68.77) v5(99.42,68.77) ; v7(99.6,65.87) v5(99.27,65.87) ; v8(100.59,69.74) v5(100.26,69.74) ; v15(92.94,67.27) v5(92.6,67.27) ; v7(95.48,64.85) v5(95.81,64.85) ; v8(100.89,74.43) v5(100.56,74.43) ; v8(90.31,76.28) v5(90.64,76.28) v7(90.99,76.28) ; v15(92.94,63.07) v5(92.6,63.07) ; v8(86.69,72.31) v5(86.36,72.31) ; v7(89.2,61.96) 89.2,62.03 v5(89.4,62.23) v7(89.29,62.95) ; v8(91.55,64.47) v5(91.22,64.47) ; v8(95.46,73.09) v5(95.13,73.09) ; v8(92.88,74.79) v5(93.21,74.79) ; v8(100.94,71.76) v5(100.61,71.76) ; v5(95.7,62.23) 96.03,62.23 v7(96.07,62.19) ; v8(87,76.28) v5(87.33,76.28) ; v8(96.18,70.76) v5(96.51,70.76) ; v15(92.94,64.85) v5(93.27,64.85) ; v5(84.53,75.95) 84.26,75.69 v7(84.26,75.67) ; v8(95.49,74.42) v5(95.16,74.42) ; v8(88.2,76.28) v5(87.87,76.28) ; v7(95.48,66.25) v5(95.81,66.25) ; v7(99.6,63.07) v5(99.27,63.07) ; v8(86.15,71.35) v5(86.48,71.35) ; v8(83.45,75.65) v5(83.8,75.65) ; v8(92.4,69.73) v5(92.73,69.73) ; v8(84.3,73.81) v5(83.97,73.81) ; v8(91.66,71.78) v5(91.33,71.78) ; v15(92.94,64.47) v5(92.6,64.47) ; v8(91.67,73.49) v5(92,73.49) ; v8(92.89,72.18) v5(93.22,72.18) ; v8(92.88,74.4) v5(92.55,74.4) ; v8(100.21,75.65) v5(100.54,75.65) ; v15(92.94,67.65) v5(93.27,67.65) ; v7(100.94,65.87) v5(100.61,65.87) ; v8(95.13,70.73) v5(95.46,70.73) ; v8(99.1,70.79) v5(99.43,70.79) ; v8(87.75,73.44) v5(88.08,73.44) ; v8(91.68,74.4) v5(91.35,74.4) ; v8(99.62,72.14) v5(99.95,72.14) ; v8(91.55,66.25) v5(91.88,66.25) ; v8(87.84,74.77) v5(88.17,74.77) ; v7(100.94,63.07) v5(100.61,63.07) ; v8(91.55,65.87) v5(91.22,65.87) ; v8(91.67,73.11) v5(91.33,73.11) ; v8(100.89,74.81) v5(101.22,74.81) ; v8(92.38,70.73) v5(92.71,70.73) ; v8(86.6,73.62) v5(86.94,73.62) ; v5(84.51,75.33) 84.26,75.08 v7(84.26,75.04) ; v8(99.61,73.09) v5(99.27,73.09) ; v7(86.59,74.64) v5(86.94,74.64) ; v7(100.94,63.46) v5(101.27,63.46) ; v8(83.45,75.01) v5(83.78,75.01) ; v7(100.94,64.47) v5(100.61,64.47) ; v7(99.6,63.46) v5(99.93,63.46) ; v7(100.94,66.25) v5(101.27,66.25) ; v8(87,75.65) v5(87.33,75.65) ; v8(100.97,73.11) v5(100.64,73.11) ; v8(88.6,70.76) v5(88.27,70.76) ; v7(100.94,67.27) v5(100.61,67.27) ; v8(100.97,73.49) v5(101.3,73.49) ; v8(99.61,73.47) v5(99.94,73.47) ; v8(95.49,74.8) v5(95.82,74.8) ; v8(91.66,72.16) v5(91.99,72.16) ; v8(92.89,71.8) v5(92.56,71.8) ; v8(92.9,73.53) v5(93.23,73.53) ; v8(87.81,72.13) v5(88.14,72.13) ; v8(91.55,63.46) v5(91.88,63.46) ; v8(84.11,72.57) v5(83.78,72.57) ; v8(87.75,73.06) v5(87.42,73.06) ; v5(92.55,60.87) 92.96,61.28 v7(92.96,61.55) ; v8(94.62,76.28) v5(94.95,76.28) ; v15(92.94,65.87) v5(92.6,65.87) ; v8(95.18,68.71) v5(95.51,68.71) ; v8(99.62,71.76) v5(99.29,71.76) ; v8(95.17,69.7) v5(95.5,69.7) ; v7(95.48,65.87) v5(95.14,65.87) ; v8(99.08,69.77) v5(99.41,69.77) ; v7(99.6,67.65) v5(99.93,67.65) ; v7(84.26,76.29) 84.26,76.29 v5(84.49,76.52) ; v8(96.15,68.68) v5(96.48,68.68) ; v7(99.6,64.85) v5(99.93,64.85) ; v8(84.3,74.19) v5(84.63,74.19) ; v8(91.45,69.72) v5(91.78,69.72) ; v8(100.66,70.76) v5(100.33,70.76) ; v8(100.6,68.73) v5(100.27,68.73) ; v7(95.48,64.47) v5(95.14,64.47) ; v8(91.55,64.85) v5(91.88,64.85) ; v7(99.6,67.27) v5(99.27,67.27) ; v8(96.19,69.75) v5(96.52,69.75) ; v7(99.6,66.25) v5(99.93,66.25) ; v8(99.62,74.44) v5(99.29,74.44) ; v8(87.84,74.39) v5(87.51,74.39) ; v8(92.41,68.75) v5(92.74,68.75) ; v8(91.55,63.07) v5(91.22,63.07) ; v8(91.55,67.65) v5(91.88,67.65) ; v8(97.29,76.28) v5(97.62,76.28) ; v8(87.81,71.75) v5(87.48,71.75) ; v8(91.43,68.75) v5(91.76,68.75) ; v8(91.55,67.27) v5(91.22,67.27) ; v8(94.62,75.65) v5(94.95,75.65) ; v8(92.9,73.15) v5(92.57,73.15) ; v8(99.62,74.82) v5(99.95,74.82) ; v8(95.46,73.47) v5(95.79,73.47) ; v8(87.38,69.67) v5(87.05,69.67) ; v8(83.45,76.28) v5(83.81,76.28) ; v8(100.21,76.28) v5(100.54,76.28) ; v8(84.11,72.95) v5(84.44,72.95) ; v8(86.16,70.4) v5(86.49,70.4) ; v7(95.48,67.65) v5(95.81,67.65) ; v7(100.94,67.65) v5(101.27,67.65) ; v7(95.48,67.27) v5(95.14,67.27) ; v8(100.94,72.14) v5(101.27,72.14)
  GND2 w0.305: v5(95.45,46.74) v8(95.78,46.74) v7(95.86,46.82) ; v7(95.86,47.26) v5(95.45,47.26) ; v7(95.86,48.11) 95.81,48.06 v5(95.45,48.06) ; v7(95.86,48.55) v5(95.45,48.55)
  GND3 w0.254: v5(86.49,70.4) v8(86.16,70.4) ; v5(95.8,72.14) v8(95.47,72.14) ; v8(90.31,76.28) v5(90.64,76.28) ; v5(84.53,75.95) v8(84.77,75.7) ; v5(100.56,74.43) v8(100.89,74.43) ; v8(84.77,76.32) 84.57,76.52 v5(84.49,76.52) ; v5(91.72,70.71) v8(91.39,70.71) ; v5(99.94,73.47) v8(99.61,73.47) ; v5(95.46,70.73) v8(95.13,70.73) ; v5(99.29,74.44) v8(99.62,74.44) ; v5(95.16,74.42) v8(95.49,74.42) ; v5(99.95,74.82) v8(99.62,74.82) ; v5(95.82,74.8) v8(95.49,74.8) ; v5(92.56,71.8) v8(92.89,71.8) ; v5(91.88,64.85) v8(91.55,64.85) ; v5(92.74,68.75) v8(92.41,68.75) ; v5(87.02,72.7) v8(86.69,72.7) ; v5(92.6,65.87) v15(92.94,65.87) ; v5(88.08,73.44) v8(87.75,73.44) ; v5(83.78,75.01) v8(83.45,75.01) ; v8(97.29,75.65) v5(97.62,75.65) ; v5(95.13,73.09) v8(95.46,73.09) ; v5(93.27,66.25) v15(92.94,66.25) ; v5(101.27,72.14) v8(100.94,72.14) ; v5(91.35,74.4) v8(91.68,74.4) ; v5(91.76,68.75) v8(91.43,68.75) ; v5(100.64,73.11) v8(100.97,73.11) ; v5(83.8,75.65) v8(83.45,75.65) ; v5(91.22,67.27) v8(91.55,67.27) ; v5(91.78,69.72) v8(91.45,69.72) ; v5(92.01,74.79) v8(91.68,74.79) ; v5(99.41,69.77) v8(99.08,69.77) ; v5(92.55,74.4) v8(92.88,74.4) ; v5(93.27,64.85) v15(92.94,64.85) ; v5(100.27,68.73) v8(100.6,68.73) ; v5(91.33,73.11) v8(91.67,73.11) ; v5(87.42,73.06) v8(87.75,73.06) ; v8(89.4,62.56) v5(89.4,62.23) ; v5(95.5,69.7) v8(95.17,69.7) ; v5(99.27,73.09) v8(99.61,73.09) ; v5(91.22,64.47) v8(91.55,64.47) ; v5(93.21,74.79) v8(92.88,74.79) ; v5(87.51,74.39) v8(87.84,74.39) ; v5(91.99,72.16) v8(91.66,72.16) ; v5(86.48,71.35) v8(86.15,71.35) ; v5(93.22,72.18) v8(92.89,72.18) ; v5(93.23,73.53) v8(92.9,73.53) ; v5(84.63,74.19) v8(84.3,74.19) ; v5(92.71,70.73) v8(92.38,70.73) ; v5(101.3,73.49) v8(100.97,73.49) ; v5(88.27,70.76) v8(88.6,70.76) ; v5(95.79,73.47) v8(95.46,73.47) ; v5(96.51,70.76) v8(96.18,70.76) ; v5(83.78,72.57) v8(84.11,72.57) ; v5(99.29,71.76) v8(99.62,71.76) ; v5(92.6,64.47) v15(92.94,64.47) ; v5(92.6,63.07) v15(92.94,63.07) ; v5(92.6,67.27) v15(92.94,67.27) ; v5(86.94,73.62) v8(86.6,73.62) ; v5(86.36,72.31) v8(86.69,72.31) ; v8(100.21,76.28) v5(100.54,76.28) ; v5(87.33,75.65) v8(87,75.65) ; v8(94.62,76.28) v5(94.95,76.28) ; v5(92,73.49) v8(91.67,73.49) ; v5(84.51,75.33) 84.64,75.19 v8(84.64,75.01) ; v5(92.57,73.15) v8(92.9,73.15) ; v8(94.62,75.65) v5(94.95,75.65) ; v5(95.51,68.71) v8(95.18,68.71) ; v5(88.29,68.8) v8(88.62,68.8) ; v8(100.21,75.65) v5(100.54,75.65) ; v5(87.48,71.75) v8(87.81,71.75) ; v5(96.48,68.68) v8(96.15,68.68) ; v5(91.22,63.07) v8(91.55,63.07) ; v5(95.14,71.76) v8(95.47,71.76) ; v5(93.27,67.65) v15(92.94,67.65) ; v5(96.52,69.75) v8(96.19,69.75) ; v5(91.88,63.46) v8(91.55,63.46) ; v5(91.22,65.87) v8(91.55,65.87) ; v5(100.33,70.76) v8(100.66,70.76) ; v5(91.88,67.65) v8(91.55,67.65) ; v5(100.26,69.74) v8(100.59,69.74) ; v5(99.42,68.77) v8(99.09,68.77) ; v5(87.87,76.28) v8(88.2,76.28) ; v5(88.14,72.13) v8(87.81,72.13) ; v5(99.43,70.79) v8(99.1,70.79) ; v5(93.27,63.46) v15(92.94,63.46) ; v5(91.33,71.78) v8(91.66,71.78) ; v5(99.95,72.14) v8(99.62,72.14) ; v5(87.33,76.28) v8(87,76.28) ; v5(100.61,71.76) v8(100.94,71.76) ; v8(97.29,76.28) v5(97.62,76.28) ; v5(87.87,75.65) v8(88.2,75.65) ; v8(90.31,75.65) v5(90.64,75.65) ; v5(87.05,69.67) v8(87.38,69.67) ; v5(84.44,72.95) v8(84.11,72.95) ; v5(83.97,73.81) v8(84.3,73.81) ; v5(88.28,69.78) v8(88.61,69.78) ; v5(83.81,76.28) v8(83.45,76.28) ; v5(88.17,74.77) v8(87.84,74.77) ; v5(101.22,74.81) v8(100.89,74.81) ; v5(91.88,66.25) v8(91.55,66.25) ; v5(92.73,69.73) v8(92.4,69.73)
  GND3 w0.305: v5(95.45,47.26) v8(95.79,47.26) ; v5(95.45,48.06) v8(95.78,48.06) ; v5(95.45,46.74) v8(95.78,46.74) ; v5(95.45,48.55) v8(95.78,48.55)
  IN3 w0.254: v14(98.31,60.55) v8(98.06,60.54) ; v14(93.59,57.29) v8(93.34,57.3) ; v14(96.74,59.24) v8(96.48,59.24) ; v14(89.65,59.89) v8(89.4,59.9) ; v14(101.46,59.24) v8(101.21,59.24) ; v14(101.46,59.89) v8(101.21,59.9) ; v14(97.53,60.55) v8(97.27,60.54) ; v14(95.95,58.59) v8(95.7,58.6) ; v14(97.53,56.64) v8(97.27,56.64) ; v14(99.1,59.89) v8(98.85,59.9) ; v14(92.8,60.55) v8(92.55,60.54) ; v14(88.08,59.24) v8(87.82,59.24) ; v14(99.1,58.59) v8(98.85,58.6) ; v14(89.65,58.59) v8(89.4,58.6) ; v14(93.59,61.9) v8(93.34,61.9) ; v14(92.01,57.94) v8(91.76,57.94) ; v14(88.08,57.94) v8(87.82,57.94) ; v14(97.53,59.89) v8(97.27,59.9) ; v14(88.86,61.2) v8(88.61,61.2) ; v14(90.44,57.29) v8(90.19,57.3) ; v14(99.1,60.55) v8(98.85,60.54) ; v14(95.16,60.55) v8(94.91,60.54) ; v14(102.25,56.64) v8(102,56.64) ; v14(96.74,59.89) v8(96.48,59.9) ; v14(93.59,62.55) v8(93.34,62.56) ; v14(95.95,57.29) v8(95.7,57.3) ; v14(90.44,59.24) v8(90.19,59.24) ; v14(99.1,59.24) v8(98.85,59.24) ; v14(102.25,59.89) v8(102,59.9) ; v14(93.59,58.59) v8(93.34,58.6) ; v14(94.38,61.9) v8(94.12,61.9) ; v14(96.74,60.55) v8(96.48,60.54) ; v14(97.53,61.2) v8(97.27,61.2) ; v14(93.59,60.55) v8(93.34,60.54) ; v14(101.46,61.2) v8(101.21,61.2) ; v14(99.1,62.55) v8(98.85,62.56) ; v14(88.08,58.59) v8(87.82,58.6) ; v14(102.25,62.55) v8(102,62.56) ; v14(95.95,57.94) v8(95.7,57.94) ; v14(101.46,57.94) v8(101.21,57.94) ; v14(88.86,61.9) v8(88.61,61.9) ; v14(95.16,59.89) v8(94.91,59.9) ; v14(91.23,60.55) v8(90.97,60.54) ; v14(88.86,62.55) v8(88.61,62.56) ; v14(95.16,61.2) v8(94.91,61.2) ; v14(94.38,59.24) v8(94.12,59.24) ; v14(99.89,60.55) v8(99.63,60.54) ; v14(96.74,58.59) v8(96.48,58.6) ; v14(95.95,62.55) v8(95.7,62.56) ; v14(91.23,58.59) v8(90.97,58.6) ; v14(91.23,62.55) v8(90.97,62.56) ; v14(100.68,56.64) v8(100.42,56.64) ; v14(97.53,57.29) v8(97.27,57.3) ; v14(101.46,62.55) v8(101.21,62.56) ; v14(99.89,57.94) v8(99.63,57.94) ; v14(95.16,56.64) v8(94.91,56.64) ; v14(90.44,60.55) v8(90.19,60.54) ; v14(99.89,57.29) v8(99.63,57.3) ; v14(90.44,58.59) v8(90.19,58.6) ; v14(102.25,61.9) v8(102,61.9) ; v14(100.68,57.29) v8(100.42,57.3) ; v14(95.16,57.94) v8(94.91,57.94) ; v14(98.31,61.2) v8(98.06,61.2) ; v14(98.31,57.94) v8(98.06,57.94) ; v14(93.59,61.2) v8(93.34,61.2) ; v14(95.95,56.64) v8(95.7,56.64) ; v14(91.23,61.9) v8(90.97,61.9) ; v14(100.68,58.59) v8(100.42,58.6) ; v14(100.68,61.2) v8(100.42,61.2) ; v14(99.89,58.59) v8(99.63,58.6) ; v14(95.16,57.29) v8(94.91,57.3) ; v14(98.31,58.59) v8(98.06,58.6) ; v14(97.53,58.59) v8(97.27,58.6) ; v14(102.25,58.59) v8(102,58.6) ; v14(91.23,57.94) v8(90.97,57.94) ; v14(92.8,56.64) v8(92.55,56.64) ; v14(94.38,60.55) v8(94.12,60.54) ; v14(99.89,56.64) v8(99.63,56.64) ; v14(96.74,57.94) v8(96.48,57.94) ; v14(89.65,57.94) v8(89.4,57.94) ; v14(90.44,59.89) v8(90.19,59.9) ; v14(101.46,60.55) v8(101.21,60.54) ; v14(95.16,58.59) v8(94.91,58.6) ; v14(90.44,57.94) v8(90.19,57.94) ; v14(96.74,62.55) v8(96.48,62.56) ; v14(95.95,60.55) v8(95.7,60.54) ; v14(89.65,62.55) v8(89.4,62.56) ; v14(92.8,59.24) v8(92.55,59.24) ; v14(92.8,57.29) v8(92.55,57.3) ; v14(88.86,58.59) v8(88.61,58.6) ; v14(89.65,60.55) 89.4,60.55 v8(89.4,60.54) ; v14(88.08,59.89) v8(87.82,59.9) ; v14(94.38,57.94) v8(94.12,57.94) ; v14(90.44,61.2) v8(90.19,61.2) ; v14(100.68,60.55) v8(100.42,60.54) ; v14(102.25,59.24) v8(102,59.24) ; v14(93.59,56.64) v8(93.34,56.64) ; v14(92.01,58.59) v8(91.76,58.6) ; v14(98.31,61.9) v8(98.06,61.9) ; v14(97.53,59.24) v8(97.27,59.24) ; v14(92.8,59.89) v8(92.55,59.9) ; v14(93.59,57.94) v8(93.34,57.94) ; v14(100.68,62.55) v8(100.42,62.56) ; v14(102.25,57.29) v8(102,57.3) ; v14(91.23,57.29) v8(90.97,57.3) ; v14(94.38,62.55) v8(94.12,62.56) ; v14(95.16,59.24) v8(94.91,59.24) ; v14(96.74,61.9) v8(96.48,61.9) ; v14(99.89,59.24) v8(99.63,59.24) ; v14(92.01,61.2) v8(91.76,61.2) ; v14(89.65,59.24) v8(89.4,59.24) ; v14(92.01,60.55) v8(91.76,60.54) ; v14(99.89,61.2) v8(99.63,61.2) ; v14(91.23,61.2) v8(90.97,61.2) ; v14(92.8,57.94) v8(92.55,57.94) ; v14(92.8,58.59) v8(92.55,58.6) ; v14(92.8,61.2) v8(92.55,61.2) ; v14(101.46,58.59) v8(101.21,58.6) ; v14(94.38,59.89) v8(94.12,59.9) ; v14(101.46,61.9) v8(101.21,61.9) ; v14(94.38,58.59) v8(94.12,58.6) ; v14(92.01,61.9) v8(91.76,61.9) ; v14(92.01,59.89) v8(91.76,59.9) ; v14(91.23,56.64) v8(90.97,56.64) ; v14(92.01,59.24) v8(91.76,59.24) ; v14(99.1,57.94) v8(98.85,57.94) ; v14(98.31,56.64) v8(98.06,56.64) ; v14(94.38,61.2) v8(94.12,61.2) ; v14(96.74,61.2) v8(96.48,61.2) ; v14(88.86,57.94) v8(88.61,57.94) ; v14(99.89,59.89) v8(99.63,59.9) ; v14(100.68,57.94) v8(100.42,57.94) ; v14(95.95,61.9) v8(95.7,61.9) ; v14(95.95,61.2) v8(95.7,61.2) ; v14(90.44,56.64) v8(90.19,56.64) ; v14(98.31,57.29) v8(98.06,57.3) ; v14(92.01,62.55) v8(91.76,62.56) ; v14(98.31,62.55) v8(98.06,62.56) ; v14(89.65,61.9) v8(89.4,61.9) ; v14(100.68,61.9) v8(100.42,61.9) ; v14(97.53,57.94) v8(97.27,57.94) ; v14(99.1,61.2) v8(98.85,61.2) ; v14(89.65,61.2) v8(89.4,61.2) ; v14(88.86,60.55) v8(88.61,60.54) ; v14(99.1,61.9) v8(98.85,61.9) ; v14(102.25,57.94) v8(102,57.94)
  BOTTOM w0.127: v14(95.95,62.55) 96.22,62.82 ; v14(95.95,62.55) 95.95,62.55 95.67,62.83 ; v14(95.95,62.55) 95.66,62.26 ; v14(95.95,62.55) 96.21,62.29 ; UC1.AE16 91.23,76.66 90.95,76.93 ; UC1.AE16 91.49,76.4 ; UC1.AE16 91.5,76.93 ; UC1.AE16 90.94,76.37 ; 96.45,60.9 v14(96.74,61.2) ; v14(96.74,61.2) 97.01,61.46 ; v14(96.74,61.2) 96.74,61.2 96.46,61.47 ; v14(96.74,61.2) 97,60.93 ; v14(88.86,62.55) 88.86,62.55 88.59,62.83 ; v14(88.86,62.55) 89.13,62.29 ; v14(88.86,62.55) 88.57,62.26 ; v14(88.86,62.55) 89.13,62.82 ; 100.38,60.9 v14(100.68,61.2) ; v14(100.68,61.2) 100.95,61.46 ; v14(100.68,61.2) 100.94,60.93 ; v14(100.68,61.2) 100.67,61.2 100.4,61.47 ; 91.74,61.47 92.01,61.2 v14(92.01,61.2) ; v14(97.53,61.2) 97.52,61.2 97.25,61.47 ; v14(97.53,61.2) 97.79,60.93 ; v14(97.53,61.2) 97.8,61.46 ; v14(97.53,61.2) 97.23,60.9 ; v14(100.68,61.9) 100.67,61.9 100.4,62.18 ; v14(100.68,61.9) 100.94,61.64 ; v14(100.68,61.9) 100.95,62.17 ; v14(100.68,61.9) 100.38,61.61 ; 90.95,62.18 91.22,61.9 v14(91.23,61.9) ; 89.52,76.93 UC1.AB16 ; UC1.AB16 89.25,76.66 88.97,76.93 ; UC1.AB16 89.51,76.4 ; UC1.AB16 88.96,76.37 ; 91.72,61.61 v14(92.01,61.9) ; v14(92.01,61.9) 92.01,61.9 91.74,62.18 ; v14(92.01,61.9) 92.28,61.64 ; v14(92.01,61.9) 92.28,62.17 ; v14(95.95,61.2) 95.95,61.2 95.67,61.47 ; v14(95.95,61.2) 96.22,61.46 ; v14(95.95,61.2) 95.66,60.9 ; v14(95.95,61.2) 96.21,60.93 ; v14(95.95,61.9) 95.95,61.9 95.67,62.18 ; v14(95.95,61.9) 96.22,62.17 ; v14(95.95,61.9) 95.66,61.61 ; v14(95.95,61.9) 96.21,61.64 ; 89.36,60.9 v14(89.65,61.2) ; v14(89.65,61.2) 89.91,60.93 ; v14(89.65,61.2) 89.92,61.46 ; v14(89.65,61.2) 89.65,61.2 89.37,61.47 ; v14(100.68,62.55) 100.94,62.29 ; v14(100.68,62.55) 100.38,62.26 ; v14(100.68,62.55) 100.67,62.55 100.4,62.83 ; v14(100.68,62.55) 100.95,62.82 ; UC1.AY16 102.01,76.4 ; UC1.AY16 102.02,76.93 ; UC1.AY16 101.45,76.37 ; UC1.AY16 101.75,76.66 101.47,76.93 ; 98.03,61.47 98.31,61.2 v14(98.31,61.2) ; 86.78,76.93 UC1.V16 ; UC1.V16 86.21,76.37 ; UC1.V16 86.51,76.66 86.23,76.93 ; UC1.V16 86.77,76.4 ; 100.56,76.93 100.83,76.66 UC1.AW16 ; 93.3,61.61 v14(93.59,61.9) ; v14(93.59,61.9) 93.59,61.9 93.31,62.18 ; v14(93.59,61.9) 93.86,62.17 ; v14(93.59,61.9) 93.85,61.64 ; v14(90.44,61.2) 90.44,61.2 90.16,61.47 ; v14(90.44,61.2) 90.7,60.93 ; v14(90.44,61.2) 90.15,60.9 ; v14(90.44,61.2) 90.71,61.46 ; v14(96.74,61.9) 96.74,61.9 96.46,62.18 ; v14(96.74,61.9) 97,61.64 ; v14(96.74,61.9) 97.01,62.17 ; v14(96.74,61.9) 96.45,61.61 ; UC1.AP16 97.17,76.66 96.9,76.93 ; UC1.AP16 97.44,76.4 ; UC1.AP16 97.45,76.93 ; UC1.AP16 96.88,76.37 ; UC1.AV16 100.19,76.93 ; UC1.AV16 100.18,76.4 ; UC1.AV16 99.92,76.66 99.64,76.93 ; UC1.AV16 99.63,76.37 ; UC1.AL16 95.19,76.66 94.92,76.93 ; UC1.AL16 95.46,76.93 ; UC1.AL16 95.46,76.4 ; UC1.AL16 94.9,76.37 ; v14(93.59,62.55) 93.85,62.29 ; v14(93.59,62.55) 93.59,62.55 93.31,62.83 ; v14(93.59,62.55) 93.3,62.26 ; v14(93.59,62.55) 93.86,62.82 ; 101.17,62.26 v14(101.46,62.55) ; v14(101.46,62.55) 101.73,62.82 ; v14(101.46,62.55) 101.73,62.29 ; v14(101.46,62.55) 101.46,62.55 101.18,62.83 ; v14(89.65,62.55) 89.91,62.29 ; v14(89.65,62.55) 89.65,62.55 89.37,62.83 ; v14(89.65,62.55) 89.92,62.82 ; v14(89.65,62.55) 89.36,62.26 ; UC1.AK16 94.54,76.4 ; UC1.AK16 93.99,76.37 ; UC1.AK16 94.28,76.66 94,76.93 ; UC1.AK16 94.55,76.93 ; 98.03,62.18 98.31,61.9 v14(98.31,61.9) ; 87.69,76.93 UC1.W16 ; UC1.W16 87.68,76.4 ; UC1.W16 87.13,76.37 ; UC1.W16 87.42,76.66 87.14,76.93 ; v14(88.86,61.9) 88.86,61.9 88.59,62.18 ; v14(88.86,61.9) 89.13,62.17 ; v14(88.86,61.9) 88.57,61.61 ; v14(88.86,61.9) 89.13,61.64 ; 98.81,62.26 v14(99.1,62.55) ; v14(99.1,62.55) 99.36,62.29 ; v14(99.1,62.55) 99.37,62.82 ; v14(99.1,62.55) 99.1,62.55 98.82,62.83 ; 91.72,62.26 v14(92.01,62.55) ; v14(92.01,62.55) 92.28,62.29 ; v14(92.01,62.55) 92.01,62.55 91.74,62.83 ; v14(92.01,62.55) 92.28,62.82 ; v14(94.38,61.9) 94.37,61.9 94.1,62.18 ; v14(94.38,61.9) 94.08,61.61 ; v14(94.38,61.9) 94.65,62.17 ; v14(94.38,61.9) 94.64,61.64 ; 96.46,62.83 96.74,62.55 v14(96.74,62.55) ; 87.85,61.42 88.07,61.2 UC1.Y39 ; 85.32,76.93 85.59,76.66 UC1.U16 ; v14(96.74,62.55) 97.01,62.82 ; v14(96.74,62.55) 97,62.29 ; v14(96.74,62.55) 96.45,62.26 ; UC1.AA16 88.6,76.4 ; UC1.AA16 88.61,76.93 ; UC1.AA16 88.33,76.66 88.06,76.93 ; UC1.AA16 88.04,76.37 ; 92.52,61.47 92.8,61.2 v14(92.8,61.2) ; 93.31,61.47 93.59,61.2 v14(93.59,61.2) ; v14(91.23,62.55) 91.22,62.55 90.95,62.83 ; v14(91.23,62.55) 91.5,62.82 ; v14(91.23,62.55) 90.93,62.26 ; v14(91.23,62.55) 91.49,62.29 ; v14(101.46,61.2) 101.73,60.93 ; v14(101.46,61.2) 101.46,61.2 101.18,61.47 ; v14(101.46,61.2) 101.73,61.46 ; v14(101.46,61.2) 101.17,60.9 ; 90.04,76.93 90.32,76.66 UC1.AD16 ; v14(99.89,61.2) 99.89,61.2 99.61,61.47 ; v14(99.89,61.2) 100.16,61.46 ; v14(99.89,61.2) 100.15,60.93 ; v14(99.89,61.2) 99.59,60.9 ; UC1.Y39 88.34,60.93 ; UC1.Y39 88.35,61.46 ; UC1.Y39 87.86,60.98 ; 90.93,61.61 v14(91.23,61.9) ; v14(91.23,61.9) 91.49,61.64 ; v14(91.23,61.9) 91.5,62.17 ; 101.17,61.61 v14(101.46,61.9) ; v14(101.46,61.9) 101.73,61.64 ; v14(101.46,61.9) 101.73,62.17 ; v14(101.46,61.9) 101.46,61.9 101.18,62.18 ; UC1.P16 84.03,76.4 ; UC1.P16 84.03,76.93 ; UC1.P16 83.76,76.66 83.49,76.93 ; UC1.P16 83.47,76.37 ; 94.08,62.26 v14(94.38,62.55) ; v14(94.38,62.55) 94.37,62.55 94.1,62.83 ; v14(94.38,62.55) 94.64,62.29 ; v14(94.38,62.55) 94.65,62.82 ; v14(99.1,61.2) 99.1,61.2 98.82,61.47 ; v14(99.1,61.2) 99.36,60.93 ; v14(99.1,61.2) 99.37,61.46 ; v14(99.1,61.2) 98.81,60.9 ; 90.02,76.37 UC1.AD16 ; UC1.AD16 90.59,76.93 ; UC1.AD16 90.58,76.4 ; UC1.U16 85.86,76.4 ; UC1.U16 85.86,76.93 ; UC1.U16 85.3,76.37 ; v14(92.8,61.2) 93.06,60.93 ; v14(92.8,61.2) 92.51,60.9 ; v14(92.8,61.2) 93.07,61.46 ; 84.39,76.37 UC1.R16 ; UC1.R16 84.68,76.66 84.4,76.93 ; UC1.R16 84.95,76.93 ; UC1.R16 84.94,76.4 ; UC1.AN16 96.26,76.66 95.98,76.93 ; UC1.AN16 96.53,76.93 ; UC1.AN16 96.52,76.4 ; UC1.AN16 95.97,76.37 ; 98.73,76.93 99,76.66 UC1.AU16 ; UC1.AW16 100.54,76.37 ; UC1.AW16 101.1,76.93 ; UC1.AW16 101.1,76.4 ; v14(94.38,61.2) 94.65,61.46 ; v14(94.38,61.2) 94.64,60.93 ; v14(94.38,61.2) 94.08,60.9 ; v14(94.38,61.2) 94.37,61.2 94.1,61.47 ; UC1.AU16 99.27,76.4 ; UC1.AU16 98.71,76.37 ; UC1.AU16 99.27,76.93 ; 98.02,62.26 v14(98.31,62.55) ; v14(98.31,62.55) 98.58,62.29 ; v14(98.31,62.55) 98.31,62.55 98.03,62.83 ; v14(98.31,62.55) 98.58,62.82 ; 101.97,62.18 102.25,61.9 v14(102.25,61.9) 101.96,61.61 ; 92.92,76.37 UC1.AH16 ; UC1.AH16 93.48,76.93 ; UC1.AH16 93.21,76.66 92.94,76.93 ; UC1.AH16 93.48,76.4 ; v14(88.86,61.2) 88.86,61.2 88.59,61.47 ; v14(88.86,61.2) 89.13,61.46 ; v14(88.86,61.2) 88.57,60.9 ; v14(88.86,61.2) 89.13,60.93 ; v14(91.23,61.2) 91.5,61.46 ; v14(91.23,61.2) 91.49,60.93 ; v14(91.23,61.2) 90.93,60.9 ; v14(91.23,61.2) 91.22,61.2 90.95,61.47 ; 89.37,62.18 89.65,61.9 v14(89.65,61.9) ; UC1.AT16 98.35,76.4 ; UC1.AT16 98.36,76.93 ; UC1.AT16 98.09,76.66 97.81,76.93 ; UC1.AT16 97.8,76.37 ; v14(93.59,61.2) 93.86,61.46 ; v14(93.59,61.2) 93.3,60.9 ; v14(93.59,61.2) 93.85,60.93 ; v14(92.01,61.2) 92.28,61.46 ; v14(92.01,61.2) 91.72,60.9 ; v14(92.01,61.2) 92.28,60.93 ; 101.96,62.26 v14(102.25,62.55) ; v14(102.25,62.55) 102.25,62.55 101.97,62.83 ; v14(102.25,62.55) 102.52,62.82 ; v14(95.16,61.2) 95.43,60.93 ; v14(95.16,61.2) 95.16,61.2 94.89,61.47 ; v14(95.16,61.2) 95.43,61.46 ; v14(95.16,61.2) 94.87,60.9 ; v14(98.31,61.9) 98.58,61.64 ; v14(98.31,61.9) 98.02,61.61 ; v14(98.31,61.9) 98.58,62.17 ; UC1.AG16 92.3,76.66 92.02,76.93 ; UC1.AG16 92.56,76.4 ; UC1.AG16 92.01,76.37 ; UC1.AG16 92.57,76.93 ; 102.38,76.93 102.66,76.66 UC1.BB16 102.37,76.37 ; 89.36,61.61 v14(89.65,61.9) ; v14(89.65,61.9) 89.92,62.17 ; v14(89.65,61.9) 89.91,61.64 ; v14(98.31,61.2) 98.58,60.93 ; v14(98.31,61.2) 98.02,60.9 ; v14(98.31,61.2) 98.58,61.46 ; v14(99.1,61.9) 99.37,62.17 ; v14(99.1,61.9) 99.1,61.9 98.82,62.18 ; v14(99.1,61.9) 99.36,61.64 ; v14(99.1,61.9) 98.81,61.61
  vias: v2(92.64,76.28) v2(92.64,75.65) v2(95.31,76.28) v2(95.31,75.65) v2(98.36,76.28) v2(98.36,75.65) v2(99.75,60.92) v2(100.9,76.28) v2(100.9,75.65) v2(102.68,76.27) v2(102.68,75.63) v5(69.82,48.09) v5(69.82,47.58) v5(70.33,48.6) v5(70.33,48.09) v5(70.33,47.58) v5(70.33,47.07) v5(70.84,48.6) v5(70.84,48.09) v5(70.84,47.58) v5(70.84,47.07) v5(71.35,48.6) v5(71.35,48.09) v5(71.35,47.58) v5(71.35,47.07) v5(71.85,48.6) v5(71.85,48.09) v5(71.85,47.58) v5(71.85,47.07) v5(72.36,48.09) v5(72.36,47.58) v5(77.31,44.53) v5(77.82,44.53) v5(77.95,48.09) v5(77.95,47.58) v5(78.33,44.53) v5(78.46,48.6) v5(78.46,48.09) v5(78.46,47.58) v5(78.46,47.07) v5(78.84,44.53) v5(78.97,48.6) v5(78.97,48.09) v5(78.97,47.58) v5(78.97,47.07) v5(79.47,48.6) v5(79.47,48.09) v5(79.47,47.58) v5(79.47,47.07) v5(79.98,48.6) v5(79.98,48.09) v5(79.98,47.58) v5(79.98,47.07) v5(80.49,48.09) v5(80.49,47.58) v5(82.01,47.33) v5(82.27,46.69) v5(82.52,47.33) v5(82.78,46.69) v5(83.03,47.33) v5(83.54,47.33) v5(87.51,45.03) v5(87.51,44.52) v5(87.51,44.01) v5(87.51,43.5) v5(87.82,59.57) v5(87.82,58.27) v5(88.14,44.27) v5(88.14,43.76) v5(88.61,62.23) v5(88.61,60.87) v5(88.61,58.27) v5(89.4,59.57) v5(89.4,58.27) v5(90.19,60.87) v5(90.19,59.57) v5(90.19,58.27) v5(90.19,56.97) v5(90.97,62.23) v5(90.97,60.87) v5(90.97,58.27) v5(90.97,56.97) v5(91.76,60.87) v5(91.76,62.23) v5(91.76,59.57) v5(91.76,58.27) v5(92.55,59.57) v5(92.55,58.27) v5(92.55,56.97) v5(93.34,60.87) v5(93.34,58.27) v5(93.34,56.97) v5(94.12,62.23) v5(94.12,60.87) v5(94.12,59.57) v5(94.12,58.27) v5(94.91,60.87) v5(94.91,59.57) v5(94.91,58.27) v5(94.91,56.97) v5(95.7,60.87) v5(95.7,58.27) v5(95.7,56.97) v5(96.48,62.23) v5(96.48,60.87) v5(96.48,59.57) v5(96.48,58.27) v5(97.27,60.87) v5(97.27,59.57) v5(97.27,58.27) v5(97.27,56.97) v5(98.06,62.23) v5(98.06,60.87) v5(98.06,58.27) v5(98.06,56.97) v5(98.85,60.87) v5(98.85,59.57) v5(98.85,58.27) v5(99.63,60.87) v5(99.63,59.57) v5(99.63,58.27) v5(99.63,56.97) v5(100.42,62.23) v5(100.42,60.87) v5(100.42,58.27) v5(100.42,56.97) v5(101.21,62.23) v5(101.21,60.87) v5(101.21,59.57) v5(101.2,58.27) v5(102,62.23) v5(102,59.57) v5(102,58.27) v5(102,56.97) v6(70.08,48.34) v6(70.08,47.83) v6(70.08,47.33) v6(70.58,48.34) v6(70.58,47.83) v6(70.58,47.33) v6(71.09,48.34) v6(71.09,47.83) v6(71.09,47.33) v6(71.6,48.34) v6(71.6,47.83) v6(71.6,47.33) v6(72.11,48.34) v6(72.11,47.83) v6(72.11,47.33) v6(78.2,48.34) v6(78.2,47.83) v6(78.2,47.33) v6(78.71,48.34) v6(78.71,47.83) v6(78.71,47.33) v6(79.22,48.34) v6(79.22,47.83) v6(79.22,47.33) v6(79.73,48.34) v6(79.73,47.83) v6(79.73,47.33) v6(80.24,48.34) v6(80.24,47.83) v6(80.24,47.33) v6(82.01,46.95) v6(82.27,47.07) v6(82.52,46.95) v6(82.78,47.07) v6(83.03,46.95) v6(83.28,47.07) v6(87.76,44.77) v6(87.76,44.27) v6(87.76,43.76) v6(87.89,44.52) v6(87.89,44.01) v6(87.89,43.5) v7(70.08,47.33) v7(70.08,46.82) v7(70.33,46.69) v7(70.58,47.33) v7(70.58,46.82) v7(70.84,46.69) v7(71.09,47.33) v7(71.09,46.82) v7(71.35,46.69) v7(71.6,47.33) v7(71.6,46.82) v7(71.85,46.69) v7(72.11,47.33) v7(72.11,46.82) v7(72.23,47.07) v7(77.31,44.15) v7(77.44,47.07) v7(77.44,46.69) v7(77.57,44.28) v7(77.7,47.07) v7(77.7,46.69) v7(77.82,44.15) v7(77.95,47.07) v7(77.95,46.69) v7(78.08,44.28) v7(78.2,46.82) v7(78.33,44.15) v7(78.46,46.69) v7(78.58,44.28) v7(78.71,46.82) v7(78.97,46.69) v7(79.22,46.82) v7(79.47,46.69) v7(79.73,46.82) v7(79.98,46.69) v7(80.24,46.82) v7(82.01,46.95) v7(82.27,47.07) v7(82.52,46.95) v7(82.78,47.07) v7(83.03,46.95) v7(83.28,47.07) v7(87.76,44.77) v7(87.76,44.27) v7(87.76,43.76) v7(87.89,44.52) v7(87.89,44.01) v7(87.89,43.5) v7(89.29,63.58) v7(96.07,61.55) v7(96.07,60.92) v7(98.5,61.49) v7(98.5,60.85) v7(100.34,61.55) v7(101.85,61.55) v7(101.85,60.92) v7(102,62.56) v7(103.34,70.78) v7(103.34,69.75) v7(103.36,68.73) v7(103.49,76.9) v7(103.53,75.95) v7(103.56,75) v7(103.52,73.94) v7(103.52,73.56) v9(73.25,47.85) v9(73.25,47.26) v9(73.83,47.85) v9(73.83,47.26) v9(74.42,47.85) v9(74.42,47.26) v9(75,47.85) v9(75,47.26) v9(75.59,47.85) v9(75.59,47.26) v9(75.93,51.9) v9(75.93,51.26) v9(75.93,50.63) v9(75.93,49.99) v9(76.17,47.26) v9(76.49,51.9) v9(76.49,51.26) v9(76.49,50.63) v9(76.49,49.99) v9(78.7,51.71) v9(78.7,51.07) v9(78.7,50.44) v9(78.7,49.8) v9(79.33,51.71) v9(79.33,51.07) v9(79.33,50.44) v9(79.33,49.8) v9(79.98,51.71) v9(79.98,51.07) v9(79.98,50.44) v9(79.98,49.8) v9(80.43,49.05) v9(80.55,45.42) v9(80.55,44.84) v9(81.02,49.05) v9(81.19,45.42) v9(81.19,44.84) v9(81.65,49.05) v9(81.82,45.42) v9(81.82,44.84) v9(82.29,49.05) v9(82.46,45.42) v9(82.46,44.84) v9(82.92,49.05) v9(83.09,45.42) v9(83.09,44.84) v9(83.56,49.05) v9(83.73,45.42) v9(83.73,44.84) v9(84.24,76.99) v9(84.19,49.05) v9(84.36,47.39) v9(84.36,46.82) v9(84.93,47.39) v9(84.95,46.82) v9(85.15,76.99) v9(86.06,76.99) v9(86.98,76.99) v9(87.89,76.99) v9(88.19,52.04) v9(88.19,51.2) v9(88.19,50.36) v9(88.62,49.1) v9(88.74,55.39) v9(88.74,54.55) v9(88.74,52.88) v9(88.67,44.79) v9(88.68,44.15) v9(88.68,43.52) v9(88.81,76.99) v9(89.25,47.39) v9(89.25,46.82) v9(89.32,44.79) v9(89.32,44.15) v9(89.32,43.52) v9(89.51,49.1) v9(89.58,55.39) v9(89.58,54.55) v9(89.58,53.71) v9(89.58,52.88) v9(89.79,76.99) v9(89.82,47.39) v9(89.84,46.82) v9(89.95,44.79) v9(89.95,44.15) v9(89.95,43.52) v9(90.31,52.04) v9(90.31,51.2) v9(90.33,50.37) v9(90.33,49.49) v9(90.42,55.39) v9(90.42,54.55) v9(90.42,53.71) v9(90.42,52.88) v9(90.4,47.39) v9(90.41,46.82) v9(90.59,44.79) v9(90.59,44.15) v9(90.59,43.52) v9(90.79,76.99) v9(91.26,55.39) v9(91.26,54.55) v9(91.26,53.71) v9(91.26,52.88) v9(91.78,76.99) v9(92.1,55.39) v9(92.1,54.55) v9(92.1,53.71) v9(92.1,52.88) v9(92.77,76.99) v9(92.94,55.39) v9(92.94,54.55) v9(92.94,53.71) v9(92.94,52.88) v9(92.94,52.04) v9(92.94,51.2) v9(93.76,76.99) v9(93.77,55.39) v9(93.77,54.55) v9(93.77,53.71) v9(93.77,52.88) v9(94.61,55.39) v9(94.61,54.55) v9(94.61,53.71) v9(94.61,52.88) v9(94.75,76.99) v9(95.22,52.04) v9(95.22,51.2) v9(95.22,50.36) v9(95.22,49.52) v9(95.45,55.39) v9(95.45,54.55) v9(95.45,53.71) v9(95.45,52.88) v9(95.74,76.99) v9(95.92,52.03) v9(96.29,55.39) v9(96.29,54.55) v9(96.29,53.71) v9(96.29,52.88) v9(96.73,76.99) v9(97.13,55.39) v9(97.13,54.55) v9(97.13,53.71) v9(97.13,52.88) v9(97.65,76.99) v9(97.96,55.39) v9(97.96,54.55) v9(97.96,53.71) v9(97.96,52.88) v9(98.09,52.04) v9(98.09,51.2) v9(98.09,50.36) v9(98.09,49.52) v9(98.56,76.99) v9(98.6,48.68) v9(98.8,55.39) v9(98.8,54.55) v9(98.8,53.71) v9(98.8,52.88) v9(99.44,48.68) v9(99.48,76.99) v9(99.64,55.39) v9(99.64,54.55) v9(99.64,53.71) v9(99.64,52.88) v9(100.28,48.68) v9(100.28,47.85) v9(100.28,47.01) v9(100.28,46.17) v9(100.39,76.99) v9(100.48,55.39) v9(100.48,54.55) v9(100.48,53.71) v9(100.48,52.88) v9(101.11,52.04) v9(101.11,51.2) v9(101.11,50.36) v9(101.11,49.52) v9(101.11,48.68) v9(101.11,47.85) v9(101.11,47.01) v9(101.11,46.17) v9(101.3,76.99) v9(101.32,55.39) v9(101.32,54.55) v9(101.32,53.71) v9(101.32,52.88) v9(101.95,52.04) v9(101.95,51.2) v9(101.95,50.36) v9(102.16,52.88) v9(102.22,76.99) v16(76.29,48.84)
