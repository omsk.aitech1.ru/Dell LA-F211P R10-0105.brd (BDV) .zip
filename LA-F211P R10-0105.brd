# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CCG5_POWERSHARE_VBUS_EN1#: length 97.3
  TOP w0.127: v2(39.39,73.05) 39.22,73.22 UC4.1 ; v9(41.93,10.64) 42,10.64 UE3.J3
  IN1 w0.064: v2(39.39,73.05) 39.39,71.91 38.59,71.11 38.59,68.53 38.43,68.36 38.43,63.97 36.78,62.33 33.78,62.33 33.6,62.15 26.52,62.15 21.62,57.24 21.62,55.39 20.12,53.89 20.12,51.56 19.39,50.83 19.39,48.96 19.85,48.51 19.85,47.67 19.62,47.44 19.62,44.11 19.02,43.52 19.02,43.06 18.23,42.27 18.23,40.19 18.49,39.93 v4(18.49,39.48)
  GND2 w0.102: v4(18.49,39.48) 18.49,39.45 v5(18.16,39.12)
  GND3 w0.102: v5(18.16,39.12) 18.27,39.01 v8(18.51,39.01)
  IN3 w0.064: v9(41.93,10.64) 41.93,9.93 41.33,9.33 38.43,9.33 38.09,9.33 37.57,9.85 35.91,9.85 35.6,10.15 34.03,10.15 32.36,11.82 32.02,11.82 28.95,14.89 28.95,15.31 27.74,16.52 27.74,18.95 27.21,19.49 27.21,22.32 27.83,22.95 27.83,24.92 25.76,26.99 25.76,27.61 24.09,29.28 24.09,29.48 18.64,34.93 18.64,38.88 v8(18.51,39.01)
CCG5_POWERSHARE_VBUS_EN2#: length 79.4
  TOP w0.127: v1(27.97,62.5) 27.97,62.57 v2(28.29,62.88) 28.8,63.39 UC5.1
  IN1 w0.064: v4(20.79,55.12) 21.48,55.82 21.48,57.3 27.06,62.88 v2(28.29,62.88)
  GND2 w0.102: v5(48.44,8.65) 48.39,8.59 v7(47.95,8.59) ; v4(20.79,55.12) v5(20.79,54.7)
  IN2 w0.074: v5(28.53,31.37) 28.34,31.55 24.39,31.55 22.73,33.21 22.73,35.82 23.77,36.86 23.77,40.69 23.15,41.32 23.15,42.06 23.52,42.43 23.52,50 23.01,50.51 23.01,51.12 20.57,53.56 20.57,54.48 v5(20.79,54.7)
  GND3 w0.102: v5(48.44,8.65) 48.44,8.89 v8(48.26,9.07) ; v8(28.76,31.13) v5(28.53,31.37)
  IN3 w0.064: v8(48.26,9.07) 48.26,10.57 45.85,12.98 45.85,13.68 45.57,13.96 41.32,13.96 40.45,14.83 38.01,14.83 33.65,19.19 33.65,20.81 33.09,21.37 33.09,26.28 28.76,30.62 v8(28.76,31.13)
CCG5_POWERSHARE_VBUS_EN3#: length 77.3
  TOP w0.127: v7(42.78,11.28) 42.66,11.41 42.07,11.41 41.65,10.99 UE3.J2
  GND2 w0.102: v5(42.8,11.65) 42.78,11.64 v7(42.78,11.28)
  GND3 w0.102: v8(43.15,11.83) 42.97,11.65 v5(42.8,11.65)
  IN3 w0.064: v8(43.15,11.83) 43.18,11.83 43.39,11.61 44.3,11.61 45.74,10.17 45.74,9.73 45.74,9.61 45.5,9.37 45.5,6.73 45.93,6.31 46.14,6.31 46.73,5.72 50.46,5.72 50.95,6.22 52.89,6.22 53.88,5.22 55.22,5.22 56.2,4.24 56.42,4.24 56.77,4.24 57.14,3.87 59.29,3.87 60.47,2.69 74.01,2.69 74.26,2.44 77.87,2.44 78.6,3.17 80.57,3.17 80.73,3 v3(80.82,3) ; v6(105.06,10.9) 104.82,10.66 104.25,10.66 103.83,10.25 103.37,10.25 103.3,10.33 102.92,10.33 102.39,9.8 99.82,9.8 98.48,8.46 94.59,8.46 94.41,8.64 86.93,8.64 86.5,8.21 84.98,8.21 84.62,8.58 v3(84.62,8.78)
  BOTTOM w0.127: v3(84.62,8.78) v1(84.3,9.1) 83.88,9.1 83.07,8.28 83.07,7.49 80.82,5.24 80.82,3 v3(80.82,3)
CCG5_POWERSHARE_VBUS_EN4#: length 72.7
  TOP w0.127: v7(45.95,11) 45.95,11.07 45.66,11.36 45.4,11.36 45.03,10.99 UE3.J6
  GND2 w0.102: v5(46,10.47) 45.95,10.52 v7(45.95,11)
  GND3 w0.102: v5(46,10.47) 46.14,10.32 v8(46.14,9.9)
  IN3 w0.064: v3(84.49,8.33) 84.63,8.33 84.89,8.07 86.56,8.07 86.99,8.5 94.35,8.5 94.53,8.32 98.54,8.32 99.88,9.66 102.45,9.66 102.98,10.19 103.24,10.19 103.32,10.11 103.89,10.11 104.29,10.51 105.04,10.51 105.43,10.9 v3(106.06,10.9) ; v3(81.2,3.36) 81.11,3.45 78.48,3.45 77.75,2.72 74.38,2.72 74.13,2.97 60.59,2.97 59.39,4.16 57.24,4.16 56.89,4.52 56.32,4.52 55.34,5.5 54,5.5 53,6.5 50.84,6.5 50.4,6.06 49.24,6.06 48.69,6.61 46.86,6.61 45.78,7.69 45.78,9.25 46.14,9.61 v8(46.14,9.9)
  BOTTOM w0.127: v3(81.2,3.36) 81.2,5.09 v1(83.93,7.82) 84.45,8.33 v3(84.49,8.33)
CCG5_SMBCLK: length 163.7
  TOP w0.089: UE3.C3 42.66,16.1 42.66,18.46 42.88,18.68
  TOP w0.127: 42.88,18.68 43.18,18.99 43.18,19.44 v2(43.02,19.6) ; v7(57.72,21.8) 57.57,21.65 v1(57.57,20.53) 58,20.1 58,18.12 58.26,17.86 v2(58.26,17.8)
  IN1 w0.064: v9(34.38,64.51) 34.4,64.51 34.66,64.78 34.66,64.88 34.8,65.01 35.43,65.01 35.58,65.16 35.58,65.56 36.07,66.05 36.07,68.49 36.18,68.6 v4(36.32,68.6) ; v2(43.02,19.6) 43.6,19.02 46.5,19.02 46.76,19.29 54.99,19.29 55.57,18.71 55.73,18.71 56.88,17.56 58.01,17.56 v2(58.26,17.8) 58.38,17.93 60.66,17.93 65.02,13.58 68.14,13.58 71.15,10.57 77.37,10.57 78.86,9.08 82.23,9.08 83.47,7.84 84.93,7.84 85.3,7.47 99.66,7.47 101.1,8.9 103.83,8.9 v4(104.3,9.37)
  GND2 w0.102: v4(104.3,9.37) v5(104.87,9.37) ; v5(57.39,21.74) 57.46,21.8 v7(57.72,21.8) ; v4(36.32,68.6) 36.32,68.84 v5(36.44,68.96)
  IN2 w0.074: v9(34.38,64.51) 34.38,64.49 34.74,64.14 37.26,64.14 37.74,63.65 37.74,62.49 38.75,61.49 39.41,61.49 39.76,61.13 39.76,56.15 41.69,54.22 42.15,54.22 46.64,49.73 46.64,41.15 45.9,40.41 45.9,37.49 44.36,35.95 42.85,35.95 42.26,35.35 42.26,25.42 43.44,24.23 44.02,24.23 45.4,22.86 47.45,22.86 47.84,23.25 52.27,23.25 52.71,22.82 55.87,22.82 56.95,21.74 v5(57.39,21.74)
  GND3 w0.102: v5(104.87,9.37) 105.38,9.37 v6(105.39,9.36) ; v5(36.44,68.96) 36.57,69.09 36.79,69.09 v15(37.13,69.44) ; v6(57.39,21.41) v5(57.39,21.74)
  IN3 w0.064: v3(32.99,69.61) 33.25,69.35 33.73,69.35 34.1,68.99 34.81,68.99 35.12,69.29 35.79,69.29 35.94,69.44 v15(37.13,69.44)
  GND4 w0.102: v15(37.13,69.44) 37.51,69.82 37.66,69.82 37.72,69.77 v14(37.72,69.63)
  BOTTOM w0.076: UPD1.L6 32.94,70.29 32.94,69.67 v3(32.99,69.61)
  BOTTOM w0.102: v6(105.39,9.36) 105.42,9.38 106.54,9.38 JIO1.M8
  BOTTOM w0.127: v6(57.39,21.41) 57.39,20.76 57.56,20.6 59.41,20.6 59.86,21.04 JCCG1.6 ; RP104.2 33.87,64 v9(34.38,64.51)
CCG5_SMBDAT: length 160.6
  TOP w0.089: 43.2,18.65 42.83,18.28 42.83,16.27 42.9,16.21 43.02,16.21 43.15,16.34 UE3.B4
  TOP w0.127: 43.2,18.65 43.44,18.88 43.44,19.44 v2(43.6,19.6) ; v2(57.89,17.82) 57.89,17.86 57.79,17.95 57.79,19.73 57.23,20.29 v1(57.23,21.8) 57.23,21.96 v7(57.44,22.17)
  IN1 w0.064: v4(36.67,69.32) 36.67,68.54 36.21,68.07 36.21,65.99 35.72,65.5 35.72,65.1 35.49,64.88 34.86,64.88 34.8,64.82 34.8,64.68 v9(34.97,64.51) ; v9(99.86,8.23) 99.24,7.61 85.35,7.61 84.79,8.17 84.17,8.17 83.11,9.23 78.95,9.23 77.46,10.71 71.24,10.71 68.24,13.72 65.08,13.72 60.72,18.07 58.14,18.07 v2(57.89,17.82) 56.82,17.82 55.79,18.85 55.63,18.85 55.05,19.43 46.71,19.43 46.44,19.16 44.03,19.16 v2(43.6,19.6)
  GND2 w0.102: v5(57.05,22.11) 57.11,22.17 v7(57.44,22.17) ; v4(36.67,69.32) 36.67,69.49 v5(36.53,69.63)
  IN2 w0.074: v9(34.97,64.51) 35.19,64.29 37.32,64.29 37.89,63.72 37.89,63.34 39.91,61.32 39.91,56.21 41.75,54.37 42.21,54.37 46.79,49.79 46.79,41.09 46.1,40.39 46.1,37.41 44.44,35.75 42.86,35.75 42.41,35.29 42.41,25.48 43.5,24.38 44.09,24.38 45.46,23.01 47.39,23.01 47.77,23.4 52.34,23.4 52.77,22.96 56.2,22.96 v5(57.05,22.11)
  GND3 w0.102: v5(36.53,69.63) 36.75,69.63 v15(36.86,69.74) ; v6(56.74,22.44) 56.74,22.43 v5(57.05,22.11)
  IN3 w0.064: v3(33.37,69.61) 33.49,69.49 33.79,69.49 34.15,69.13 34.76,69.13 35.08,69.45 35.69,69.45 35.98,69.74 v15(36.86,69.74)
  GND4 w0.102: v15(36.86,69.74) 37.16,69.74 37.42,70.01 37.51,70.01 v14(37.72,70.21)
  BOTTOM w0.076: UPD1.K6 v3(33.37,69.61)
  BOTTOM w0.127: v9(34.97,64.51) 34.48,64.03 RP105.2 ; v6(56.74,22.44) 56.74,20.66 57.13,20.26 59.52,20.26 60.36,21.1 JCCG1.5 ; JIO1.Q11 102.8,6.9 102.6,6.7 101.56,6.7 100.03,8.23 v9(99.86,8.23)
CCG5_SWD_CLK1: length 82.3
  TOP w0.127: v1(29.61,65.04) 29.94,65.37 RP33.1 30.73,66.24 v7(30.75,66.22)
  GND2 w0.102: v5(30.9,66.69) 30.9,66.37 v7(30.75,66.22)
  IN2 w0.074: v5(30.9,66.69) 30.9,66.69 32.1,66.69 32.15,66.74 32.38,66.74 32.77,67.13 33.09,67.13 33.27,66.95 33.56,66.95 33.74,67.13 34.08,67.13 34.32,66.88 34.32,66.73 34.19,66.59 34.19,66.38 33.63,65.82 33.63,64.45 34.92,63.15 36.66,63.15 38.13,61.69 38.13,61.39 39.46,60.05 39.46,56.03 41.57,53.92 42.03,53.92 46.34,49.61 46.34,41.27 45.6,40.53 45.6,40.28 45.6,37.61 44.23,36.25 42.73,36.25 41.96,35.48 41.96,25.3 43.32,23.94 43.9,23.94 45.27,22.56 47.72,22.56 48.11,22.95 52.15,22.95 53.13,21.97 55.84,21.97 v5(55.85,21.98)
  GND3 w0.102: v6(55.9,21.6) 55.9,21.92 v5(55.85,21.98) ; v6(31.18,66.53) 31.01,66.69 v5(30.9,66.69)
  BOTTOM w0.127: JCCG1.3 61.36,20.57 60.57,19.79 56.44,19.79 55.9,20.33 v6(55.9,21.6)
CCG5_SWD_IO1: length 83.3
  TOP w0.127: v1(37.88,63.9) 37.69,64.09 RP98.2 v2(36.48,64.81)
  IN1 w0.064: v2(36.48,64.81) 36.2,64.81 35.52,64.13 34.12,64.13 32.81,65.44 31.63,65.44 31.38,65.68 v4(31.37,65.68)
  GND2 w0.102: v4(31.37,65.68) 31.03,65.68 v5(30.93,65.77)
  IN2 w0.074: v5(59.82,20.94) 59.63,20.75 57.22,20.75 56.34,21.63 53.25,21.63 52.09,22.8 48.17,22.8 47.79,22.41 45.21,22.41 43.84,23.79 43.25,23.79 41.81,25.23 41.81,35.54 42.67,36.4 44.17,36.4 45.45,37.68 45.45,40.22 45.45,40.59 46.19,41.33 46.19,49.54 41.96,53.77 41.5,53.77 39.31,55.96 39.31,59.99 37.98,61.32 37.98,61.62 36.6,63 34.83,63 33.12,64.72 33.12,64.85 32.55,65.42 32.55,65.68 32.23,66 31.59,66 31.37,65.77 v5(30.93,65.77)
  GND3 w0.102: v6(31.18,66.03) 31.18,66.02 v5(30.93,65.77) ; v6(60.23,20.53) v5(59.82,20.94)
  BOTTOM w0.127: JCCG1.4 60.86,20.9 60.49,20.53 v6(60.23,20.53)
CCG5_VBUS1_CSN_P1: length 15.3
  IN2 w0.152: v5(31.68,65.31) 30.44,65.31 27.56,68.19 27.56,68.53 27.19,68.9 27.19,71.75 v5(27.39,71.95)
  GND3 w0.152: v8(27.71,72.59) 27.71,72.27 v5(27.39,71.95) ; v6(31.68,66.03) v5(31.68,65.31)
  IN3 w0.152: v3(24.71,75.13) 25.94,75.13 27.71,73.36 v8(27.71,72.59)
CCG5_VBUS2_CSN_P2: length 42.6
  GND3 w0.152: v8(28.65,98.69) 28.9,98.44 v5(29.05,98.44)
  IN3 w0.152: v3(34.08,69.62) 34.12,69.65 34.12,70.39 33.99,70.52 33.99,71.71 33.72,71.98 33.72,72.51 32.84,73.39 32.84,74.76 32.89,74.81 32.89,84.07 32.46,84.5 31.89,84.5 31.67,84.28 31.02,84.28 30.39,84.92 27.97,84.92 26.51,86.38 26.51,91.6 27.09,92.17 30.5,92.17 31.84,93.5 31.84,97.4 30.29,98.95 28.91,98.95 v8(28.65,98.69)
  BOTTOM w0.152: UPD1.K8 v3(34.08,69.62)
  vias: v7(28.36,98.82) v7(28.67,98.89) v7(28.93,99.08)
CCG5_VBUS_5V_ON1: length 5.8
  TOP w0.254: 20.42,70.44 20.55,70.57 20.8,70.57 21.07,70.3 PQ216.3 ; 20.42,70.44 20.23,70.63 18.94,70.63 PR263.2 18.68,70.19 18.42,69.93 17.71,69.93 17.46,70.19 RP143.2 ; 20.42,70.44 PQ216.2
CCG5_VBUS_5V_ON1#: length 21.6
  TOP w0.127: v7(24,70.71) 23.49,70.71 22.91,71.29 PR110.1
  IN1 w0.064: v2(37.96,73.87) 37.79,73.87 37.41,73.48 35.42,73.48 34.11,72.17 32.05,72.17 31.69,71.81 29.21,71.81 v4(28.6,71.2)
  GND2 w0.102: v7(24,70.71) 24.08,70.63 v5(24.39,70.63) ; v5(28.6,70.86) v4(28.6,71.2)
  GND3 w0.102: v8(24.84,70.63) v5(24.39,70.63) ; v5(28.6,70.86) 28.6,70.57 v6(28.66,70.5)
  IN3 w0.064: v8(24.84,70.63) 24.96,70.5 v6(28.66,70.5)
  BOTTOM w0.076: 30.07,70.05 30.3,70.28 31.43,70.28 UPD1.K3
  BOTTOM w0.127: 30.07,70.05 29.76,69.74 v1(29.24,69.74) 28.66,70.33 v6(28.66,70.5)
CCG5_VBUS_5V_ON2: length 4.7
  TOP w0.127: PQ217.3 23.46,91.53 23.34,91.65 22.9,91.65 22.81,91.56 PQ217.2 22.81,90.2 PR265.2 22.95,90.01 23.28,89.68 24.2,89.68 RP144.2
CCG5_VBUS_5V_ON2#: length 45.7
  TOP w0.127: v7(26.84,89.53) 26.79,89.48 22.59,89.48 20.35,91.71 RP91.2 19.62,92.27 PR136.1 ; v7(32.73,65.8) 32.77,65.76 32.77,63.29 v1(32.23,62.76) 32.22,62.74 UC5.2
  GND2 w0.102: v5(32.11,65.61) 32.14,65.61 32.32,65.8 v7(32.73,65.8) ; v7(26.84,89.53) 26.78,89.46 v5(26.44,89.46)
  IN2 w0.074: v5(26.44,89.46) 26.63,89.27 26.63,87.22 27.19,86.65 27.19,78.74 26.36,77.9 26.36,69.23 27.11,68.47 27.11,68.1 27.34,67.88 27.59,67.88 30.53,64.93 31.96,64.93 32.14,65.11 32.14,65.59 v5(32.11,65.61)
  GND3 w0.102: v6(32.18,66.03) 32.11,65.96 v5(32.11,65.61)
CCG5_VBUS_DISCHARGE_P1: length 11.2
  BOTTOM w0.076: 36.29,68.57 35.99,68.27 35.04,68.27 34.9,68.41 34.9,69.24 UPD1.J10
  BOTTOM w0.127: 36.29,68.57 36.62,68.9 37.87,68.9 38.03,68.74 39.52,68.74 v1(40.04,68.22) 40.52,68.7 42.45,68.7 42.72,68.43 RP108.1 42.92,68.08 QP1.2
CCG5_VBUS_DISCHARGE_P2: length 9.5
  BOTTOM w0.076: UPD1.H10 35.43,68.78 36.05,68.78 36.29,69.02
  BOTTOM w0.127: 36.29,69.02 36.46,69.18 37.92,69.18 38.2,69.46 38.2,70.07 38.4,70.27 39.42,70.27 39.67,70.53 40.52,70.53 41.03,70.02 41.51,70.02 42.07,70.58 QP2.2 42.16,70.66 RP109.1
CCG5_XRES: length 82.6
  TOP w0.127: RP29.2 v7(33.18,69)
  GND2 w0.102: v7(33.18,69) v6(33.18,69.03) v5(32.94,69.27)
  IN2 w0.074: v5(32.94,69.27) 33.06,69.14 34.12,69.14 35.1,68.17 35.1,67.75 34.92,67.57 34.92,67.32 34.52,66.91 34.52,66.71 34.34,66.53 34.34,66.32 33.78,65.76 33.78,64.51 34.3,63.99 37.2,63.99 37.59,63.59 37.59,62.43 38.29,61.74 38.29,61.44 39.61,60.11 39.61,56.09 41.63,54.07 42.09,54.07 46.49,49.67 46.49,41.21 45.75,40.47 45.75,40.34 45.75,37.55 44.29,36.1 42.79,36.1 42.11,35.41 42.11,25.36 43.38,24.09 43.96,24.09 45.33,22.71 47.66,22.71 48.04,23.1 52.21,23.1 52.87,22.43 v5(55.15,22.43)
  GND3 w0.102: v5(32.94,69.27) 32.94,69.2 33.11,69.03 v6(33.18,69.03) ; v5(55.15,22.43) 55.15,22.37 v6(55.35,22.17)
  BOTTOM w0.127: JCCG1.2 61.86,20.18 61.26,19.58 56.36,19.58 55.35,20.59 v1(55.35,21.48) v6(55.35,22.17)
CD_WAKE#: length 4.1
  TOP w0.127: v1(25.88,60.79) 25.36,61.31 RR7.2 RR8.2 23.72,62.42 23.89,62.59 UR1.32
CFG0: length 29.5
  TOP w0.127: v7(146.79,94.17) 146.79,95.28 v1(146.82,95.32) 146.96,95.46 RH43.1
  GND2 w0.102: v5(146.79,93.75) v7(146.79,94.17)
  GND3 w0.102: v8(146.55,93.51) v5(146.79,93.75)
  IN3 w0.061: 136.21,78.44 134.63,78.44 133.51,77.32 131.57,77.32 131.1,76.85 v3(131.1,76.82)
  IN3 w0.064: 136.21,78.44 137.02,78.44 137.65,79.08 138.47,79.08 141.15,81.76 141.15,83.29 143.88,86.01 143.88,91.03 146.03,93.19 146.2,93.19 146.53,93.51 v8(146.55,93.51)
CFG1: length 12.2
  GND2 w0.102: v7(141.94,80.87) 141.84,80.87 v5(141.59,80.63)
  GND3 w0.102: v5(141.59,80.63) 141.55,80.63 v8(141.31,80.4)
  IN3 w0.061: 136.21,76.87 132.84,76.87 132.79,76.82 ; v3(131.75,76.82) 131.93,76.82 131.94,76.82
  IN3 w0.064: 131.94,76.82 132.2,76.55 132.52,76.55 132.79,76.82 ; v8(141.31,80.4) 141.31,80.27 139.55,78.5 137.98,78.5 136.35,76.87 136.21,76.87
CFG2: length 14.2
  GND2 w0.102: v5(138.53,84.44) 138.53,84.45 v7(138.2,84.45)
  GND3 w0.102: v5(138.53,84.44) 138.53,84.45 v8(138.19,84.45)
  IN3 w0.061: 136.21,83.71 135.04,83.71 133.31,81.98 133.31,80.51 132.4,79.59 129.73,79.59 129.45,79.3 129.45,77.91 v6(129.15,77.61)
  IN3 w0.064: 136.21,83.71 137.29,83.71 138.02,84.45 v8(138.19,84.45)
CFG3: length 13.2
  GND2 w0.102: v7(138.22,83.7) v5(138.58,83.7)
  GND3 w0.102: v5(138.58,83.7) v8(138.21,83.7)
  IN3 w0.061: 136.21,83.4 135.22,83.4 133.69,81.87 133.69,79.87 132.65,78.83 130.33,78.83 130.05,78.55 130.05,78.01 129.8,77.76 v3(129.8,77.61)
  IN3 w0.064: 136.21,83.4 137.5,83.4 137.79,83.7 v8(138.21,83.7)
CFG4: length 31.4
  TOP w0.127: RH58.1 v7(148.74,95) 148.37,95 v1(147.83,94.46)
  GND2 w0.102: v5(148.5,94.63) 148.5,94.76 v7(148.74,95)
  GND3 w0.102: v8(148.14,94.45) 148.32,94.45 v5(148.5,94.63)
  IN3 w0.061: v3(130.45,76.82) 130.69,76.82 131.47,77.6 131.47,77.69 131.65,77.87 133.24,77.87 134.06,78.69 136.21,78.69
  IN3 w0.064: v8(148.14,94.45) 147.1,94.45 143.74,91.09 143.74,86.07 141.01,83.34 141.01,81.81 138.41,79.22 137.6,79.22 137.06,78.69 136.21,78.69
CFG5: length 32.3
  TOP w0.127: RH60.1 149.37,94.77 v7(149.28,94.67) 149.28,94.34 v1(149.13,94.19)
  GND2 w0.102: v5(149.16,94.31) 149.28,94.44 v7(149.28,94.67)
  GND3 w0.102: v8(148.81,94.31) v5(149.16,94.31)
  IN3 w0.064: v3(131.1,76.03) 131.26,76.03 131.44,76.22 132.68,76.22 132.97,76.51 136.47,76.51 138.17,78.21 140.21,78.21 141.6,79.6 141.6,83.39 144.7,86.49 144.7,91.08 147.12,93.5 147.55,93.5 148.36,94.31 v8(148.81,94.31)
CFG6: length 35.7
  TOP w0.127: v1(150.13,93.29) 149.71,93.7 v7(149.71,94.69) 150,94.98 RH61.1
  GND2 w0.102: v7(149.71,94.69) 149.71,94.44 v5(149.94,94.22)
  GND3 w0.102: v8(149.71,94.7) 149.71,94.45 v5(149.94,94.22)
  IN3 w0.061: 130.13,76.82 130.13,76.96 130.28,77.12 130.65,77.12 130.85,77.32 130.85,77.73 130.98,77.87 131.39,77.87 131.54,78.02 133.13,78.02 133.96,78.85 136.21,78.85
  IN3 w0.064: v8(149.71,94.7) 149.66,94.76 147.21,94.76 143.6,91.15 143.6,86.13 140.87,83.4 140.87,81.87 138.36,79.36 137.54,79.36 137.03,78.85 136.21,78.85 ; v3(129.8,76.03) 129.8,76.21 130.13,76.54 130.13,76.82
CFG7: length 33.6
  TOP w0.127: RH64.1 v1(150.62,94.49) 150.62,94.37 v7(150.41,94.15)
  GND2 w0.102: v7(150.41,94.15) 150.41,93.87 v5(150.55,93.73)
  GND3 w0.102: v8(150.57,94.08) 150.55,94.07 v5(150.55,93.73)
  IN3 w0.064: v8(150.57,94.08) 150.42,93.93 148.36,93.93 147.78,93.36 147.18,93.36 144.87,91.04 144.87,86.45 142.65,84.24 142.65,79.58 140.68,77.62 138.61,77.62 136.84,75.85 133.24,75.85 132.91,75.52 132.74,75.52 132.46,75.25 v3(132.4,75.25)
CFG8: length 13.8
  GND2 w0.102: v5(142.35,79.99) 142.53,80.17 v7(142.72,80.17)
  GND3 w0.102: v5(142.35,79.99) 142.35,79.87 v8(142.16,79.68)
  IN3 w0.064: v8(142.16,79.68) 142.16,79.57 140.5,77.91 138.43,77.91 136.7,76.18 133.11,76.18 132.78,75.85 131.7,75.85 v3(131.1,75.25)
CFG9: length 21.7
  GND2 w0.102: v7(144.11,79.45) 144,79.45 v5(143.8,79.25)
  GND3 w0.102: v5(143.8,79.25) 143.8,79.05 v8(143.6,78.85)
  IN3 w0.064: v3(129.8,74.46) 129.8,74.5 130.1,74.8 132.59,74.8 132.98,75.19 133.05,75.19 133.38,75.52 137.59,75.52 138.4,74.71 138.4,74.2 139.87,72.73 141.93,72.73 143.45,74.24 143.45,78.7 v8(143.6,78.85)
CFG10: length 10.6
  GND2 w0.102: v7(140.63,80.29) v5(140.25,80.29)
  GND3 w0.102: v5(140.25,80.29) 140.07,80.29 v8(139.83,80.05)
  IN3 w0.064: v3(134.85,77.43) 135.69,78.27 137.04,78.27 137.71,78.94 138.72,78.94 v8(139.83,80.05)
  BOTTOM w0.127: v3(134.85,77.43) v1(134.46,77.43) 134.24,77.43 133.24,76.43 132.18,76.43 131.78,76.03 UC1.DG17
CFG11: length 14.1
  GND2 w0.102: v7(138.2,82.86) v5(138.2,83.21)
  GND3 w0.102: v5(138.2,83.21) v8(137.84,83.21)
  IN3 w0.061: 136.21,83.15 135.18,83.15 133.84,81.81 133.84,79.81 132.72,78.68 130.94,78.68 130.71,78.45 130.71,78.21 130.15,77.65 130.15,77.5 129.87,77.22 129.74,77.22 129.51,76.99 129.51,76.82
  IN3 w0.064: v8(137.84,83.21) 137.79,83.15 136.21,83.15 ; 129.51,76.82 129.51,76.4 v3(129.15,76.03)
CFG12: length 15.1
  GND2 w0.102: v5(142.87,81.34) 143.2,81.34 v7(143.23,81.31)
  GND3 w0.102: v8(142.36,81.15) 142.55,81.34 v5(142.87,81.34)
  IN3 w0.064: v3(131.75,75.25) 131.76,75.25 132.2,75.69 132.85,75.69 133.17,76.01 136.81,76.01 138.55,77.76 140.62,77.76 142.44,79.57 142.44,81.06 v8(142.36,81.15)
CFG13: length 15
  GND2 w0.102: v5(142.33,80.53) 142.58,80.78 v7(142.71,80.78)
  GND3 w0.102: v8(142.01,80.39) 142.15,80.53 v5(142.33,80.53)
  IN3 w0.064: v8(142.01,80.39) 141.88,80.26 141.88,79.53 140.41,78.06 138.3,78.06 136.58,76.34 133.04,76.34 132.71,76.02 131.49,76.02 130.72,75.25 v3(130.45,75.25)
CFG14: length 23.3
  GND2 w0.102: v7(143.72,80.7) 143.72,80.56 v5(143.53,80.38)
  GND3 w0.102: v5(143.53,80.38) 143.53,80 v8(143.54,80)
  IN3 w0.064: v8(143.54,80) 143.31,79.77 143.31,74.3 141.87,72.87 139.93,72.87 138.54,74.26 138.54,74.77 137.62,75.68 133.31,75.68 132.98,75.35 132.91,75.35 132.52,74.96 129.61,74.96 129.15,74.5 v3(129.15,74.46)
CFG15: length 10.3
  GND2 w0.102: v7(141.27,80.32) v5(140.99,80.04)
  GND3 w0.102: v8(140.56,79.89) 140.71,80.04 v5(140.99,80.04)
  IN3 w0.061: 135.52,77.02 132.6,77.02 v3(132.4,76.82)
  IN3 w0.064: 135.52,77.02 136.17,77.67 136.95,77.67 137.92,78.64 139.32,78.64 v8(140.56,79.89)
CFG16: length 26.2
  GND2 w0.102: v7(144.09,80.1) v5(144.38,79.81)
  GND3 w0.102: v5(144.38,79.81) v8(144.38,79.45)
  IN3 w0.061: 129.13,76.82 129.14,76.82 v3(129.15,76.82)
  IN3 w0.064: v8(144.38,79.45) 143.86,78.94 143.86,74.41 142.05,72.59 139.76,72.59 138.21,74.14 138.21,74.69 137.84,75.06 135.76,75.06 135.58,74.89 132.91,74.89 132.61,74.58 132.25,74.58 131.85,74.17 129.05,74.17 128.83,74.4 128.83,76.51 129.13,76.82
CFG17: length 12.8
  GND2 w0.102: v7(140.63,81) v5(140.27,81)
  GND3 w0.102: v5(140.27,81) v8(139.63,81)
  IN3 w0.061: 136.21,79.01 133.87,79.01 133.02,78.17 131.41,78.17 131.29,78.05 130.95,78.05 130.7,77.8 130.7,77.44 130.55,77.3 130.25,77.3 129.8,76.85 v3(129.8,76.82)
  IN3 w0.064: v8(139.63,81) 138.13,79.5 137.48,79.5 137,79.01 136.21,79.01
CFG18: length 14.4
  GND2 w0.102: v7(141.92,80.24) 141.82,80.24 v5(141.62,80.05)
  GND3 w0.102: v5(141.62,80.05) v8(141.32,79.75)
  IN3 w0.064: v3(129.8,75.25) 130.23,75.67 130.55,75.67 130.73,75.85 130.73,76.14 130.93,76.35 131.29,76.35 131.33,76.38 132.61,76.38 132.9,76.67 136.38,76.67 138.07,78.36 139.94,78.36 v8(141.32,79.75)
CFG19: length 14.8
  GND2 w0.102: v7(141.27,80.97) 141.23,80.97 v5(140.93,80.67)
  GND3 w0.102: v8(140.59,80.64) 140.89,80.64 v5(140.93,80.67)
  IN3 w0.061: 131.42,76.82 131.42,76.92 131.67,77.17 135.44,77.17
  IN3 w0.064: 131.42,76.82 131.42,76.76 131.16,76.51 130.5,76.51 130.15,76.16 130.15,76 129.84,75.7 129.66,75.7 129.21,75.25 v3(129.15,75.25) ; v8(140.59,80.64) 140.59,80.63 140.59,80.41 138.97,78.79 137.76,78.79 136.92,77.95 136.22,77.95 135.44,77.17
CFG_RCOMP: length 16.1
  TOP w0.127: v9(144.75,75.65) 144.92,75.48 RH57.1
  BOTTOM w0.076: 136.21,76.84 136.19,76.82
  BOTTOM w0.127: UC1.DH19 133.75,75.8 v1(135.18,75.8) 136.19,76.82 ; 136.21,76.84 136.92,77.54 142.19,77.54 144.09,75.65 v9(144.75,75.65)
CHG_ACIN: length 5.5
  TOP w0.203: PR504.1 160.71,2.96 161.4,2.28 PC511.1 161.87,2.05 PR501.2 162.82,2.48 PR509.2 162.69,3.01 PU501.19
CHG_ADP: length 6.6
  TOP w0.203: v9(160.25,5.54) 160.3,5.6 PU501.16
  TOP w0.508: v9(160.25,5.54) 160.18,5.48 158.78,5.48 158.3,5 PR506.2
  BOTTOM w0.254: PC526.1 160.89,7.38 160.89,6.19 v9(160.25,5.54)
CHG_AMON: length 2.1
  TOP w0.203: PU501.29 v1(166.44,7.2) 166.47,7.2 166.78,7.51 PR538.1
CHG_BGATE: length 41.1
  TOP w0.203: PC533.1 165.59,9.94 165.66,9.87 165.66,9.4 165.96,9.1 165.96,8.53 165.83,8.4 165.83,8.4 PU501.32
  TOP w0.254: v9(167.42,10.37) 167.42,10.38 166.99,10.81 166.99,10.82 166.85,10.95 166.85,10.95 v1(166.47,11.33) 166.35,11.33 165.59,10.57 PC533.1
  IN3 w0.254: v3(142.86,2.04) 142.86,3.21 143.32,3.66 145.12,3.66 147.48,1.3 153.42,1.3 154.49,2.37 161.01,2.37 161.96,1.42 165.74,1.42 167.42,3.09 v9(167.42,10.37)
CHG_BST1:
  vias: v1(160.25,6.47) v9(159.79,7.19) v9(160.37,6.94)
CHG_BST2: length 1.6
  TOP w0.203: PU501.4 163.49,10.55 v9(163.42,10.62)
CHG_CLK: length 2.5
  TOP w0.203: PU501.22 163.89,4.36 v1(164.4,3.85) 164.89,3.36 164.89,3.13 PR514.2
CHG_CMIN: length 1.7
  TOP w0.203: PR512.2 163.09,3.74 PU501.20
CHG_COMP: length 5.9
  TOP w0.127: PC541.1 169.1,5.96 170.09,4.97 v1(170.42,4.97)
  TOP w0.203: PC541.1 168.6,5.96 168.58,5.99 167.75,5.99 167.34,6.39 PR527.1 166.89,6.5 166.58,6.8 PU501.28
CHG_CSIN: length 8
  TOP w0.203: PU501.14 159.54,6.4 PC510.2 158.85,7.83 157.95,8.73 v1(157.01,8.73) PR503.2 155.39,9.26 PC513.1
CHG_CSIP: length 8.6
  TOP w0.203: PU501.15 v1(159.93,6) 159.03,6 PC510.1 158.35,6.67 158.35,7.93 157.95,8.34 156.75,8.34 PR502.2 155.39,6.98 PC512.1
CHG_CSON: length 4.4
  TOP w0.203: PR522.2 163.84,12.57 163.84,11.89 PC539.2 164.44,11.87 164.64,11.66 PC540.1 164.64,11.14 164.69,11.09 v1(164.69,10.37) PU501.1
CHG_CSOP: length 8.6
  TOP w0.127: PC538.2 162.02,13.4 162.02,14.37 162.53,14.88 v1(162.53,15.58)
  TOP w0.203: PC538.2 162.81,12.93 163.09,12.66 PR521.2 162.92,12.24 162.92,11.89 PC539.1 162.9,11.83 163.36,11.37 163.69,11.37 164.29,10.77 PU501.2
CHG_DAT: length 2.3
  TOP w0.203: PR513.2 164.18,3.46 163.49,4.15 PU501.21
CHG_DCIN: length 6
  TOP w0.203: PU501.17 161.8,5.04 v9(160.76,5.04)
  TOP w0.508: PR508.2 158.64,3.02 v1(158.91,2.75) 159.46,3.3 159.46,4.07 159.99,4.6 160.3,4.6 160.73,5.04 v9(160.76,5.04)
CHG_LG1: length 29.6
  IN2 w1.016: 142.91,11.49 142.91,14.75 147.93,19.77 155.52,19.77 156.69,18.6 156.69,17.46 159.86,14.28 159.86,10.5 160.25,10.12
  vias: v1(159.61,9.42) v9(142.93,10.67) v9(142.92,10.06) v9(160.63,9.3) v9(161.11,8.87)
CHG_LG2: length 31.4
  TOP w0.127: v9(134.85,20.08) v1(134.15,20.08)
  IN3 w0.762: 160.19,10.78 159.89,10.78 158.45,12.21 138.36,12.21 136.75,13.82 136.75,18.88 136.05,19.58
  vias: v9(135.42,20.08) v9(160.92,10.84) v9(161.27,10.36)
CHG_LX1: length 9.4
  IN2 w1.016: 158.85,9.33 158.06,10.12 158.06,12.63 154.28,16.41 154.28,16.82
  vias: v1(160.31,8.91) v9(153.9,18.12) v9(153.9,17.54) v9(159.84,8.76) v9(160.37,8.43)
CHG_LX2: length 22.6
  IN3 w0.762: 139.42,13.93 139.93,13.42 159.41,13.42 161.11,11.72
  vias: v1(161.32,11.45) v9(138.27,14.5) v9(138.91,14.5) v9(161.71,11.11) v9(162.04,10.57)
CHG_PROCHOT#: length 222.4
  TOP w0.203: PU501.23 164.29,4.52 165.02,3.79 v9(165.71,3.79) 165.96,3.54 PR515.2
  IN1 w0.064: v4(144.83,7.47) 144.54,7.18 135.04,7.18 133.61,8.61 133.61,10.79 130.73,13.68 v4(130.73,13.77) ; v4(97.93,24.67) 95.38,27.21 88.21,27.21 v4(87.87,27.55)
  GND2 w0.102: v4(130.73,13.77) 130.49,13.53 v5(130.22,13.53) ; v5(145.18,7.3) 145.18,7.4 145.11,7.47 v4(144.83,7.47) ; v5(87.33,27.69) 87.73,27.69 v4(87.87,27.55) ; v4(97.93,24.67) v5(97.93,23.8)
  IN2 w0.074: v5(130.22,13.53) 129.14,12.45 124.22,12.45 122.86,13.81 122.86,15.64 122.08,16.42 122.08,17.71 120.58,19.21 111.29,19.21 106.29,24.22 104.38,24.22 103.96,23.8 v5(97.93,23.8) ; v9(165.71,3.79) 158.82,3.79 156.18,6.43 154.09,6.43 153.15,7.37 145.26,7.37 v5(145.18,7.3) ; v5(87.33,27.69) 87.29,27.74 77.94,27.74 76.65,29.02 73.01,29.02 70.44,26.45 60.04,26.45 54.46,32.03 54.46,33.66 52.98,35.14 52.98,43.89 54.22,45.12 54.22,51.1 50.35,54.97 50.35,61.54 51.76,62.95 51.76,63.55 55.38,67.17 55.38,70.33 56.44,71.38 56.44,74.25 54.77,75.92 53.61,75.92 52.02,77.52 52.02,83.19 50.95,84.26 50.95,88.52 48.7,90.77 46.71,90.77 46.44,91.04 43.32,91.04 41.88,92.48 41.88,93.27 41.68,93.48 v5(41.27,93.48)
  GND3 w0.102: v5(41.27,93.48) 41.26,93.47 v8(40.67,93.47)
  IN3 w0.064: v6(35.53,102.47) 35.53,101.99 36.72,100.79 36.72,97.58 39.69,94.62 39.99,94.62 40.67,93.94 v8(40.67,93.47)
CHG_PSYS: length 4.6
  TOP w0.127: PR526.1 168.51,9.23 v1(168.7,9.42)
  TOP w0.203: PU501.30 166.17,7.6 166.58,8.01 168.11,8.01 168.51,8.41 PR526.1
CHG_UG1: length 16.5
  IN2 w1.016: 158.98,7.83 157.96,7.83 156.05,9.73 156.05,11 152.5,14.56 152.5,17.1
  IN3 w1.016: 157.77,19.01 153.84,19.01
  vias: v1(159.29,8.08) v3(158.85,19.04) v3(158.85,18.66) v9(153.01,18.55) v9(153.01,17.98) v9(159.86,7.91) v9(160.37,7.58)
CHG_UG2: length 26
  TOP w0.127: v9(140.65,14.52) v1(140.65,15.07)
  TOP w0.203: PU501.5 163.09,10.01 162.84,10.27 v9(162.84,10.55)
  IN3 w0.762: 162.84,11.31 162.84,12.08 158.43,16.49 151.81,16.49 150.26,14.94 142.21,14.94
  vias: v9(141.23,14.53)
CHG_VBAT1: length 2.7
  TOP w0.203: PC544.1 167.73,8.59 PR530.1 166.42,8.59 165.83,8 PU501.31
CHG_VDDP: length 3.8
  TOP w0.203: PU501.8 161.89,9.3 161.53,9.66 161.21,9.66 v1(160.75,10.12) 160.36,10.51 PC528.1 159.79,10.53 PR507.1
CLINK_CLK: length 107.9
  IN1 w0.064: v4(111.28,9.79) 111.28,11.23 112.48,12.44 112.48,14.33 112.04,14.78 111.38,14.78 111.22,14.63 110.82,14.63 110.49,14.3 106.12,14.3 106.08,14.26 104.57,14.26 104.52,14.3 102.85,14.3 102.04,13.5 98.22,13.5 97.69,12.97 91.69,12.97 90.42,14.24 79.59,14.24 78.96,14.86 70.78,14.86 68.9,16.75 68.28,16.75 63.04,21.98 58.45,21.98 58.25,22.19 57.85,22.19 57.47,22.57 54.04,22.57 53.33,23.28 49.28,23.28 48.91,23.65 47.05,23.65 46.62,24.08 44.93,24.08 43.13,25.88 41.25,25.88 40.01,24.64 38.31,24.64 36.5,22.83 v4(36.5,22.33)
  GND2 w0.102: v4(36.5,22.33) 36.47,22.36 v5(36.12,22.36) ; v4(111.28,9.79) 111.16,9.67 v5(111.16,9.33)
  GND3 w0.102: v5(111.16,9.33) 111.06,9.23 v6(111.06,8.9) ; v6(35.66,22.5) 35.8,22.36 v5(36.12,22.36)
  BOTTOM w0.076: 29.79,33.36 29.79,34.46 29.45,34.8 29.45,34.81 29.41,34.85 29.41,35.89 UH4.AV2
  BOTTOM w0.127: v6(35.66,22.5) v1(35.15,22.5) 34.89,22.5 29.26,28.13 29.26,30.94 29.79,31.48 29.79,33.36
CLINK_DATA: length 101.5
  IN1 w0.064: v4(107.22,15) 106.39,15 105.95,15.44 102.24,15.44 100.99,14.2 97.93,14.2 97.4,13.67 92.07,13.67 90.22,15.53 84.95,15.53 84.55,15.93 82.36,15.93 81.43,16.86 74.53,16.86 v4(74.04,17.35)
  GND2 w0.102: v5(107.58,14.83) 107.41,15 v4(107.22,15) ; v5(73.71,17.35) v4(74.04,17.35)
  GND3 w0.102: v6(73.38,17.35) v5(73.71,17.35) ; v6(107.58,15.29) v5(107.58,14.83)
  BOTTOM w0.076: 29.56,33.36 29.56,34.45 29.23,34.78 29.23,35.79 29.21,35.82 29.21,36.05 29.35,36.2 UH4.AV3
  BOTTOM w0.102: JIO1.E7 108.06,15.77 v6(107.58,15.29)
  BOTTOM w0.127: v6(73.38,17.35) 73.38,13.61 v1(72.87,13.1) 72.62,12.85 61.57,12.85 55.49,18.93 48.27,18.93 47.49,19.7 37.39,19.7 29.05,28.04 29.05,31.03 29.56,31.53 29.56,33.36
CLINK_RST#: length 98
  IN1 w0.064: v4(87.23,9.35) 87.95,9.35 88.21,9.09 92.99,9.09 93.93,10.03 96.8,10.03 97.05,9.79 99.16,9.79 99.75,10.39 103.16,10.39 103.52,10.75 104.15,10.75 105.89,12.5 v4(106.65,12.5)
  GND2 w0.102: v4(87.23,9.35) 86.93,9.06 v5(86.78,9.06) ; v5(107.06,12.35) 106.91,12.5 v4(106.65,12.5)
  GND3 w0.102: v8(86.25,9.07) 86.26,9.06 v5(86.78,9.06) ; v6(107.06,11.9) v5(107.06,12.35)
  IN3 w0.064: v8(86.25,9.07) 86.2,9.12 80.16,9.12 79.69,9.59 78.5,9.59 78.04,9.12 74.5,9.12 73.83,9.8 v3(72.84,9.8)
  BOTTOM w0.076: 27.78,33.36 27.78,33.76 28.39,34.37 28.39,35.01 28.52,35.13 28.52,35.77 28.76,36.01 UH4.AW2
  BOTTOM w0.127: v3(72.84,9.8) 72.48,9.8 70.03,12.25 61.59,12.25 55.32,18.52 48.06,18.52 47.34,19.25 37.24,19.25 28.41,28.07 28.22,28.07 v1(27.99,28.3) 27.99,31.12 27.78,31.32 27.78,33.36
CLK_PCIE_N0: length 87.5
  IN3 w0.086: v3(41.8,38.37) 41.8,38.44 41.9,38.55 42.23,38.55 42.49,38.28 42.49,37.9 41.13,36.54 41.13,27.03 44.88,23.28 50.88,23.28 63.47,10.7 74.12,10.7 74.51,10.31 79.99,10.31 80.39,9.92 87.82,9.92 88.06,9.67 92.02,9.67 92.29,9.94 92.29,10.26 v3(92.36,10.33)
  BOTTOM w0.145: v3(92.36,10.33) 92.29,10.4 92.29,11.65 92.11,11.83 92.11,12.72 91.56,13.26 91.56,18.83 92.48,19.74 93.93,19.74 94.73,18.94 96.21,18.94 96.37,18.77 96.71,18.77 96.86,18.62 JNGFF2.53
CLK_PCIE_N3: length 91.6
  IN3 w0.086: v3(110.58,11.18) 110.5,11.11 110.23,11.11 110.07,11.27 110.07,11.54 109.77,11.84 109.39,11.84 109.12,11.57 98.91,11.57 97.94,10.6 93.58,10.6 93.09,11.09 90.89,11.09 90.8,11 81.19,11 80.5,11.69 77.79,11.69 77.6,11.87 63.84,11.87 51.24,24.47 45.24,24.47 42.25,27.46 42.25,35.18 42.94,35.87 44.37,35.87 44.92,36.42 44.92,37.17 45.02,37.26 v3(45.48,37.26)
  BOTTOM w0.102: JIO1.G5 110.58,13.38 v3(110.58,11.18)
CLK_PCIE_N6: length 53
  IN3 w0.086: v3(40.8,38.97) 40.8,38.72 40.86,38.67 41,38.67 41.13,38.8 41.13,39.32 42.11,40.3 42.73,40.3 43.11,40.68 43.11,46.24 41.98,47.38 41.58,47.38 41.25,47.71 41.25,48.37 41.72,48.84 41.72,50.37 41.4,50.7 41.4,52.13 40.13,53.4 40.13,53.85 39.08,54.91 39.08,55.78 38.68,56.17 38.53,56.17 38.13,56.17 38.13,56.18 38.01,56.18 37.87,56.31 36.98,56.31 35.77,57.51 35.77,61.22 37.75,63.2 37.75,64.32 37.38,64.69 37.38,64.7 37.38,67.41 37.63,67.65 37.63,68.02 37.95,68.35 37.95,68.57 37.63,68.89 37.63,69.56 34.87,72.32 34.87,76.5 35.66,77.29 35.91,77.29 35.92,77.29 39.09,77.29 39.33,77.54 40.03,77.54 40.14,77.65 40.14,77.9 40.07,77.97 v3(39.8,77.97)
CLK_PCIE_N8: length 40.4
  TOP w0.145: UR1.6 24.97,65.64 25.02,65.59 25.37,65.59 v9(25.42,65.64)
  IN3 w0.061: 35.89,40.64 35.9,40.64 35.98,40.72 37.56,40.72 37.92,40.37 37.92,40.02 38.13,39.81 38.38,39.81 v3(38.48,39.71)
  IN3 w0.086: v9(25.42,65.64) 25.37,65.59 24.86,65.59 24.48,65.2 24.48,64.24 25.62,63.09 29.5,63.09 30.91,61.69 30.91,59.65 30.9,59.65 30.9,57.95 31.36,57.49 31.36,55 31.03,54.67 31.03,52.38 31.23,52.18 31.23,51.18 31.06,51.01 31.06,50.29 30.04,49.28 30.04,46.5 30.62,45.91 30.62,42.94 31.62,41.94 31.62,41.37 32.55,40.44 34.72,40.44 34.92,40.64 35.89,40.64
CLK_PCIE_P0: length 87.5
  IN3 w0.086: v3(91.98,10.33) 91.98,10.07 91.89,9.98 88.19,9.98 87.95,10.23 80.51,10.23 80.12,10.62 74.64,10.62 74.25,11.01 63.6,11.01 51.01,23.59 45.01,23.59 41.44,27.16 41.44,36.41 42.8,37.77 42.8,38.41 42.36,38.86 41.88,38.86 41.8,38.94 v3(41.8,39.13)
  BOTTOM w0.145: JNGFF2.55 96.86,19.12 96.81,19.08 96.5,19.08 96.33,19.25 94.86,19.25 94.05,20.05 92.35,20.05 91.25,18.96 91.25,13.14 91.8,12.59 91.8,11.7 91.98,11.52 v3(91.98,10.33)
CLK_PCIE_P3: length 91.6
  IN3 w0.086: v3(44.52,37.12) 44.61,37.03 44.61,36.55 44.24,36.18 42.81,36.18 41.94,35.31 41.94,27.33 45.11,24.16 51.11,24.16 63.71,11.56 77.48,11.56 77.66,11.38 80.37,11.38 81.06,10.69 90.93,10.69 91.02,10.78 92.96,10.78 93.45,10.29 98.07,10.29 99.04,11.26 109.25,11.26 109.52,11.53 109.64,11.53 109.76,11.41 109.76,11.28 109.65,11.17 v3(109.55,11.17)
  BOTTOM w0.102: JIO1.F5 110.06,14.75 109.55,14.23 109.55,11.17 v3(109.55,11.17)
CLK_PCIE_P6: length 53
  IN3 w0.086: v3(40.8,38.21) 40.95,38.36 41.13,38.36 41.44,38.67 41.44,39.19 42.24,39.99 42.86,39.99 43.42,40.55 43.42,46.37 42.1,47.69 41.71,47.69 41.56,47.84 41.56,48.24 42.03,48.72 42.03,50.5 41.71,50.83 41.71,52.26 40.44,53.53 40.44,53.98 39.39,55.03 39.39,55.9 38.81,56.48 38.4,56.48 38.26,56.48 38.26,56.49 38.13,56.49 38,56.62 37.1,56.62 36.08,57.64 36.08,61.09 38.06,63.07 38.06,64.45 37.69,64.81 37.69,67.28 37.94,67.52 37.94,67.89 38.26,68.22 38.26,68.7 37.94,69.02 37.94,69.69 35.18,72.44 35.18,76.37 35.79,76.98 39.22,76.98 39.46,77.23 40.16,77.23 40.45,77.52 v3(40.45,77.97)
CLK_PCIE_P8: length 40.3
  TOP w0.145: v9(25.42,65.06) 25.2,65.28 24.96,65.28 24.92,65.24 UR1.5
  IN3 w0.061: v3(38.48,40.47) 38.74,40.21 38.74,40.01 38.69,39.96 38.19,39.96 38.07,40.08 38.07,40.43 37.63,40.87 35.98,40.87 35.9,40.95 35.89,40.95
  IN3 w0.086: v9(25.42,65.06) 25.42,65.11 25.25,65.28 24.99,65.28 24.79,65.07 24.79,64.37 25.75,63.4 29.63,63.4 31.22,61.82 31.22,59.52 31.21,59.52 31.21,58.08 31.67,57.62 31.67,54.87 31.34,54.54 31.34,52.51 31.54,52.3 31.54,51.05 31.37,50.88 31.37,50.17 30.35,49.15 30.35,46.62 30.93,46.04 30.93,43.07 31.93,42.07 31.93,41.5 32.68,40.75 34.6,40.75 34.79,40.95 35.89,40.95
CLK_PEG_N7: length 80
  IN1 w0.086: v6(81.78,57.29) 81.9,57.17 81.9,57.04 81.81,56.95 80.66,56.95 72,65.61 61.67,65.61 60.6,66.69 59.23,66.69 57.27,64.73 57.27,63.96 55.37,62.06 55.37,54.29 57.43,52.23 57.43,48.18 49,39.76 49,37.78 46.71,35.49 46.71,34.16 46.21,33.67 46.05,33.67 45.6,33.22 43.53,33.22 42.34,34.41 42.34,35.57 40.61,37.29 39.14,37.29 38.79,37.64 38.79,37.98 38.95,38.14 39.44,38.14 39.51,38.07 39.51,37.95 v9(39.32,37.76)
  GND2 w0.102: v6(81.78,57.29) v5(81.54,57.53)
  GND3 w0.102: v6(81.78,57.29) v5(81.54,57.53)
  BOTTOM w0.076: v9(39.32,37.76) UH4.U5
CLK_PEG_P7: length 80
  IN1 w0.086: v9(39.31,38.54) 39.22,38.45 38.82,38.45 38.48,38.11 38.48,37.52 39.01,36.98 40.48,36.98 42.03,35.44 42.03,34.28 43.4,32.91 45.73,32.91 46.18,33.36 46.34,33.36 47.02,34.03 47.02,35.36 49.31,37.66 49.31,39.63 57.74,48.05 57.74,52.36 55.68,54.41 55.68,61.93 57.58,63.83 57.58,64.6 59.36,66.38 60.47,66.38 61.54,65.3 71.87,65.3 80.53,56.64 v6(81.78,56.64)
  GND2 w0.102: v6(81.78,56.64) v5(81.54,56.88)
  GND3 w0.102: v6(81.78,56.64) v5(81.54,56.88)
  BOTTOM w0.076: v9(39.31,38.54) UH4.U7
CLK_TP_SIO_I2C_DAT: length 35.7
  TOP w0.127: v7(48.35,14.59) UE3.E10
  GND2 w0.102: v7(48.35,14.59) 48.35,14.64 48.21,14.79 v5(48.05,14.79)
  GND3 w0.102: v5(48.05,14.79) 48.05,15.53 v6(47.98,15.6)
  IN3 w0.064: v3(33.14,16.2) 32.56,16.78 31.77,16.78 v3(31.01,17.54)
  BOTTOM w0.127: v6(47.98,15.6) 47.2,15.6 45.94,16.86 42.9,16.86 42.63,16.59 39.54,16.59 39.19,16.94 38.06,16.94 37.55,16.43 33.36,16.43 v3(33.14,16.2) ; v3(31.01,17.54) 31.01,15.02 31.81,14.22 31.81,12.61 30.39,11.19 30.39,9.61 29.8,9.02 27.43,9.02 26.92,9.53 26.3,9.53 v9(25.92,9.15) JKB1.25
CLKDET#: length 3.7
  BOTTOM w0.076: UH4.AL43 32.65,56.43 32.81,56.6 32.81,58.52 32.65,58.68 32.18,58.68 32.1,58.76
  BOTTOM w0.127: RH192.1 31.87,58.98 32.1,58.76
CLKOUT_LPC1: length 10.5
  TOP w0.127: RH169.1 21.84,43.71 v7(22.39,44.25)
  GND2 w0.102: v7(22.39,44.25) v5(22.73,44.25)
  GND3 w0.102: v5(22.73,44.25) 22.83,44.15 v8(23.06,44.15)
  IN3 w0.064: v3(29.21,44.2) 28.91,43.91 26.25,43.91 25.75,44.41 24.15,44.41 23.85,44.1 23.11,44.1 v8(23.06,44.15)
  BOTTOM w0.076: UH4.AV19 v3(29.21,44.2)
CLKREQ_PCIE#0: length 102.9
  TOP w0.127: v2(27.48,26.98) 30.43,26.98 30.91,26.5 v1(32.8,26.5) v2(33.37,26.5)
  IN1 w0.064: v9(87.36,16.85) 87.04,16.85 86.61,17.28 76.18,17.28 73.25,20.21 69.52,20.21 64.72,25.02 60.42,25.02 60.2,25.24 58.01,25.24 57.64,24.87 56.15,24.87 54.4,26.62 45.21,26.62 43.96,27.87 39.04,27.87 38.06,26.89 33.77,26.89 v2(33.37,26.5) ; v2(27.48,26.98) 27.4,26.98 21.87,32.52 21.87,42.01 21.45,42.42 21.45,43.17 20.88,43.75 20.88,46.21 21.46,46.79 v4(21.76,46.79)
  GND2 w0.102: v4(21.76,46.79) 21.48,46.79 v5(21.41,46.87)
  GND3 w0.102: v6(21.69,47.07) 21.48,46.87 v5(21.41,46.87)
  BOTTOM w0.076: 22.07,47.15 22.27,47.35 24.57,47.35 24.92,47 26.46,47 26.62,46.84 UH4.BC24
  BOTTOM w0.127: 22.07,47.15 21.99,47.07 v6(21.69,47.07) 21.64,47.07 21.38,47.33 19.49,47.33 18.84,47.97 RP2.8 ; JNGFF2.52 89.25,18.37 87.73,16.85 v9(87.36,16.85)
CLKREQ_PCIE#3: length 186.4
  TOP w0.127: v7(83,2.04) 83.41,2.46 83.41,6.07 84.62,7.27 v1(84.62,9.67) 84.62,12.94 84.35,13.21 v2(84.35,13.25)
  IN1 w0.064: v4(103.41,13.84) 103.17,13.6 102.77,13.6 102.33,13.16 98.28,13.16 97.8,12.69 93.91,12.69 93.5,12.28 90.74,12.28 90.03,12.99 84.61,12.99 v2(84.35,13.25)
  GND2 w0.102: v4(103.41,13.84) 103.67,13.59 v5(103.67,13.29) ; v7(83,2.04) 83,2.06 83.01,2.07 83.3,2.07 v5(83.34,2.1)
  GND3 w0.102: v6(104.06,12.9) v5(103.67,13.29) ; v5(83.34,2.1) 83.02,1.78 v8(82.86,1.78)
  IN3 w0.064: v3(17.5,49.47) 17.5,50.47 17.24,50.73 17.24,54.23 16.58,54.9 14.73,54.9 12.98,56.65 10.13,56.65 6.63,53.15 6.63,37.69 6.76,37.56 6.76,35.94 7.48,35.22 7.48,32.06 7.04,31.63 7.04,28.05 7.46,27.63 7.46,25.51 8.51,24.47 12.73,24.47 14.35,22.85 14.35,20.73 17.85,17.24 17.85,13.8 15.34,11.29 15.34,8.8 17.88,6.25 24.82,6.25 26.2,4.87 30.26,4.87 32.47,2.66 36.61,2.66 37.2,2.06 50.21,2.06 50.45,2.31 51.91,2.31 52.27,1.95 54.45,1.95 55.33,2.83 56.27,2.83 57.6,1.49 82.57,1.49 v8(82.86,1.78)
  BOTTOM w0.076: UH4.BD25 26.26,47.41 25.78,47.88 22.97,47.88 22.16,48.7 22.07,48.7
  BOTTOM w0.127: 22.07,48.7 18.99,48.7 18.21,49.47 v3(17.5,49.47)
CLKREQ_PCIE#6: length 74.3
  IN1 w0.064: v4(37.11,71.94) 36.4,71.94 35.04,70.58 33.16,70.58 32.46,71.28 31.6,71.28 31.34,71.53 30.25,71.53 29.36,70.64 28.29,70.64 26.78,69.13 26.78,67.03 26.46,66.71 26.46,65.31 27.16,64.61 27.16,63.18 21.34,57.36 21.34,56.15 19.42,54.24 19.42,51.91 18.64,51.12 18.64,48.75 v4(18.36,48.47)
  GND2 w0.102: v5(18.03,48.49) 18.06,48.47 v4(18.36,48.47) ; v4(37.11,71.94) v5(37.5,71.94)
  IN2 w0.074: v5(46.73,85.48) 46.73,76.82 44.93,75.01 41.59,75.01 39.82,73.25 38.02,73.25 37.5,72.73 v5(37.5,71.94)
  GND3 w0.102: v6(17.5,48.47) 18.01,48.47 v5(18.03,48.49) ; v6(47.14,85.53) 47.09,85.48 v5(46.73,85.48)
  IN3 w0.064: v3(30.21,51.34) 29.83,51.72 29.41,51.72 28.83,51.14 25.82,51.14 25.67,50.99 23.71,50.99 23.47,51.24 22.9,51.24 21.4,49.74 18.77,49.74 v6(17.5,48.47)
  BOTTOM w0.127: v6(47.14,85.53) 46.58,84.97 RT71.2
CLKREQ_PCIE#6_R: length 4
  BOTTOM w0.076: 44.93,83.99 44.08,83.99 43.63,84.44 UT2.AC5
  BOTTOM w0.127: RT10.2 45.95,84.37 45.57,83.99 44.93,83.99
  BOTTOM w0.145: RT71.1 RT10.2
CLKREQ_PCIE#7: length 116.6
  TOP w0.127: RH104.2 22.11,50.78 v7(22.18,50.71) ; v2(41.73,86.21) v1(44.23,86.21) 45.59,84.85 46.84,84.85 48.45,83.24 v7(51.3,83.24)
  IN1 w0.064: v7(22.18,50.71) 22.5,51.03 22.5,54.41 23.02,54.92 23.02,56.57 26.63,60.18 27.43,60.18 28.62,61.37 28.7,61.45 33.92,61.45 34.23,61.77 37.93,61.77 38.69,62.53 38.69,63.25 39.13,63.68 39.13,68.07 39.29,68.24 39.29,70.82 40.21,71.74 40.21,74.23 40.54,74.56 40.54,80.36 41.96,81.78 41.96,85.98 v2(41.73,86.21) ; v4(60.28,67.56) 60.63,67.56 62,66.2 72.24,66.2 79.19,59.24 81.41,59.24 81.73,59.57 v4(81.97,59.57)
  GND2 w0.102: v5(22.52,50.89) 22.36,50.89 v7(22.18,50.71) ; v5(60.02,67.82) v4(60.28,67.56) ; v4(81.97,59.57) 82.28,59.57 v5(82.33,59.52) ; v7(51.3,83.24) v5(51.3,82.89)
  GND3 w0.102: v5(82.33,59.52) 82.57,59.28 v6(82.57,59.24) ; v8(60.25,68.1) 60.25,68.06 v5(60.02,67.82) ; v5(22.52,50.89) 22.6,50.81 22.84,50.81 v8(22.86,50.83) ; v5(51.3,82.89) v8(51.3,82.53)
  IN3 w0.064: v8(60.25,68.1) 60.25,68.13 49.86,78.52 49.86,81.08 v8(51.3,82.53) ; v8(22.86,50.83) 22.88,50.85 30.41,50.85 v6(30.53,50.73)
  BOTTOM w0.076: UH4.AR31 v6(30.53,50.73)
CLKREQ_PCIE#8: length 27.9
  TOP w0.127: v2(26.85,60.63) 25.88,61.6 v1(25.88,62.5) 25.88,63.15 24.99,64.04 UR1.2
  IN1 w0.064: v2(26.85,60.63) 22.84,56.62 22.84,54.95 22.12,54.23 v4(22.12,53.5)
  GND2 w0.102: v4(22.12,53.5) 22.15,53.47 22.53,53.47 v5(22.55,53.45)
  GND3 w0.102: v6(22.94,53.24) 22.74,53.45 v5(22.55,53.45)
  IN3 w0.064: v3(17.5,48.97) 18.41,49.88 21.34,49.88 22.32,50.86 22.32,50.88 23.15,51.71 23.15,53.04 v6(22.94,53.24)
  BOTTOM w0.076: v6(22.94,53.24) 23.07,53.24 24.8,51.52 24.8,51.17 25.32,50.65 26.02,50.65 26.18,50.81 UH4.BD32
CLKRUN#: length 9.9
  TOP w0.127: v7(21.26,48.85) v1(21.26,49.88)
  GND2 w0.102: v5(21.59,48.47) 21.26,48.8 v7(21.26,48.85)
  GND3 w0.102: v5(21.59,48.47) v8(21.59,48.11)
  IN3 w0.064: v6(28.53,45.69) 28.53,45.69 28.04,46.18 25.48,46.18 23.77,47.9 22.49,47.9 22.27,48.11 v8(21.59,48.11)
CPU_24MHZ_N: length 82.8
  IN1 w0.086: v9(46.2,34.22) 46.12,34.3 46.12,35.57 48.52,37.96 48.52,39.94 56.68,48.11 56.68,52.29 54.86,54.11 54.86,62.28 56.7,64.12 56.7,64.84 60.12,68.25 61.31,68.25 62.55,67.01 69.51,67.01 73.68,71.18 73.68,75.49 78.14,79.95 78.14,80.77 79.17,81.79 87.67,81.79 88.08,82.2 88.47,82.2 88.53,82.15 88.53,82.02 v6(88.36,81.86)
  GND2 w0.102: v5(88.13,82.09) v6(88.36,81.86)
  GND3 w0.102: v6(88.36,81.86) v5(88.13,82.09)
  BOTTOM w0.076: UH4.F1 45.04,35.55 44.97,35.47 44.97,35.33 45.37,34.93 45.74,34.93 45.95,34.73 45.95,34.48 v9(46.2,34.22)
CPU_24MHZ_P: length 82.8
  IN1 w0.086: v6(88.36,82.51) 87.95,82.51 87.54,82.1 79.04,82.1 77.83,80.89 77.83,80.08 73.37,75.62 73.37,71.31 69.38,67.32 62.68,67.32 61.44,68.56 59.99,68.56 56.39,64.97 56.39,64.25 54.55,62.41 54.55,53.99 56.37,52.16 56.37,48.24 48.21,40.07 48.21,38.09 45.81,35.69 45.81,34.41 v9(45.62,34.22)
  GND2 w0.102: v5(88.13,82.74) v6(88.36,82.51)
  GND3 w0.102: v6(88.36,82.51) v5(88.13,82.74)
  BOTTOM w0.076: v9(45.62,34.22) 45.78,34.38 45.78,34.66 45.67,34.77 45.3,34.77 44.8,35.26 44.8,35.47 44.73,35.55 UH4.G1
CPU_DP1_AUXN: length 106.2
  IN3 w0.061: v3(77.54,65.17) 77.69,65.03 77.69,64.93 77.92,64.7 78.84,64.7 79.46,64.08 79.46,61.08 79.78,60.76 79.78,60.41 81.3,58.88 81.3,58.47 81.58,58.19 81.93,58.19 82.07,58.06 82.07,56.21 81.42,55.56 81.3,55.56 81.29,55.55
  IN3 w0.086: v3(100.62,22.57) 100.65,22.6 100.65,23.24 94.95,28.94 78.33,28.94 77.85,29.42 69.46,29.42 62.53,36.36 62.53,44.12 61.84,44.81 61.84,51.01 63.87,53.04 71.95,53.04 72.36,53.45 79.19,53.45 81.29,55.55
  BOTTOM w0.145: v3(77.54,65.17) 77.22,64.86 UC1.D34 ; v3(100.62,22.57) 100.65,22.54 100.65,21.7 99.99,21.04 v10(99.99,20.47) 99.99,19.32 99.36,18.69 99.36,14.36 101.56,12.16 101.8,12.16 JIO1.J13
CPU_DP1_AUXP: length 106.2
  IN3 w0.061: 81.51,55.33 81.52,55.34 81.52,55.45 82.22,56.14 82.22,58.12 82,58.34 81.64,58.34 81.45,58.53 81.45,58.94 79.93,60.47 79.93,60.82 79.61,61.14 79.61,64.14 78.9,64.85 77.98,64.85 77.84,65 77.84,65.22 77.91,65.3 78.07,65.3 v3(78.19,65.17)
  IN3 w0.086: 81.51,55.33 79.32,53.14 72.49,53.14 72.08,52.73 64,52.73 62.15,50.88 62.15,44.93 62.84,44.25 62.84,36.49 69.59,29.73 77.98,29.73 78.46,29.25 95.08,29.25 100.96,23.36 100.96,22.61 v3(101,22.57)
  BOTTOM w0.145: v3(101,22.57) 100.96,22.53 100.96,21.57 100.3,20.91 100.3,19.2 99.67,18.56 99.67,14.49 101.69,12.47 101.9,12.47 102.06,12.63 JIO1.H13 ; v3(78.19,65.17) 77.87,64.86 UC1.E34
CPU_DP1_CTRL_CLK: length 6.6
  IN3 w0.064: v3(27.43,37.22) 26.73,36.52 26.73,34.66 26.18,34.12 v3(26.18,34.07)
  BOTTOM w0.076: UH4.BA5 v3(27.43,37.22) ; 25.47,33.36 v3(26.18,34.07)
  BOTTOM w0.127: RP1.3 25.3,33.19 25.47,33.36
CPU_DP1_CTRL_DATA: length 6.1
  IN3 w0.064: v3(25.9,34.37) 26.16,34.37 26.5,34.72 26.5,36.72 v3(26.85,37.07)
  BOTTOM w0.076: v3(25.9,34.37) 25.9,34.19 25.07,33.36
  BOTTOM w0.127: RP1.2 24.8,33.09 25.07,33.36
CPU_DP1_HPD: length 113.5
  TOP w0.127: v2(84.81,17.86) v1(84.81,13.93) 84.81,13.34 v2(84.72,13.25)
  IN1 w0.064: v4(27.35,34.52) 27.38,34.5 29.01,34.5 31.64,31.87 37.87,31.87 41.04,28.7 43.72,28.7 45.38,27.04 55.11,27.04 55.81,26.34 57.21,26.34 57.89,25.66 60.37,25.66 60.59,25.44 65.07,25.44 69.79,20.72 73.33,20.72 75.91,18.14 84.53,18.14 v2(84.81,17.86) ; v2(84.72,13.25) 84.84,13.13 90.09,13.13 90.8,12.42 93.44,12.42 93.85,12.83 97.75,12.83 98.24,13.32 102.09,13.32 102.93,14.16 104.47,14.16 104.51,14.12 106.14,14.12 106.18,14.16 110.58,14.16 110.88,14.46 111.29,14.46 111.45,14.61 112,14.61 112.34,14.27 112.34,12.5 111.14,11.29 111.14,10.54 110.54,9.94 110.39,9.94 110.04,10.28 109.56,10.28 v4(109.45,10.4)
  GND2 w0.102: v4(27.35,34.52) v5(26.9,34.52) ; v4(109.45,10.4) 109.11,10.4 v5(109.04,10.33)
  GND3 w0.102: v6(27.03,34.21) 26.9,34.35 v5(26.9,34.52) ; v6(109.06,10) 109.06,10.31 v5(109.04,10.33)
  IN3 w0.064: v6(27.03,34.21) 27.09,34.26 27.29,34.26 27.85,34.82 27.85,36.24 28.16,36.56 v3(28.37,36.56)
  BOTTOM w0.076: v6(27.03,34.21) 27.03,33.98 26.77,33.71 26.77,33.36 ; UH4.AW4 28.5,36.69 v3(28.37,36.56)
  BOTTOM w0.127: JIO1.M6 v6(109.06,10) ; 26.77,33.36 26.77,31.07 RH617.1
CPU_DP1_N0: length 95.2
  IN3 w0.061: v3(78.17,56.64) 78.28,56.53 78.28,56.4 78.22,56.34 77.16,56.34 76.7,56.79 73.95,56.79 73.87,56.87 73.86,56.87
  IN3 w0.086: 73.86,56.87 71.11,56.87 70.15,55.91 62.69,55.91 58.84,52.06 58.84,43.84 59.51,43.17 59.51,41.95 59.63,41.84 59.63,35.01 69.49,25.14 79.58,25.14 80.31,24.42 85.92,24.42 87.04,25.53 91.31,25.53 91.77,25.99 92.98,25.99 94.5,24.47 95.29,24.47 97.2,22.56 97.2,22.06 98.98,20.29 98.98,19.77 100.18,18.56 100.18,18.18 v3(100.15,18.14)
  BOTTOM w0.102: 101.31,14.96 101.86,14.41 102.55,14.41 JIO1.G12
  BOTTOM w0.145: 101.31,14.96 100.85,14.96 100.18,15.64 100.18,18.11 v3(100.15,18.14)
CPU_DP1_N1: length 93.6
  IN3 w0.061: 74.64,55.78 74.65,55.78 74.73,55.86 76.71,55.86 77.17,55.4 78.45,55.4 79.48,56.43 79.94,56.89 80.14,56.89 80.2,56.83 v3(80.2,56.64)
  IN3 w0.086: v3(104.56,17.4) 104.37,17.58 104.37,17.8 103.55,18.62 101.83,18.62 100.36,20.09 100.36,20.33 98.27,22.42 98.27,23 95.78,25.49 94.94,25.49 93.39,27.04 91.31,27.04 90.83,26.55 74.45,26.55 74.12,26.88 69.31,26.88 60.7,35.5 60.7,43.41 59.94,44.17 59.94,51.7 63.14,54.9 71.07,54.9 71.96,55.78 74.64,55.78
  BOTTOM w0.102: JIO1.E11 104.56,16.4 v3(104.56,17.4)
CPU_DP1_N2: length 93.6
  IN3 w0.061: 79.26,55.55 79.27,55.56 79.39,55.56 79.95,56.11 80.17,56.11 80.52,56.46 80.52,56.89 80.52,57.42 80.4,57.54 79.58,57.54 79.42,57.38 v3(79.42,57.29)
  IN3 w0.086: v3(105.06,17.9) 105.06,17.96 104.87,18.14 104.73,18.14 104.34,18.54 104.34,20.04 103.37,21.01 100.23,21.01 98.66,22.59 98.66,23.16 95.93,25.89 95.14,25.89 93.6,27.44 91.08,27.44 90.62,26.98 76.55,26.98 75.56,27.97 68.8,27.97 61.09,35.68 61.09,43.57 60.34,44.32 60.34,51.54 63.3,54.49 71.3,54.49 71.7,54.9 78.61,54.9 79.26,55.55
CPU_DP1_N3: length 96.3
  IN3 w0.061: v3(80.2,58.59) 80.2,58.69 80.27,58.76 80.42,58.76 80.51,58.67 80.51,58.41 81.3,57.63 81.3,56.46 80.39,55.56 80.28,55.56 80.27,55.55
  IN3 w0.086: v3(105.58,17.28) 105.65,17.35 105.65,19.72 103.66,21.71 100.55,21.71 99.55,22.72 99.55,23.35 94.72,28.17 90.8,28.17 90.32,27.69 78.41,27.69 77.42,28.68 69.13,28.68 61.79,36.02 61.79,43.87 61.08,44.58 61.08,51.26 63.59,53.78 71.62,53.78 72.03,54.18 78.91,54.18 80.27,55.55
  BOTTOM w0.102: v3(105.58,17.28) 105.58,16.4 106.06,15.92 JIO1.E9
CPU_DP1_P0: length 95.1
  IN3 w0.061: v3(78.94,56.64) 78.94,56.71 78.85,56.8 78.53,56.8 78.43,56.7 78.43,56.34 78.28,56.19 77.1,56.19 76.64,56.64 73.95,56.64 73.87,56.56 73.86,56.56
  IN3 w0.086: 73.86,56.56 71.24,56.56 70.28,55.6 62.82,55.6 59.15,51.93 59.15,43.97 59.82,43.3 59.82,42.08 59.94,41.97 59.94,35.14 69.62,25.45 79.71,25.45 80.44,24.73 85.8,24.73 86.91,25.84 91.18,25.84 91.64,26.3 93.11,26.3 94.63,24.78 95.42,24.78 97.51,22.69 97.51,22.19 99.29,20.41 99.29,19.89 100.49,18.69 100.49,18.18 v3(100.53,18.14)
  BOTTOM w0.102: 101.42,15.27 101.51,15.19 101.61,15.19 101.81,15.38 102.86,15.38 103.06,15.18 JIO1.F12
  BOTTOM w0.145: v3(100.53,18.14) 100.49,18.11 100.49,15.77 100.98,15.27 101.42,15.27
CPU_DP1_P1: length 93.6
  IN3 w0.061: 74.64,56.09 74.65,56.09 74.73,56.01 76.78,56.01 77.24,55.55 78.39,55.55 79.05,56.21 79.88,57.04 80.14,57.04 80.2,57.1 v3(80.2,57.29)
  IN3 w0.086: 74.64,56.09 71.83,56.09 70.94,55.21 63.01,55.21 59.63,51.82 59.63,44.04 60.39,43.28 60.39,35.37 69.18,26.57 73.99,26.57 74.32,26.24 90.95,26.24 91.44,26.73 93.27,26.73 94.81,25.18 95.65,25.18 97.96,22.87 97.96,22.3 100.05,20.21 100.05,19.96 101.7,18.31 103.42,18.31 104.06,17.67 104.06,17.45 103.93,17.32 103.67,17.32 v3(103.57,17.42)
  BOTTOM w0.102: v3(103.57,17.42) 104.06,16.93 JIO1.D11
CPU_DP1_P2: length 93.6
  IN3 w0.061: 79.48,55.33 79.49,55.34 79.49,55.45 80.01,55.96 80.23,55.96 80.67,56.4 80.67,56.83 80.67,57.48 80.46,57.69 79.67,57.69 v3(79.42,57.94)
  IN3 w0.086: v3(105.06,18.9) 105.19,18.77 105.19,18.55 105.1,18.45 104.86,18.45 104.65,18.67 104.65,20.17 103.49,21.32 100.36,21.32 98.97,22.71 98.97,23.29 96.06,26.2 95.27,26.2 93.72,27.75 90.95,27.75 90.5,27.29 76.68,27.29 75.69,28.28 68.93,28.28 61.4,35.81 61.4,43.7 60.65,44.45 60.65,51.41 63.43,54.18 71.43,54.18 71.83,54.59 78.74,54.59 79.48,55.33
CPU_DP1_P3: length 96.4
  IN3 w0.061: 80.49,55.33 80.5,55.34 80.5,55.45 81.45,56.4 81.45,57.69 80.66,58.48 80.66,58.73 80.49,58.91 80.18,58.91 80.12,58.97 80.12,59.16 v3(80.2,59.24)
  IN3 w0.086: 80.49,55.33 79.04,53.87 72.16,53.87 71.75,53.47 63.72,53.47 61.39,51.14 61.39,44.7 62.1,43.99 62.1,36.15 69.26,28.99 77.54,28.99 78.53,28 90.19,28 90.67,28.48 94.85,28.48 99.86,23.48 99.86,22.85 100.68,22.02 103.78,22.02 105.96,19.85 105.96,17.38 106.04,17.29 106.19,17.29 v3(106.29,17.4)
  BOTTOM w0.102: JIO1.D9 106.36,16.9 106.46,17 106.46,17.22 v3(106.29,17.4)
CPU_DP2_AUXN: length 62.6
  IN3 w0.061: v3(77.87,63.99) 78.06,63.99 78.12,63.93 78.12,63.11 77.91,62.89 77.11,62.89 76.97,63.03 76.97,64.19 76.71,64.45 75.78,64.45 75.53,64.19 74.1,64.19 72.84,65.45 72.84,66.09 72.9,66.15
  IN3 w0.086: v3(48.26,85.25) 48.36,85.15 48.81,85.15 49.24,85.58 49.24,90.17 50.99,91.92 51.62,91.92 53.67,93.97 62.84,93.97 63.41,93.39 64.3,93.39 67.27,90.42 67.27,89.94 69.87,87.34 69.87,82.79 71.14,81.52 71.14,68.74 72.92,66.97 72.92,66.17 72.9,66.15
CPU_DP2_AUXN_C: length 8.4
  IN3 w0.086: v3(41.1,81.87) 41.1,82.52 41.38,82.8 42.17,82.8 43.56,84.18 45.1,84.18 46.17,85.25 v3(47.67,85.25)
CPU_DP2_AUXP: length 62.6
  IN3 w0.061: 72.61,66.17 72.61,66.16 72.61,66.15 72.63,66.15 72.69,66.09 72.69,65.39 74.04,64.04 75.59,64.04 75.85,64.3 76.65,64.3 76.82,64.12 76.82,62.97 77.05,62.74 77.97,62.74 78.27,63.04 78.27,63.93 78.33,63.99 v3(78.52,63.99)
  IN3 w0.086: v3(48.26,84.69) 48.4,84.84 48.94,84.84 49.55,85.45 49.55,90.04 51.12,91.61 51.75,91.61 53.79,93.66 62.71,93.66 63.28,93.08 64.17,93.08 66.96,90.29 66.96,89.81 69.56,87.21 69.56,82.66 70.83,81.39 70.83,68.61 72.61,66.84 72.61,66.17
CPU_DP2_AUXP_C: length 8.3
  IN3 w0.086: v3(41.75,81.87) 41.41,82.21 41.41,82.39 41.51,82.49 42.3,82.49 43.69,83.87 45.23,83.87 46.3,84.94 47.67,84.94 47.74,84.87 47.74,84.76 v3(47.67,84.69)
