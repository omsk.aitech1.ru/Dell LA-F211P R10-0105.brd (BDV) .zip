# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_N3: length 40.2
  IN3 w0.086: v3(34.26,41.83) 34.16,41.73 33.3,41.73 33.19,41.84 33.19,42.78 32.93,43.05 32.27,43.05 31.84,43.48 31.84,44.97 31.95,45.08 32.33,45.08 32.6,45.35 32.6,47.58 32.33,47.84 31.42,47.84 31.27,48 31.27,48.57 31.36,48.65 32.09,48.65 32.43,48.99 32.43,49.81 32.52,49.9 36.75,49.9 37.09,50.24 37.09,51.12 36.71,51.5 33.92,51.5 33.77,51.34 33.35,51.34 33.2,51.49 33.2,52.85 33.84,53.48 33.84,54.02 33.4,54.46 33.4,55.43 32.89,55.93 32.89,57.68 32.12,58.46 32.12,62.23 31.21,63.15 31.21,63.33 31.4,63.52 31.44,63.52 v3(31.47,63.54)
  BOTTOM w0.076: v3(34.26,41.83) 34.38,41.71 35.22,41.71 35.52,41.4 35.52,39.42 35.26,39.16 35.15,39.16 UH4.AG8
USB20_N4: length 38.2
  IN3 w0.061: 39.75,39.22 39.43,39.22 37.83,37.62 37.83,37.03 36.44,35.64 35.76,35.64 v3(35.66,35.55)
  IN3 w0.086: v3(36.89,63.54) 36.73,63.38 36.73,63.07 35.18,61.51 35.18,59.04 34.83,58.69 34.83,57.61 36.82,55.62 37.29,55.62 37.33,55.58 38.03,55.58 38.48,55.13 38.48,54.61 39.22,53.87 39.22,52.82 39.31,52.73 39.91,52.73 40.48,52.15 40.48,51.77 40.48,50.73 41.12,50.09 41.12,49.09 40.57,48.54 40.57,46.45 40.65,46.37 42.13,46.37 42.51,45.98 42.51,45.16 42.18,44.82 42.18,44.45 42.42,44.2 42.42,43.1 41.95,42.63 41.68,42.63 41.4,42.34 41.4,40.75 39.87,39.22 39.75,39.22
USB20_N6: length 99.3
  IN3 w0.061: v3(35.04,35.96) 35.15,35.85 35.15,35.46 35.51,35.11 36.05,35.11 36.09,35.07
  IN3 w0.086: v3(112.53,12.22) 112.61,12.14 112.74,12.14 113.17,11.71 113.17,11.14 111.45,9.42 107.82,9.42 107.73,9.5 107.73,9.5 107.66,9.57 107.12,9.57 105.37,7.82 104.69,7.82 104.51,7.82 103.51,6.82 102.86,6.82 102.25,6.21 93.52,6.21 93.43,6.3 90.26,6.3 90.04,6.08 84.28,6.08 82.63,7.73 70.86,7.73 69.71,8.88 63.02,8.88 50.22,21.68 44.22,21.68 39.37,26.52 39.37,27.68 39.36,27.69 39.36,27.95 39.36,29.72 37.2,31.88 37.2,32.31 36.44,33.08 36.44,34.72 36.09,35.07
  BOTTOM w0.102: v3(112.53,12.22) 112.36,12.39 111.57,12.39 JIO1.H4
USB20_N8: length 28.9
  IN3 w0.061: v3(40.04,40.66) 39.9,40.8 39.6,40.8 39.16,40.35 39.16,39.62 38.81,39.26 34.28,39.26 34.19,39.35 33.57,39.35 33.27,39.05 32.99,39.05 32.78,39.26 32.58,39.26 32.41,39.08 v3(32.41,38.69)
  BOTTOM w0.076: v3(32.41,38.69) 32.57,38.69 32.64,38.76 UH4.AL8 ; 50.26,42.02 50.25,42.01 49.33,42.01 48.39,41.06 47.43,41.06 47.38,41.01 46.94,41.01 46.74,40.93 46.52,40.7 46.52,40.46 46.34,40.29 45.9,40.29 45.5,40.7 43.59,40.7 43.23,40.34 41.79,40.34 41.33,40.8 40.18,40.8 v3(40.04,40.66)
  BOTTOM w0.145: 50.26,42.02 50.97,42.72 v10(52.8,42.72) 53.03,42.72 53.37,42.38 53.79,42.38 53.89,42.27 D429.2 54.24,42.19 54.35,42.19 54.67,41.88 54.67,41.61 54.85,41.43 54.85,40.97 54.76,40.87 JDEBUG1.4
USB20_N10: length 147.2
  IN3 w0.061: 33.56,36.93 33.58,36.94 33.58,37.86 33.34,38.09 33.34,38.49 33.76,38.9 v3(33.76,39.05)
  IN3 w0.086: v3(151.31,1.7) 151.23,1.78 149.69,1.78 147.33,4.14 115.41,4.14 115.18,3.91 109.4,3.91 109.19,3.89 108.99,3.84 108.8,3.76 108.48,3.59 107.79,2.9 107.79,2.35 106.67,1.22 101.91,1.22 100.38,2.75 96.44,2.75 95.3,1.61 91.01,1.61 90.24,2.37 88.39,2.37 88.17,2.59 84.8,2.59 81.76,5.63 68.97,5.63 68.26,6.34 62.28,6.34 50.16,18.46 38.64,18.46 36.82,20.28 36.82,28.23 34.01,31.04 34.01,33.35 32.45,34.9 32.45,35.88 33.43,36.86 33.49,36.86 33.56,36.93
USB20_N10_FP: length 16.4
  BOTTOM w0.145: ML1.2 152.04,1.83 152.27,1.83 152.42,1.68 153.83,1.68 v10(154.02,1.87) 154.54,2.39 155.37,2.39 155.74,2.76 155.74,4.12 155.32,4.54 155.32,5.32 154.4,6.24 154.4,8.9 154.58,9.08 154.79,9.08 154.96,8.91 154.96,8.77 DI5.2 155.7,8.81 155.84,8.81 155.94,8.71 155.94,8.58 156.46,8.06 156.54,8.06 156.69,7.91 156.69,7.64 157.1,7.23 157.1,7.01 156.91,6.82 JFP1.3
USB20_N11: length 98.1
  IN3 w0.086: v3(38.52,35.06) 38.45,34.99 38.45,32.16 40.38,30.23 40.38,26.94 44.63,22.69 50.64,22.69 63.39,9.94 70.16,9.94 71.36,8.74 83.05,8.74 84.49,7.31 100.09,7.31 101.59,8.81 104.02,8.81 105.15,9.94 106.06,9.94 106.7,10.58 111.18,10.58 111.47,10.88 111.47,12.86 112.3,13.68 112.89,13.68 113.43,14.22 113.43,15.22 113.71,15.5 113.98,15.5 114.11,15.63 114.11,15.85 v3(114.06,15.9)
  BOTTOM w0.076: UH4.W2 38.53,35.99 38.53,36.12 38.59,36.19 38.74,36.19 38.85,36.08 38.85,35.81 38.6,35.56 38.6,35.46 38.41,35.27 38.41,35.17 v3(38.52,35.06)
USB20_P1: length 238.8
  TOP w0.145: LV4.4 150.66,104.62 150.66,103.99 v9(150.71,103.94)
  IN3 w0.061: 33.74,36.02 33.74,36.04 33.82,36.12 33.82,36.56 34.52,37.25 34.52,37.76 v3(34.94,38.18)
  IN3 w0.086: v9(150.71,103.94) 150.53,103.76 150.53,101.69 151.02,101.2 151.02,95.31 152.75,93.59 152.75,81.29 148.26,76.79 148.26,74.25 150.03,72.47 150.74,72.47 152.78,70.43 152.78,45.58 150.81,43.62 150.81,35.33 148.43,32.94 148.43,29.61 147.32,28.5 141.74,28.5 141.13,27.89 141.13,26.69 140.16,25.72 140.16,23.3 139.01,22.15 133.65,22.15 132.59,21.09 131.37,21.09 130.6,20.32 126.77,20.32 124.64,18.19 124.64,14.46 123.75,13.57 123.75,10.96 119.03,6.25 112.02,6.25 110.39,4.61 109.36,4.61 109.08,4.58 108.65,4.5 108.44,4.41 108.04,4.15 107.09,3.2 107.09,2.64 106.4,1.95 102.31,1.95 100.79,3.46 96.09,3.46 94.94,2.32 91.29,2.32 90.31,3.29 85.09,3.29 82.05,6.33 69.52,6.33 68.8,7.05 62.87,7.05 50.76,19.16 38.93,19.16 37.59,20.5 37.59,28.58 34.71,31.45 34.71,33.84 33.74,34.82 33.74,36.02
USB20_P1_R: length 9.4
  TOP w0.145: LV4.3 150.65,105.35 150.65,105.81 150.33,106.14 v10(150.02,106.14) 149.65,106.14 148.96,105.45 DV7.3 147.44,105.13 147.24,105.13 v9(147.09,105.28)
  BOTTOM w0.145: JCAM1.10 144.58,102.55 144.68,102.45 144.77,102.45 145.42,103.11 145.42,103.93 146.55,105.07 146.88,105.07 v9(147.09,105.28)
USB20_P2: length 119.1
  IN3 w0.061: v3(36.04,38.18) 35.94,38.18 35.84,38.08 35.84,37.8 35.9,37.74 36.48,37.74 36.68,37.54 36.68,36.86 36.36,36.53 35.9,36.53 35.62,36.81 34.98,36.81 34.75,36.58 34.75,35.23 34.9,35.08 35.01,35.08 35.02,35.07
  IN3 w0.086: v3(114.06,18.9) 113.89,19.07 113.89,19.25 114.01,19.37 114.42,19.37 115.19,18.61 115.19,14.97 114.55,14.34 114.55,11.91 114.03,11.38 114.03,8.21 113.07,7.26 111.55,7.26 109.91,5.62 109.31,5.62 109.21,5.61 109.18,5.64 108.91,5.58 108.91,5.58 108.36,5.47 107.98,5.32 107.96,5.31 106.89,4.59 103.54,4.59 103.43,4.48 95.55,4.48 94.48,3.41 91.62,3.41 90.73,4.3 85.51,4.3 82.47,7.34 70.7,7.34 69.61,8.43 62.92,8.43 51.02,20.32 39.36,20.32 38.68,21 38.68,28.96 35.89,31.76 35.89,34.2 35.02,35.07
USB20_P3: length 40.3
  IN3 w0.086: v3(34.26,41.42) 33.17,41.42 32.88,41.71 32.88,42.65 32.8,42.74 32.14,42.74 31.53,43.36 31.53,45.1 31.82,45.39 32.2,45.39 32.29,45.48 32.29,47.45 32.2,47.53 31.29,47.53 30.96,47.87 30.96,48.69 31.23,48.96 31.96,48.96 32.12,49.12 32.12,49.94 32.39,50.21 36.62,50.21 36.78,50.37 36.78,50.99 36.58,51.19 34.05,51.19 33.9,51.03 33.22,51.03 32.89,51.36 32.89,52.98 33.53,53.61 33.53,53.9 33.09,54.34 33.09,55.3 32.58,55.8 32.58,57.56 31.81,58.33 31.81,62.1 30.9,63.02 v3(30.9,63.54)
  BOTTOM w0.076: v3(34.26,41.42) 34.36,41.54 35.15,41.54 35.36,41.33 35.36,39.49 35.19,39.33 35.01,39.33 34.94,39.4 UH4.AG10
USB20_P4: length 38.3
  IN3 w0.061: 39.98,39.77 39.97,39.76 39.97,39.66 39.68,39.37 39.37,39.37 37.68,37.69 37.68,37.09 36.38,35.79 35.56,35.79 35.49,35.87 35.49,35.97 35.57,36.05 v3(35.66,36.05)
  IN3 w0.086: 39.98,39.77 41.09,40.88 41.09,42.47 41.55,42.94 41.82,42.94 42.11,43.22 42.11,44.08 41.87,44.32 41.87,44.95 42.2,45.28 42.2,45.86 42,46.06 40.52,46.06 40.26,46.32 40.26,48.67 40.81,49.22 40.81,49.97 40.17,50.6 40.17,51.89 40.17,51.9 40.17,52.02 39.78,52.42 39.18,52.42 38.91,52.69 38.91,53.75 38.17,54.49 38.17,55 37.9,55.27 37.2,55.27 37.16,55.31 36.69,55.31 34.52,57.48 34.52,58.82 34.87,59.17 34.87,61.64 36.42,63.19 36.42,63.44 v3(36.32,63.54)
USB20_P6: length 99.3
  IN3 w0.061: 36.34,35.26 35.57,35.26 35.3,35.53 35.3,36.21 v3(35.04,36.47)
  IN3 w0.086: v3(112.49,11.35) 112.35,11.35 112.23,11.48 112.23,11.68 112.38,11.83 112.61,11.83 112.86,11.58 112.86,11.27 111.32,9.73 107.94,9.73 107.79,9.88 106.99,9.88 105.24,8.13 104.69,8.13 104.38,8.13 103.39,7.13 102.73,7.13 102.12,6.52 93.64,6.52 93.56,6.61 90.13,6.61 89.91,6.39 84.41,6.39 82.76,8.04 70.99,8.04 69.84,9.19 63.14,9.19 50.35,21.99 44.34,21.99 39.68,26.65 39.68,27.81 39.67,27.82 39.67,29.85 37.51,32.01 37.51,32.44 36.75,33.2 36.75,34.85 36.34,35.26
  BOTTOM w0.102: JIO1.J4 111.58,11.38 112.46,11.38 v3(112.49,11.35)
USB20_P8: length 28.9
  IN3 w0.061: v3(32.97,39.45) 32.97,39.29 33.05,39.2 33.21,39.2 33.51,39.5 34.25,39.5 34.34,39.41 38.74,39.41 39.01,39.68 39.01,40.42 39.54,40.95 40.03,40.95 v3(40.15,41.07)
  BOTTOM w0.076: 50.04,42.24 49.98,42.17 49.26,42.17 48.32,41.23 47.36,41.23 47.31,41.18 46.91,41.18 46.64,41.06 46.35,40.77 46.35,40.53 46.28,40.46 45.97,40.46 45.56,40.86 43.52,40.86 43.16,40.51 41.86,40.51 41.4,40.96 40.26,40.96 v3(40.15,41.07) ; UH4.AL7 32.99,38.64 32.99,39.43 v3(32.97,39.45)
  BOTTOM w0.145: 50.04,42.24 50.84,43.03 v10(51.28,43.03) 53.16,43.03 53.5,42.69 53.74,42.69 D429.3 54.24,42.5 54.48,42.5 54.98,42 54.98,41.74 55.16,41.56 55.16,40.97 55.26,40.87 JDEBUG1.3
USB20_P10: length 147.1
  IN3 w0.061: 33.56,36.55 33.74,36.73 33.73,36.74 33.73,37.92 33.49,38.16 33.49,38.42 33.8,38.74 33.99,38.74 34.07,38.66 34.07,38.41 33.95,38.29 v3(33.76,38.29)
  IN3 w0.086: 33.56,36.55 32.76,35.75 32.76,35.03 34.32,33.48 34.32,31.17 37.13,28.36 37.13,20.4 38.76,18.77 50.29,18.77 62.41,6.65 68.39,6.65 69.1,5.94 81.89,5.94 84.93,2.9 88.3,2.9 88.52,2.68 90.37,2.68 91.14,1.92 95.17,1.92 96.31,3.06 100.51,3.06 102.03,1.53 106.54,1.53 107.48,2.48 107.48,3.03 108.29,3.84 108.67,4.04 108.9,4.13 109.14,4.19 109.39,4.22 115.05,4.22 115.28,4.45 147.46,4.45 149.82,2.09 151.2,2.09 v3(151.31,2.2)
USB20_P10_FP: length 16.5
  BOTTOM w0.145: JFP1.4 157.41,7.36 157,7.77 157,8.04 156.67,8.37 156.59,8.37 156.25,8.71 156.25,8.84 155.97,9.12 155.6,9.12 DI5.3 155.27,9.39 154.45,9.39 154.09,9.03 154.09,6.11 155.01,5.19 155.01,4.41 155.43,3.99 155.43,2.89 155.24,2.7 154.41,2.7 153.7,1.99 v10(152.74,1.99) 152.55,1.99 152.4,2.14 151.97,2.14 ML1.3
USB20_P11: length 98.2
  IN3 w0.086: v3(114.06,14.9) 114.06,15.07 113.94,15.19 113.84,15.19 113.74,15.09 113.74,14.09 113.02,13.37 112.42,13.37 111.78,12.73 111.78,10.75 111.31,10.27 106.83,10.27 106.19,9.63 105.28,9.63 104.15,8.5 101.72,8.5 100.22,7 84.36,7 82.92,8.43 71.23,8.43 70.04,9.63 63.26,9.63 50.51,22.38 44.51,22.38 40.07,26.81 40.07,30.1 38.14,32.03 v3(38.14,35.06)
  BOTTOM w0.076: v3(38.14,35.06) 38.24,35.16 38.24,35.34 38.44,35.53 38.44,35.71 38.37,35.78 38.37,36.3 UH4.W3
USB_ILIM1: length 30.6
  TOP w0.127: RP121.1 RP122.1 v1(39.06,64.47) 39.06,64.33 38.31,63.58 37.31,63.58 v2(36.48,64.41)
  IN1 w0.064: v2(36.48,64.41) 36.04,63.96 35.22,63.96 33.54,62.29 29.75,62.29 27.5,64.54 27.43,64.54 26.6,65.37 26.6,66.66 27.04,67.09 v4(27.04,68.41)
  GND2 w0.102: v4(27.04,68.41) v5(26.64,68.41)
  GND3 w0.102: v5(26.64,68.41) 26.51,68.54 v8(26.51,68.74)
  IN3 w0.064: v8(26.51,68.74) 22.1,68.74 21.92,68.92 21.63,68.92 20.94,69.61 v3(19.91,69.61)
  BOTTOM w0.127: v3(19.91,69.61) 19.82,69.7 19.82,71.16 20.22,71.57 US5.11
USB_ILIM2: length 66.3
  TOP w0.127: RP125.1 RP124.1 36.76,72.18 37.34,72.76 39.56,72.76 39.79,72.99 39.79,73.67 v1(38.96,74.5) 38.57,74.89 34.41,74.89 v2(34.2,74.68)
  IN1 w0.064: v2(34.2,74.68) 32.85,74.68 32.43,75.1 32.07,75.1 31.24,75.93 31.24,78.46 30.45,79.26 26.44,79.26 23.53,82.17 23.53,85.74 23.87,86.08 25.53,86.08 28.6,89.15 28.6,89.95 28.28,90.26 25.99,90.26 25.09,89.36 19.6,89.36 16.53,92.43 16.53,94.28 16.83,94.59 21.08,94.59 24.72,98.23 24.72,100.22 24.33,100.61 v2(23.51,100.61)
USB_OC0#: length 117.6
  TOP w0.127: v7(35.79,59.32) 35.79,59.32 37.05,58.06 41.76,58.06 44.03,55.79 44.56,55.79 45.4,54.96 45.4,35.91 46.89,34.41 47.83,34.41 v2(48,34.25) ; v2(79.83,28.53) v1(79.83,26.56) 79.83,25.54 78.97,24.67 78.97,23.02 77.28,21.33 77.28,16.31 v2(77.38,16.21)
  IN1 w0.064: v2(79.83,28.53) 79.13,29.23 69.05,29.23 67.98,30.3 65.69,30.3 65.03,30.95 63.04,30.95 62.09,31.9 58.19,31.9 57.98,31.69 56.25,31.69 55.49,32.45 55.26,32.45 52.83,34.88 48.38,34.88 48,34.5 v2(48,34.25) ; v2(77.38,16.21) 78.75,16.21 79.75,15.21 84.08,15.21 84.91,14.38 90.48,14.38 91.75,13.11 97.63,13.11 98.16,13.64 101.98,13.64 102.79,14.44 105.43,14.44 v4(105.51,14.52)
  GND2 w0.102: v5(105.92,14.6) 105.88,14.64 105.55,14.64 105.51,14.6 v4(105.51,14.52) ; v5(35.45,59.07) 35.7,59.32 v7(35.79,59.32)
  GND3 w0.102: v6(106.06,14.9) 105.92,14.76 v5(105.92,14.6) ; v6(35.45,59.56) v5(35.45,59.07)
  BOTTOM w0.076: 35.53,58.76 35.88,58.4 35.88,56.92 35.86,56.9 35.86,56.61 36.1,56.37 UH4.AD43
  BOTTOM w0.127: v6(35.45,59.56) 35.45,58.83 35.53,58.76
USB_OC1#: length 127.6
  TOP w0.127: v7(36.47,61.37) 36.77,61.66 39.66,61.66 45.81,55.52 45.81,36.07 47.06,34.82 48.4,34.82 v2(48.74,34.47) ; v2(79.42,28.53) 79.42,25.96 78.18,24.71 78.18,22.8 76.87,21.5 76.87,15.86 v1(74.68,13.67) 73.63,12.61 v2(73.21,12.61)
  IN1 w0.064: v4(104.37,11.71) 103.98,11.31 99.7,11.31 98.46,10.07 97.16,10.07 96.92,10.31 93.82,10.31 93.12,9.61 89.38,9.61 89.14,9.37 88.32,9.37 87.94,9.75 85.48,9.75 85.09,10.15 84.07,10.15 83.69,10.52 79.65,10.52 77.86,12.31 73.51,12.31 v2(73.21,12.61) ; v2(79.42,28.53) 78.89,29.06 68.98,29.06 67.91,30.13 65.62,30.13 64.94,30.81 62.98,30.81 62.03,31.76 58.25,31.76 58.04,31.55 56.19,31.55 55.43,32.31 55.2,32.31 53.14,34.37 48.84,34.37 v2(48.74,34.47)
  GND2 w0.102: v7(36.47,61.37) 36.61,61.23 v5(36.61,61.04) ; v5(104.62,11.93) 104.59,11.93 v4(104.37,11.71)
  GND3 w0.102: v6(36.38,60.72) 36.38,60.82 v5(36.61,61.04) ; v6(105.06,11.9) 105.04,11.92 104.63,11.92 v5(104.62,11.93)
  BOTTOM w0.076: UH4.AD42 36.23,55.95 36.33,56.05 36.33,56.89 36.24,56.98 36.24,58.51 36.05,58.7 36.05,58.76
  BOTTOM w0.127: 36.05,58.76 36.05,59.27 36.04,59.28 36.04,60.39 36.14,60.48 36.14,60.48 v6(36.38,60.72)
USB_OC2#: length 27.4
  IN2 w0.074: v5(22.06,66.39) 22.56,66.9 v5(22.56,68.8)
  GND3 w0.102: v5(22.56,68.8) 22.65,68.89 v6(22.65,69.12) ; v8(21.62,66.26) 21.75,66.39 v5(22.06,66.39)
  IN3 w0.064: v3(32.76,60.85) 33.76,59.85 33.76,56.28 34.39,55.65 34.39,55.07 34.93,54.53 v3(36.04,54.53) ; v3(27.16,63.92) 27.16,64.2 26.64,64.73 26.64,65.98 26.36,66.26 v8(21.62,66.26)
  BOTTOM w0.127: CP18.2 v6(22.65,69.12) 22.01,69.76 US5.8 ; v3(32.76,60.85) 32.67,60.85 32.19,61.33 30.24,61.33 29.94,61.62 29.46,61.62 v1(28.01,63.08) v3(27.16,63.92)
USB_OC3#: length 70.7
  TOP w0.127: v2(22.2,102.08) 22.82,102.08 23.36,102.62 24.48,102.62 24.71,102.39 US6.8
  IN1 w0.064: v4(27.67,91.41) 27.36,91.1 25.78,91.1 25.28,90.59 24.41,90.59 23.73,91.27 23.02,91.27 21.43,92.86 21.43,94.75 24.86,98.17 24.86,101.96 24.74,102.08 v2(22.2,102.08)
  GND2 w0.102: v5(27.76,91.89) 27.67,91.8 v4(27.67,91.41)
  IN2 w0.074: v5(36.74,59.01) 36.99,59.01 37.88,59.9 37.88,61 37.68,61.2 37.68,61.5 36.47,62.7 32.33,62.7 27.46,67.58 26.59,67.58 26.06,68.11 26.06,78.02 26.89,78.86 26.89,86.53 26.33,87.09 26.33,88.52 25.94,88.91 25.94,89.81 27.76,91.62 v5(27.76,91.89)
  GND3 w0.102: v6(36.38,59.01) v5(36.74,59.01)
  BOTTOM w0.076: 36.38,58.76 36.38,58.6 36.46,58.53 36.46,57.04 36.61,56.88 UH4.AC44
  BOTTOM w0.127: 36.38,58.76 v6(36.38,59.01) RH159.1
USB_OC4#: length 5.1
  BOTTOM w0.076: 39.76,58.76 39.45,58.44 39.18,58.44 39.11,58.38 39.07,58.38 38.56,57.86 38.56,56.98 38.63,56.92 38.63,56.5 38.38,56.25 UH4.Y43
  BOTTOM w0.127: RH650.1 40.8,59.8 39.76,58.76
USB_OC5#: length 6.2
  BOTTOM w0.076: 39.47,58.76 39.32,58.61 38.89,58.61 38.05,57.77 38.05,56.52 38.12,56.44 38.12,55.55 UH4.Y41
  BOTTOM w0.127: RH649.1 40.22,59.5 39.47,58.76
USB_OC6#: length 5
  BOTTOM w0.076: UH4.W44 38.89,56.89 38.73,57.05 38.73,57.76 39.25,58.28 39.57,58.28 40.04,58.76 40.24,58.76
  BOTTOM w0.127: 40.24,58.76 v1(40.8,59.32) 41.37,59.89 RH651.1
USB_OC7#: length 5.5
  BOTTOM w0.076: 40.89,58.76 40.59,58.76 39.25,57.42 39.25,57.05 39.12,56.92 39.12,56.45 38.89,56.21 UH4.W43
  BOTTOM w0.127: 40.89,58.76 41.94,59.81 RH652.1
VCI_IN2#: length 8.1
  TOP w0.122: UE3.D4 43.15,15.23 v7(42.98,15.4)
  IN1 w0.064: v7(35.82,16.47) 41.91,16.47 v7(42.98,15.4)
VCI_IN3#: length 7.7
  TOP w0.076: UE3.E4 v2(42.78,14.19)
  IN1 w0.064: v7(35.82,15.2) 36.87,15.2 37.14,14.92 37.51,14.92 37.91,14.52 41.85,14.52 41.92,14.45 42.52,14.45 v2(42.78,14.19)
VCORE_B+:
  vias: v3(133.83,33.61) v3(133.83,33.25) v3(133.83,32.92) v3(133.83,32.57) v3(133.83,32.24) v3(133.83,31.88) v3(133.83,31.53) v3(133.83,31.2) v3(133.83,30.84) v3(134.21,33.61) v3(134.21,33.28) v3(134.21,32.92) v3(134.21,32.59) v3(134.21,32.24) v3(134.21,31.88) v3(134.21,31.55) v3(134.21,31.2) v3(134.34,33.86) v3(134.59,33.58) v3(134.59,33.25) v3(134.59,32.9) v3(134.59,32.57) v3(134.59,32.21) v3(134.59,31.86) v3(134.59,31.53) v9(114.59,33.55) v9(114.59,32.94) v9(114.59,32.33) v9(114.69,31.75) v9(114.78,38.51) v9(115.07,33.24) v9(115.23,31.56) v9(115.82,31.55) v9(116.38,31.56) v9(116.94,31.54) v9(121.18,32.77) v9(121.18,32.19) v9(121.79,33.05) v9(121.79,32.49) v9(121.79,31.86) v9(122.07,37.88) v9(128.27,34.09) v9(128.27,33.51) v9(128.83,34.57) v9(128.83,34.01) v9(128.83,33.38) v9(129.21,39.33) v9(129.69,34.57) v9(129.69,33.93) v9(132.03,33.45) v9(132.03,32.84) v9(132.59,33.53) v9(132.59,32.96) v16(129.45,29.48)
VPP25_PG: length 100.3
  TOP w0.127: 61.19,75.58 61.06,75.71 58.96,75.71 58.71,75.46 QE31.2 ; 61.19,75.58 61.31,75.71 62.33,75.71 62.52,75.52 62.52,75.03 63,74.54 63,73.46 62.14,72.6 v7(61.5,72.6) ; 61.19,75.58 QE30.2 ; v2(47.02,33.13) 47.32,33.13 48.68,31.77 48.85,31.77 PR1813.1 ; 46.72,39.43 46.76,39.39 PR2338.1 ; 46.72,39.43 46.72,40.67 v1(46.83,40.79) 46.72,40.9 46.72,43.14 47.68,44.1 47.68,50.53 48.42,51.26 49.82,51.26 50.07,51.52 QE32.2 ; 46.72,39.43 46.72,36.45 47.34,35.83 v2(48.68,35.83) ; PR2317.1 66.23,46.64 66.01,46.87 60.15,46.87 59.6,46.32 v2(57.73,46.32)
  IN1 w0.064: v2(47.02,33.13) 47.02,33.21 47.6,33.79 47.6,34.76 v2(48.68,35.83) 48.84,36 49.96,36 52.52,38.56 52.52,41.27 57.57,46.32 v2(57.73,46.32) 58.57,47.15 59.28,47.15 59.58,47.45 59.58,50.99 60.55,51.96 v7(60.55,52.18)
  GND2 w0.102: v5(60.22,52.15) 60.25,52.18 v7(60.55,52.18) ; v7(61.5,72.6) v5(61.06,72.6)
  IN2 w0.074: v5(58.9,61.42) 58.82,61.42 55.66,58.26 55.66,53.93 57.44,52.15 v5(60.22,52.15)
  GND3 w0.102: v6(60.74,72.85) 60.99,72.6 v5(61.06,72.6) ; v6(59.28,61.42) v5(58.9,61.42)
  BOTTOM w0.127: 60.02,67.95 58.59,67.95 58.37,68.18 R1320.1 58.37,69.45 58.11,69.7 U15.5 ; 60.02,67.95 60.75,67.21 60.75,64.37 59.28,62.9 v6(59.28,61.42) ; 60.02,67.95 60.03,67.95 60.89,68.81 60.89,72.7 v6(60.74,72.85)
VR_ON: length 132.5
  TOP w0.127: RZ36.1 42.41,29.85 42.87,29.85 43.07,30.05 UE7.2 ; RZ36.1 42.21,31.17 43.23,32.19 45.48,32.19 v1(45.95,32.66) 46.76,33.47 47.38,33.47 v2(47.53,33.32) ; RZ36.1 RZ30.2
  IN1 w0.064: v2(47.53,33.32) 47.74,33.53 47.74,34.44 48.36,35.06 52.85,35.06 55.32,32.59 55.55,32.59 56.31,31.83 57.92,31.83 58.13,32.04 62.15,32.04 63.1,31.09 65.13,31.09 65.76,30.46 68.05,30.46 69.11,29.39 79.65,29.39 81.44,27.6 87.12,27.6 87.65,27.07 95.15,27.07 97.82,24.41 103.11,24.41 103.87,25.16 104.68,25.16 108.25,28.74 111.79,28.74 112.97,29.91 132.94,29.91 136.24,33.21 136.24,35.03 136.88,35.67 137.33,35.67 138.3,36.63 143.46,36.63 144.07,37.24 144.07,41.66 142.93,42.79 136.48,42.79 136.2,43.07 v2(135.28,43.07)
VR_SVID_ALERT#: length 30.7
  TOP w0.127: PR1127.1 142.41,48.35 v9(142.41,49.36)
  IN3 w0.064: v9(142.41,49.36) 142.1,49.67 137.27,49.67 135.92,51.02 135.92,53.87 135.5,54.29 135.5,69.32 137.31,71.13 v3(137.31,71.2)
  BOTTOM w0.127: RH49.1 137.3,71.19 v3(137.31,71.2)
VR_SVID_ALERT#_R: length 5.7
  BOTTOM w0.127: UC1.DG22 132.14,72.49 132.63,72.49 133.47,73.34 v1(135.16,73.34) 135.2,73.34 RH49.2
VR_SVID_CLK: length 37.5
  GND2 w0.102: v5(144.75,47.71) 144.94,47.9 v7(144.94,48.1)
  GND3 w0.102: v8(144.37,47.71) v5(144.75,47.71)
  IN3 w0.064: v8(144.37,47.71) 142.59,47.71 141.52,48.78 136.9,48.78 135.04,50.65 135.04,53.5 134.57,53.96 134.57,69.04 132.58,71.02 132.25,71.02 132.03,71.25 131.42,71.25 131.19,71.02 131.01,71.02 130.81,71.23 130.81,71.48 131.01,71.68 131.21,71.68 131.44,71.91 131.44,72.24 132.08,72.88 v3(132.4,72.88)
VR_SVID_DATA: length 39.9
  TOP w0.127: PR1129.1 143.76,48.62 v9(143.8,48.66)
  IN3 w0.064: v3(137.31,72.09) 135.67,70.45 135.67,70.14 135.01,69.49 135.01,54.15 135.48,53.68 135.48,50.83 137.09,49.22 141.7,49.22 142.27,48.66 v9(143.8,48.66)
  BOTTOM w0.127: v3(137.31,72.09) 137.31,72.55 v1(136.53,73.33) 136.01,73.84 133.3,73.84 132.73,73.28 131.49,73.28 UC1.DF22
VRA_VDD18: length 5.3
  TOP w0.203: 143.54,43.45 143.33,43.23 PU1100.26
  TOP w0.508: PR1101.2 145.56,45.09 145.39,44.91 PC1101.1 144.87,43.88 v1(144.75,43.77) 144.69,43.71 143.87,43.71 143.61,43.45 143.54,43.45
VRACPU_VINSEN: length 7.5
  TOP w0.127: PR1100.2 v1(133.71,33.69)
  TOP w0.203: PU1100.47 137.96,37.82 PC1100.1 136.52,36.38 136.52,34.66 PR1103.1 PR1100.2
VRACPU_VTEMP: length 98.1
  TOP w0.127: v9(106.17,36.25) 106.42,36.25 v1(106.71,35.96)
  TOP w0.203: PR1149.1 v9(134.53,38.63)
  IN1 w0.254: v9(149.91,62.92) 151.24,61.59 151.24,57.83 148.66,55.25 v9(148.66,53.68)
  IN2 w0.254: v5(132.89,30.26) 134.78,32.15 134.78,35.52 135.43,36.16 135.43,37.72 v9(134.53,38.63) ; v5(113.75,30.49) 112.3,31.94 112.3,33.04 ; v9(106.17,36.25) 106.19,36.23 106.19,35.11 107.11,34.19 111.15,34.19 112.3,33.04 ; v9(112.82,35.11) 112.75,35.11 112.3,34.66 112.3,33.04 ; v9(120.19,34.98) 120.19,34.83 119.76,34.4 v5(119.76,30.59) ; v9(127.4,36.35) 127.4,36.2 127.02,35.82 127.02,30.41 v5(126.87,30.26)
  VCC w0.254: v5(113.75,30.49) 113.83,30.41 119.58,30.41 v5(119.76,30.59) 120.01,30.33 126.79,30.33 v5(126.87,30.26) v5(132.89,30.26)
  BOTTOM w0.203: v9(120.19,34.98) 120.36,35.15 PU1201.11 ; PU1200.11 113.27,35.56 v9(112.82,35.11) ; v9(106.17,36.25) 106.36,36.25 106.62,36.51 PU1302.11 ; v9(148.66,53.68) 148.63,53.71 PU1300.11 ; PU1301.11 149.09,63.56 149.3,63.35 149.45,63.35 149.88,62.92 v9(149.91,62.92) ; PU1202.11 127.6,36.55 v9(127.4,36.35)
  BOTTOM w0.254: v9(134.53,38.63) 134.92,39.02 134.92,45.18 135.47,45.73 136.93,45.73 141.4,50.2 146.75,50.2 147.93,51.37 147.93,51.92 148.88,52.87 148.88,53.46 v9(148.66,53.68)
VSET_5105: length 9.9
  TOP w0.127: v1(53.27,21.03) 53.27,20.3 52.92,19.94 RE199.1 CE79.1 52.09,18.56 51.28,17.75 v2(50.92,17.75) ; v7(47.53,16.85) 47.53,16.17 UE3.C9
  IN1 w0.064: v2(50.92,17.75) 48.89,17.75 47.98,16.85 v7(47.53,16.85)
WLAN_WIGIG60GHZ_DIS#: length 69.1
  TOP w0.127: RE119.1 53.07,5.85 52.68,5.85 v2(52.63,5.9) 52.43,6.09 52.43,6.75 v1(52.05,7.14) 50.97,8.21 50.97,8.88 50.47,9.39 UE3.L13
  IN1 w0.064: v2(52.63,5.9) 52.89,5.63 55.67,5.63 55.91,5.4 59.89,5.4 61.04,4.25 72.89,4.25 73.04,4.1 78.32,4.1 78.59,3.83 79.84,3.83 80.04,4.03 83.56,4.03 83.79,4.25 84.55,4.25 84.8,4 86.06,4 86.57,4.51 89.85,4.51 90.26,4.11 92.07,4.11 92.19,3.99 93.33,3.99 94.86,5.52 98.01,5.52 98.82,6.33 103.14,6.33 103.84,7.03 103.84,7.65 106.54,10.35 108.94,10.35 109.27,10.68 109.59,10.68 109.84,10.42 110.27,10.42 v4(110.45,10.25)
  GND2 w0.102: v4(110.45,10.25) 110.77,9.93 v5(110.77,9.67)
  GND3 w0.102: v6(111.1,10) 111.1,9.94 110.83,9.67 v5(110.77,9.67)
  BOTTOM w0.127: JIO1.M4 111.06,9.96 v6(111.1,10)
XDP_BPM#0: length 1.2
  GND2 w0.102: v5(131.52,74.69) 131.52,74.77 v7(132.07,75.32)
  GND3 w0.127: v6(131.75,74.46) v5(131.52,74.69)
XDP_BPM#1: length 0.7
  GND2 w0.107: v5(130.87,74.69) v6(131.1,74.46)
  GND3 w0.127: v6(131.1,74.46) v5(130.87,74.69)
XDP_BPM#2: length 1
  GND2 w0.102: v7(129.64,74.41) 129.93,74.41 v5(130.22,74.69)
  GND3 w0.127: v6(130.45,74.46) v5(130.22,74.69)
XDP_BPM#3: length 1.1
  GND2 w0.102: v7(130.43,73.37) 130.43,73.47 v5(130.87,73.91)
  GND3 w0.127: v6(131.1,73.67) v5(130.87,73.91)
XDP_ITP_PMODE: length 214.3
  TOP w0.127: TP_ITP_PMODE.1 143.18,79.68 v2(142.55,79.06)
  IN1 w0.064: v2(142.55,79.06) 143.37,78.24 143.37,73.77 142.15,72.56 137.96,72.56 137.16,71.77 134.95,71.77 133.71,70.53 133.71,70.41 133.37,70.07 133.37,69.73 132.89,69.25 132.31,69.25 132.08,69.02 132.08,55.85 132.33,55.6 132.33,52.66 136.7,48.29 140.56,48.29 142.13,46.72 142.51,46.72 147.58,41.65 147.58,35.39 146.56,34.38 146.56,32.83 144.64,30.91 139.75,30.91 135.63,26.79 130.84,26.79 130.61,26.56 130.61,19.85 128.56,17.8 125.32,17.8 123.91,19.2 120.78,19.2 120.25,18.68 115.97,18.68 115.41,19.24 114.62,19.24 114.14,19.72 111.03,19.72 108.9,21.84 105.72,21.84 102.74,18.86 100.46,18.86 99.55,19.77 94.67,19.77 94.36,20.07 90.61,20.07 88.02,22.66 86.09,22.66 85.44,23.32 79.76,23.32 78.21,24.87 v17(76.65,24.87)
  GND2 w0.102: v5(76.3,24.97) 76.4,24.87 v17(76.65,24.87)
  GND3 w0.102: v6(75.79,24.87) 76.2,24.87 v5(76.3,24.97)
  BOTTOM w0.076: 30.25,33.36 30.25,35.61 29.98,35.87 UH4.AT2
  BOTTOM w0.127: v6(75.79,24.87) v1(75.39,25.27) 73.72,26.94 58.6,26.94 55.71,24.05 54.51,24.05 51.5,21.04 43.93,21.04 43.23,20.34 37.93,20.34 36.57,21.7 36.57,22.61 35.2,23.98 34.01,23.98 29.66,28.33 29.66,30.77 30.25,31.36 30.25,33.36
XDP_PRDY#: length 220.4
  IN1 w0.064: v4(137.36,72.66) 136.48,72.66 135.97,72.15 134.79,72.15 133.33,70.69 133.33,70.57 132.95,70.19 132.95,69.93 132.71,69.69 131.2,69.69 130.78,69.27 130.78,56.43 131.93,55.28 131.93,52.52 136.54,47.91 139.4,47.91 141.61,45.7 142.99,45.7 147.2,41.5 147.2,35.55 144.36,32.71 144.22,32.71 142.8,31.29 139.6,31.29 135.92,27.62 131.13,27.62 130.23,26.71 130.23,20.69 129.51,19.97 125.21,19.97 124.58,20.6 123.09,20.6 122.81,20.88 114.96,20.88 112.92,22.92 112.92,23.48 112.51,23.89 110.1,23.89 109.45,23.24 104.91,23.24 103.88,22.21 96.23,22.21 95.35,23.09 88.75,23.09 87.79,24.05 79.77,24.05 78.18,25.64 76.01,25.64 v4(75.85,25.8)
  GND2 w0.102: v5(144.53,78.54) 144.53,78.83 v7(144.6,78.91) ; v5(75.54,25.96) 75.7,25.8 v4(75.85,25.8) ; v5(137.69,72.66) v4(137.36,72.66)
  GND3 w0.102: v6(75.13,25.96) v5(75.54,25.96) ; v5(144.53,78.54) v8(144.88,78.54) ; v8(138.03,72.66) v5(137.69,72.66)
  IN3 w0.064: v3(131.75,72.1) 132.07,72.42 132.61,72.42 133.32,71.71 135,71.71 135.71,72.42 136.49,72.42 137.05,72.98 137.71,72.98 v8(138.03,72.66) 138.99,71.7 142.43,71.7 145.23,74.5 145.23,78.18 v8(144.88,78.54)
  BOTTOM w0.076: UH4.AT4 30.37,36.71 30.25,36.58 30.25,35.84 30.45,35.64 30.45,33.36
  BOTTOM w0.127: 30.45,33.36 30.45,31.27 29.87,30.69 29.87,28.41 34.1,24.19 35.28,24.19 36.8,22.67 36.8,21.79 38.03,20.57 43.14,20.57 43.92,21.35 v1(50.83,21.35) 51.53,21.35 54.43,24.25 55.62,24.25 58.52,27.15 73.95,27.15 v6(75.13,25.96)
XDP_PREQ#: length 213.6
  IN1 w0.064: v4(74.43,26.06) 74.97,26.06 75.69,26.78 77.24,26.78 79.83,24.19 87.92,24.19 88.88,23.23 95.41,23.23 96.28,22.35 103.82,22.35 104.85,23.38 109.39,23.38 110.04,24.03 112.57,24.03 113.06,23.54 113.06,22.97 115.02,21.02 122.86,21.02 123.15,20.74 124.64,20.74 125.27,20.11 129.45,20.11 130.09,20.75 130.09,26.77 131.07,27.76 135.86,27.76 139.94,31.84 141.65,31.84 142.05,31.43 142.74,31.43 144.16,32.85 144.3,32.85 147.06,35.61 147.06,41.44 142.97,45.52 141.59,45.52 139.35,47.77 136.49,47.77 131.79,52.47 131.79,55.22 130.64,56.37 130.64,60.71 130.15,61.21 130.15,70.11 130.3,70.26 132.71,70.26 134.74,72.29 135.91,72.29 137.23,73.62 v4(137.79,73.62)
  GND2 w0.102: v4(137.79,73.62) 137.79,73.49 v5(137.59,73.28) ; v5(74.1,26.06) v4(74.43,26.06)
  GND3 w0.102: v6(138.02,73.28) v5(137.59,73.28) ; v5(74.1,26.06) 73.94,26.06 v6(73.76,26.24)
  IN3 w0.064: v3(130.45,72.1) 130.56,72.1 130.95,72.48 131.33,72.48 132,73.16 132.52,73.16 133.51,72.17 135.07,72.17 135.49,72.59 136.46,72.59 137.23,73.36 137.94,73.36 v6(138.02,73.28)
  BOTTOM w0.076: 30.02,33.36 30.02,34.5 29.59,34.93 29.59,35.64 29.71,35.77 29.71,36.33 29.98,36.6 UH4.AT3
  BOTTOM w0.127: v6(73.76,26.24) 73.26,26.74 58.69,26.74 55.79,23.84 54.6,23.84 51.47,20.72 v1(48.55,20.72) 43.94,20.72 43.33,20.11 37.84,20.11 36.3,21.64 36.3,22.55 35.1,23.75 33.92,23.75 29.46,28.21 29.46,30.86 30.02,31.42 30.02,33.36 ; RH44.2 139.1,72.41 138.22,73.28 v6(138.02,73.28)
XDP_SPI_SI: length 230.2
  TOP w0.127: RC9.2 145.59,78.43 v1(142.75,78.43) v2(142.14,78.43)
  IN1 w0.064: v2(142.14,78.43) 140.89,78.43 138.67,76.21 138.67,74.76 138.69,74.74 138.69,73.08 138.37,72.75 137.88,72.75 137.09,71.96 134.87,71.96 133.52,70.61 133.52,70.49 133.14,70.11 133.14,69.86 132.79,69.5 131.8,69.5 131.47,69.17 131.47,59.58 131.89,59.16 131.89,55.59 132.13,55.35 132.13,52.6 136.62,48.1 139.48,48.1 141.22,46.36 142.6,46.36 147.39,41.57 147.39,35.47 146.37,34.46 146.37,32.91 144.56,31.1 139.67,31.1 135.55,26.98 130.77,26.98 130.42,26.63 130.42,20.61 129.58,19.78 125.13,19.78 124.5,20.41 123.01,20.41 122.73,20.69 114.88,20.69 112.73,22.84 112.73,23.4 112.43,23.7 110.18,23.7 109.53,23.05 104.99,23.05 103.96,22.02 96.15,22.02 95.27,22.9 88.67,22.9 87.71,23.86 79.69,23.86 78.1,25.45 75.84,25.45 75.49,25.8 73.69,25.8 73.31,26.18 72.93,26.18 72.68,26.43 68.96,26.43 66.09,29.3 65.3,29.3 65.03,29.58 63.16,29.58 61.72,31.01 58.56,31.01 58.35,30.8 55.88,30.8 55.12,31.57 54.88,31.57 53.32,33.13 47.99,33.13 47.45,32.59 46.51,32.59 46.05,32.13 43.08,32.13 41.25,33.96 41.25,35.12 40.26,36.11 33.33,36.11 v4(33.12,36.33)
  GND2 w0.102: v4(33.12,36.33) 32.76,36.33 v5(32.66,36.43)
  GND3 w0.102: v5(32.66,36.43) 32.56,36.33 v8(32.13,36.33)
  IN3 w0.064: v3(16.56,50.98) 16.56,48.6 16.33,48.37 16.33,47.58 16.57,47.34 20.43,47.34 21.12,48.03 21.12,48.34 21.36,48.58 22.24,48.58 22.71,48.12 24.64,48.12 25.27,47.49 28.06,47.49 28.72,46.83 28.72,46.28 28.84,46.16 29.5,46.16 29.99,45.67 29.99,42.73 30.84,41.88 30.84,39.79 31.3,39.33 31.3,38.29 32.13,37.46 v8(32.13,36.33)
  BOTTOM w0.127: RC44.2 16.58,51.01 v3(16.56,50.98)
XTAL24_IN: length 6
  BOTTOM w0.127: UH4.A6 48.12,37.3 48.12,32.65 RH214.2
XTAL24_OUT: length 5.7
  BOTTOM w0.122: 47.67,37.4 UH4.A5
  BOTTOM w0.127: 47.67,37.4 47.85,37.22 47.85,33.2 RH215.2
XTAL_25_IN: length 3.9
  BOTTOM w0.076: 33.88,75.82 33.93,75.88 33.93,76.38 34.16,76.62 UT2.D22
  BOTTOM w0.127: 33.88,75.82 33.51,75.46 31.25,75.46 RT72.2
XTAL_25_IN_R: length 1.6
  BOTTOM w0.127: YT1.1 29.55,76.18 CT38.1 RT72.1
XTAL_25_OUT: length 3.9
  BOTTOM w0.127: RT24.2 31.25,75.14 33.75,75.14 34.17,75.56 UT2.D23
XTAL_25_OUT_R: length 3.8
  BOTTOM w0.127: YT1.3 27.96,74.11 28.86,75.01 29.88,75.01 30.48,74.42 CT37.1 RT24.1
N12389: length 3.1
  TOP w0.127: PR1205.1 v1(128.64,41.93)
  TOP w0.508: PR1205.1 129.58,43.77 v9(129.77,43.58)
N12481: length 3
  TOP w0.127: v1(132.84,42.28) PC1225.1
  TOP w0.635: PR1205.2 131.31,42.37 PC1225.1
N12559: length 4.3
  TOP w0.127: v9(127.61,37.99) 128.25,37.99 v1(128.38,38.12)
  TOP w0.381: PC3259.1 127.73,38.74 127.29,38.74 PR1204.2 127.61,38.17 v9(127.61,37.99)
  BOTTOM w0.203: PC1220.1 127.15,38.45 v9(127.61,37.99) 127.85,37.75 PU1202.14
N12635:
  vias: v1(128.75,39.71)
N25790: length 1.3
  TOP w0.508: PR1303.1 143.67,63.07 v9(143.99,62.76)
  vias: v1(144.31,60.22)
N25814: length 2.7
  TOP w0.127: v1(142.4,68.33) PC1317.1
  TOP w0.508: PR1303.2 142.4,66.12 PC1317.1
N25900: length 1.5
  TOP w0.127: v1(146.72,61.93) 147.04,62.25 v9(147.48,62.25)
  TOP w0.508: v9(147.48,62.25) 147.47,62.26 PR1302.2
N25968: length 1.2
  BOTTOM w0.127: v1(147.67,61.61) 147.16,61.61 146.86,61.92 PC1316.1
N29706: length 3.3
  TOP w0.127: PR1305.1 107.86,40.09 v1(106.91,41.04)
  TOP w0.635: PR1305.1 109.26,39.45 v9(109.26,39.12)
N54708: length 1
  TOP w0.508: PR1301.1 v9(143.18,58.07)
  vias: v1(145.64,57.3)
N54789: length 2.6
  TOP w0.127: v1(114.14,40.83) 114.22,40.91 PR1201.1
  TOP w0.508: PR1201.1 v9(115.09,42.48)
N54830: length 2.7
  TOP w0.127: v1(121.89,41.23) 121.96,41.31 PR1203.1
  TOP w0.508: PR1203.1 v9(123.01,42.87)
N104691: length 7.3
  TOP w0.127: v1(134.08,35.01) 134.59,34.5 135.61,34.5 136.06,34.96 PR1134.2
  TOP w0.203: PR1134.2 PC1105.2 PR1136.2 136.72,37.51 137.26,37.51 137.96,38.22 PU1100.46
N18408062: length 1.6
  GND2 w0.102: v5(44.93,14.59) 44.88,14.64 44.88,14.86 v7(44.75,14.99)
  GND3 w0.102: v5(44.93,14.59) 45.01,14.59 45.26,14.84 v6(45.46,14.84)
  BOTTOM w0.127: v6(45.46,14.84) 45.46,14.49 T79.1
N19473413: length 3.5
  TOP w0.203: PC2302.2 85.19,108.92 85.11,109 PR2304.1 ; PC2302.2 84.6,108.49 84.32,108.77 PU2300.4 ; PC2302.2 PR2302.2
N19473637:
  vias: v1(83.35,105.75)
N29436789: length 2.9
  TOP w0.127: v1(118.34,40.98) PC1209.1
  TOP w0.508: PC1209.1 116.88,41.03 PR1201.2
N30818241: length 2.2
  TOP w0.127: RD195.1 104.94,100.29 UD5.F9
N30818347: length 2.1
  TOP w0.127: RD194.1 93.89,100.29 UD6.F9
N30820408: length 2.1
  BOTTOM w0.127: RD196.1 114.82,100.29 UD7.F9
N30820514: length 2.4
  BOTTOM w0.127: UD8.F9 102.96,100.29 103.81,101.14 RD197.1
N30927710: length 3.3
  BOTTOM w0.127: RD229.1 134.48,80.21 133.89,80.79 133.89,81.62 v1(134.4,82.12)
  BOTTOM w0.254: CD324.2 RD229.1
N39070459: length 2.7
  TOP w0.127: RE219.1 RE222.2 32.27,17.76 QE13.3 31.18,18.07 v1(31.01,18.24)
N39070470: length 3.5
  TOP w0.127: RE219.2 33.54,16.96 32.8,16.23 QE16.2 31.47,16.23 v1(30.88,15.64)
N44325406: length 4.1
  TOP w0.127: UE3.B1 39.91,16.59 39.77,16.45 v1(39.07,16.45) 38.57,16.95 RE154.1 38.05,16.95 37.56,16.47 37.51,16.47 RE251.1
N44325565: length 3.9
  TOP w0.127: UE3.N4 43.15,5.87 RE115.2 v1(41.44,5.11)
N44325691: length 2
  BOTTOM w0.127: v1(26.65,24.71) RE172.2 CE65.1
N46619932: length 5
  TOP w0.203: PR1102.2 136.32,41.03 PC1102.1 136.31,40.85 136.83,40.33 136.83,39.31 v1(137.32,38.82) 137.52,39.02 PU1100.44
N46621117: length 2.4
  TOP w0.203: PR1131.1 141.77,34.78 141.33,35.22 v1(141.33,35.39) PU1100.6
N46621120: length 9.2
  TOP w0.127: PR1131.2 141.84,33.47 v1(143.1,32.21)
  TOP w0.203: PR1135.1 140.19,31.39 141.2,32.39 141.2,32.9 PR1131.2 141.77,33.56 142.31,34.1 142.31,34.75 141.73,35.33 PU1100.7
N46621397: length 3.1
  TOP w0.127: v1(140.18,30.79) 138.79,30.79 PR1135.2
  TOP w0.203: PC1106.1 PR1135.2
N46621424: length 2.5
  TOP w0.203: PR1137.1 142.85,34.77 142.13,35.49 PU1100.8
N46621427: length 2.7
  TOP w0.203: PR1140.1 143.74,34.45 v1(142.82,35.36) 142.53,35.66 PU1100.9
N46621964: length 2.1
  TOP w0.127: v1(146.66,32.4) 146.39,32.67 PC1107.1
  TOP w0.203: PR1144.2 146.38,33.47 PC1107.1
N46621983: length 3.2
  TOP w0.203: PR1142.1 144.62,34.59 144.34,34.88 143.82,34.88 142.93,35.78 PU1100.10
N46621986: length 4.9
  TOP w0.203: PR1142.2 145.51,34.36 PR1144.1 145.51,34.56 144.81,35.26 v1(144.12,35.26) 143.93,35.26 143.33,35.86 PU1100.11
N46622191: length 3.8
  TOP w0.203: PU1100.12 143.73,35.91 143.92,35.72 145.06,35.72 v1(145.45,35.32) 145.82,35.32 PR1145.1
N46622194: length 2.7
  TOP w0.203: PU1100.13 144.92,37.42 v1(145.59,36.74) 146.39,35.95 PR1147.1
N46622340: length 6
  TOP w0.127: v1(134.21,43.52) 135.6,43.52 136.04,43.96 PR1108.2
  TOP w0.203: PR1108.2 PR1109.2 136.2,43.06 PC1103.2 137.07,42.75 138.01,41.82 PU1100.37
N46622659: length 8.1
  TOP w0.127: v1(135.18,47.45) 135.61,47.88 PR1107.2
  TOP w0.203: PR1107.2 136.69,47.31 136.69,45.68 137.08,45.28 PR1110.2 137.52,45.28 139.73,43.08 PU1100.35
N46622666: length 6.2
  TOP w0.203: PU1100.33 140.53,42.98 140.43,43.07 140.43,43.14 140.41,43.16 140.41,43.19 139.16,44.43 v1(139.16,44.6) 138.53,45.23 PR1106.2 138.22,46.03 138.22,46.03 137.97,46.29 137.97,46.29 137.83,46.42 137.83,47.26 PR1113.2
N46622669: length 6
  TOP w0.203: PU1100.32 140.93,43.27 v1(140.31,43.89) 140.12,44.09 140.12,44.34 139.35,45.1 PR1105.2 139.86,46.23 139.86,47.07 PR1114.2
N46623252: length 3.8
  TOP w0.127: PR1130.1 143.07,46.36 PR1129.2 143.81,47.05 144.34,47.58 144.34,49.18 PR1112.2
N46623254: length 3.7
  TOP w0.127: PR1128.1 142.29,46.56 PR1127.2 142.83,47.06 143.25,47.48 143.25,49.18 PR1116.2
N46623256: length 4.4
  TOP w0.127: PR1125.1 143.86,46.35 144.7,47.19 PR1124.2 144.99,47.19 145.89,48.09 v1(145.89,48.09) 145.89,48.6 145.39,49.1 PR1111.2
N46623799: length 5.2
  TOP w0.203: PR1122.2 141.67,47.06 141.02,46.41 141.02,45.64 PR1104.2 141.5,44.28 v1(141.56,44.21) 141.56,43.86 141.73,43.7 PU1100.30
N46624101: length 2.9
  TOP w0.127: PU1100.27 142.93,43.49 143.86,44.43 PR1125.2
N46624104: length 2.6
  TOP w0.127: PR1128.2 142.29,43.66 142.13,43.49 PU1100.29
N46624128: length 2.7
  TOP w0.127: PR1130.2 143.07,44.23 v1(142.95,44.11) 142.53,43.68 PU1100.28
N46624575: length 6.5
  TOP w0.203: PR1115.2 140.94,47.87 141.09,47.72 141.09,46.98 140.48,46.36 PR1120.2 v1(140.37,45.17) 140.37,44.66 141.33,43.7 PU1100.31
N46625447: length 5.9
  TOP w0.203: PR1132.2 147.68,44.72 PR1133.2 147.28,44.71 146.76,44.19 v1(146.53,44.19) 146.5,44.19 145.45,43.14 143.93,43.14 143.73,42.93 PU1100.25
N46626546: length 5.1
  TOP w0.203: PU1100.36 139.33,43.01 138.58,43.76 138.16,43.76 v1(138.02,43.9) 137.31,44.61 136.62,44.61 PR1141.2 136.12,45.12 PR1138.2
N46626820: length 3.7
  TOP w0.203: PU1100.24 145.34,41.82 v1(146.43,42.91) 147.35,43.83 PR1139.2
N46626937: length 5.3
  TOP w0.203: PR1143.2 149.18,40.86 148.91,41.13 147.89,41.13 147.47,40.71 PC1108.2 145.69,40.6 v1(145.67,40.62) PU1100.21
N46627867: length 5.6
  TOP w0.203: PR1146.2 149.18,41.94 148.91,42.21 147.89,42.21 147.47,41.79 PC1109.2 146.59,41.67 v1(146.53,41.61) 145.93,41.02 PU1100.22
N46628199: length 7.1
  TOP w0.203: PR1148.2 149.58,43.15 149.58,43.58 v1(149.44,43.72) 149.15,43.72 148.72,43.29 147.89,43.29 147.47,42.87 PC1110.2 146.78,42.75 145.44,41.42 PU1100.23
N46634435: length 7.4
  TOP w0.127: PR1152.1 135.92,37.74 135.48,38.18 134.15,38.18 v1(134.08,38.25)
  TOP w0.203: PU1100.45 137.88,38.62 137.58,38.31 137.19,38.31 136.5,39 136.5,39.52 PC1111.1 136.06,39.46 PR1149.2 PR1152.1
N46635062: length 2.4
  TOP w0.203: PU1100.14 145.05,37.82 146.03,36.84 PR1151.1
N46635065: length 3.1
  TOP w0.203: PR1154.1 147.46,37.75 PR1151.2 145.69,37.75 145.22,38.22 PU1100.15
N46635193: length 2.5
  TOP w0.127: v1(149.64,37.74) PR1154.2
  TOP w0.203: PC1112.1 148.36,37.74 PR1154.2
N46635895: length 3.1
  TOP w0.203: PR1150.1 147.2,38.43 145.84,38.43 v1(145.71,38.55) 145.65,38.62 PU1100.16
N46635936: length 3.2
  TOP w0.203: PU1100.17 145.9,39.02 v1(146.47,39.58) 146.53,39.64 PR1153.1
N46642076: length 4
  TOP w0.127: v9(113.26,36.89) 113.26,36.53 v1(113.51,36.28)
  TOP w0.381: PC3257.1 113.14,37.58 112.9,37.34 PR1200.2 113.13,36.89 v9(113.26,36.89)
  BOTTOM w0.203: PU1200.14 113.38,36.76 v9(113.26,36.89) 112.81,37.33 PC1207.1
N46643804: length 3.6
  BOTTOM w0.127: PC1208.1 112.63,38.13 112.18,37.67 112.18,35.45 112.27,35.36 v1(112.27,34.82)
N46645025: length 3.1
  TOP w0.127: v1(126.21,41.36) PC1217.1
  TOP w0.508: PC1217.1 124.63,41.4 PR1203.2
N46645111: length 4
  TOP w0.127: v9(120.44,36.63) v1(120.96,36.63)
  TOP w0.381: v9(120.44,36.63) 120.32,36.63 PR1202.2 120.09,37.09 120.63,37.63 PC3258.1
  BOTTOM w0.203: PU1201.14 120.72,36.35 v9(120.44,36.63) 120,37.08 PC1210.1
N46645235:
  vias: v1(121.19,38.06)
N46647976: length 2.7
  TOP w0.127: v1(142.11,61.08) PC1308.1
  TOP w0.508: PC1308.1 143.38,59.94 PR1301.2
N46648066: length 1.3
  TOP w0.127: v9(146.77,52.41) v1(146.77,51.72)
  TOP w0.508: PR1300.2 v9(146.77,52.41)
N46648174: length 1.3
  BOTTOM w0.127: PC1307.1 146.97,51.14 v1(147.29,51.45)
N46648306: length 3.6
  TOP w0.127: v1(111.67,41.48) PC1326.1
  TOP w0.635: PR1305.2 109.89,41.48 PC1326.1
N46648510:
  vias: v1(106.76,39.34)
N46648536: length 4.1
  TOP w0.127: v9(106.37,37.85) 106.73,37.85 106.91,37.68 v1(106.91,37.48)
  TOP w0.381: v9(106.37,37.85) 106.21,37.85 105.83,38.23 PC3260.1 105.84,38.45 PR1304.2
  BOTTOM w0.203: PC1324.1 105.91,38.31 v9(106.37,37.85) 106.51,37.71 PU1302.14
N55155827:
  vias: v1(64.42,94.51)
N55155843: length 2.2
  TOP w0.127: v1(64.48,97.37) RV785.2 65.35,98.44 QV9.1
N120109057: length 3.4
  BOTTOM w0.122: CH76.1 RH99.2
  BOTTOM w0.127: CH76.1 20.81,40.35 20.7,40.4 YH1.2 ; RH99.2 22.6,39.54 22.83,39.77 RH213.1
N120109063: length 3.6
  BOTTOM w0.122: CH75.1 RH99.1
  BOTTOM w0.127: RH99.1 22.84,39.2 RH212.1 ; YH1.1 20.82,37.81 CH75.1
N120109283: length 5.9
  BOTTOM w0.127: RH214.1 47.79,30.96 RH105.1 48.64,30.97 CH77.1 48.68,30.73 48.42,30.47 47.79,30.47 47.63,30.32 47.63,28.93 YH2.1
N120109300: length 3.2
  BOTTOM w0.127: RH215.1 46.96,31.04 RH105.2 46.05,30.97 CH78.1 46.01,30.06 YH2.3
N120139517: length 6.7
  BOTTOM w0.127: v1(43.95,31.49) RH100.2
  BOTTOM w0.254: UH4.E1 45.67,35.44 46.83,34.27 46.83,33.81 46.15,33.13 44.93,33.13 44.4,32.59 RH100.2
N120176782: length 5.4
  BOTTOM w0.076: 44.18,58.06 43.89,57.77 43.33,57.77 42.77,57.21 42.77,56.98 42.67,56.88 42.67,56.5 UH4.L43
  BOTTOM w0.127: 44.46,58.89 44.46,58.33 44.18,58.06
  BOTTOM w0.145: T59.1 44.46,60.13 44.46,58.89
N120176822: length 1.8
  BOTTOM w0.076: T60.1 25.18,52.91 26.07,52.91 26.24,53.08 UH4.BD36
N120177456: length 2.6
  BOTTOM w0.076: T61.1 23.76,43.48 UH4.BD17
N120361881: length 1.4
  BOTTOM w0.127: CZ11.1 20.61,33.3 UZ3.6
N121070696: length 7.5
  BOTTOM w0.076: 38.12,34.23 37.45,34.91 35.73,34.91 34.77,35.87 34.77,36.28 34.53,36.52 UH4.AG3
  BOTTOM w0.127: RH163.1 v1(39.47,33.04) 38.27,34.23 38.12,34.23
N121388945: length 6.4
  BOTTOM w0.076: UH4.AJ4 33.93,36.86 33.68,36.61 33.68,36.28 33.8,36.15 33.8,34.99 34.53,34.27 35.1,34.27 35.53,33.84 35.53,33.36
  BOTTOM w0.127: RH96.1 36.37,32.12 v1(35.53,32.96) 35.53,33.36
N122282431: length 1.9
  TOP w0.127: RR10.1 22.83,61.88 22.29,62.42 UR1.28
N122517438: length 5.3
  TOP w0.127: RH155.2 2.63,11.17 v1(2.63,11.39) SW1.1
N122687725: length 8.6
  TOP w0.127: UZ8.4 34.06,26.85 RZ29.1 34.06,28.05 34.59,28.58 34.59,30.26 34.33,30.51 UZ10.1 34.01,30.82 34.31,31.12 v1(36.81,31.12) 36.99,30.94 RZ23.1
N122739033: length 2.3
  TOP w0.127: v1(32.93,31.13) RZ26.2 33.07,29.86 UZ10.2
N122739334: length 2.3
  TOP w0.127: v1(41.3,28.1) RZ30.1 41.25,29.21 UZ11.4
N122754331: length 3.3
  TOP w0.254: UZ18.7 118.08,96.17 118.53,95.73 RZ44.1 118.58,95.45 UZ18.8
N122754354: length 2.2
  TOP w0.254: UZ18.6 117.58,96.53 117.34,96.3 116.6,96.3 CZ31.1
N122755391:
  vias: v1(83.35,26.12)
N122912247:
  vias: v1(111.86,28.06)
N124817422: length 11.6
  BOTTOM w0.076: 39.8,33.36 38.37,34.79 37.91,34.79 37.66,35.03 37.66,39.15 37.49,39.33 36.42,39.33 UH4.AD10
  BOTTOM w0.127: v1(41.44,31.58) 40.76,32.25 RH164.1 40.23,32.92 39.8,33.36
N124817429: length 6.5
  BOTTOM w0.076: 38.13,33.36 38.13,33.74 37.19,34.68 35.73,34.68 34.53,35.88 UH4.AG2
  BOTTOM w0.127: 38.13,33.36 v1(38.13,33.29) 38.13,33.19 38.83,32.49 RH165.1
N125742089: length 3.8
  TOP w0.127: v1(19.02,52.85) 17.89,51.72 RH117.1
  TOP w0.381: UH5.5 16.99,51.19 RH118.1 RH117.1
N125836022: length 2.4
  TOP w0.254: UZ18.3 117.58,100.53 RZ43.2 117.59,101.43 RZ45.2
N125857121:
  vias: v1(64.87,87.97)
N125861425:
  vias: v1(147.04,103.21)
N126729390: length 4.7
  TOP w0.127: v1(40.48,23.51) 40.94,23.97 RZ42.2 40.94,24.92 41.44,25.42 41.44,25.67 41.75,25.99 DZ1.1 42.9,25.99 43.03,25.86 UZ17.2
N127291407: length 3
  BOTTOM w0.127: CZ14.1 58.23,100.89 57.75,100.42 v1(57.62,100.42) 57.42,100.42 56.79,101.05 UZ4.6
N127291517: length 2.2
  BOTTOM w0.127: RZ11.1 54.23,101.8 53.23,100.81 v1(53.23,100.42)
N132190101: length 4.9
  TOP w0.127: v1(78.03,110.73) 78.45,110.31 PC2304.1
  TOP w0.203: PU2300.6 80.39,109.27 79.36,110.31 PC2304.1 78.97,110.28 78.97,109.71 78.99,109.68 PR2307.2 PR2306.2
N132200507: length 5.3
  TOP w0.127: v1(100.62,22.5) 100.62,22.82 101.13,23.32 101.84,23.32 102.23,23.72 PR1002.1
  TOP w0.254: PR1002.1 102.66,23.77 103.43,24.53 PR1013.2 103.61,24.55 PU1000.9
N132200681: length 1.7
  TOP w0.127: PR1009.2 107.12,28.33 PR1012.1 PR1011.1
N132200732: length 3.4
  TOP w0.127: PR1006.1 109.61,27.58 v1(109.4,27.37) 108.97,27.37 108.87,27.46 PR1004.2 107.12,27.46 PR1007.1
N132640197: length 6.8
  TOP w0.127: v1(161.57,14.22) 161.59,14.19 PR516.1
  TOP w0.203: PU501.3 163.89,10.77 163.57,11.09 162.44,11.09 161.59,11.94 PC535.1 PR516.1
N132640209: length 4
  GND2 w0.254: v5(166.79,9.99) 166.86,9.91 v7(166.86,9.51)
  GND3 w0.254: v6(166.85,10.56) 166.71,10.42 166.71,10.06 v5(166.79,9.99)
  BOTTOM w0.127: v6(166.85,10.56) 166.98,10.43 v1(166.98,10.14)
  BOTTOM w0.254: PR553.1 165.38,11.98 PD501.1 166.6,11.07 166.85,10.81 v6(166.85,10.56)
N132640228: length 1.4
  BOTTOM w0.127: PC530.2 164.44,12.85 v1(164.69,13.1)
N132640229: length 2.4
  TOP w0.203: PR524.1 167.34,5.5 166.45,6.4 PU501.27
N132640234: length 13.1
  TOP w0.508: PR508.1 153.91,2.18 149.74,2.18 v1(149.34,2.58) 148.87,3.05 148.87,5.64 v9(148.59,5.92)
  IN3 w0.508: v3(145.78,6.04) 148.47,6.04 v9(148.59,5.92)
  BOTTOM w0.508: v3(145.78,6.04) 145.31,5.57 PD505.1
N132640241: length 2.3
  TOP w0.203: PU501.26 165.78,6 v1(166.41,5.37) 166.99,4.79 PR525.2
N132640248: length 135.9
  TOP w0.203: PC543.1 170.34,7.38 168.4,7.38 PR538.2
  TOP w0.254: v2(95.12,2.8) v1(94.22,1.9) 93.65,1.33 54.99,1.33 54.77,1.54 PR537.1 PR536.1 ; v2(169.99,3.42) 170.44,3.42 171.42,4.4 171.42,6.43 171.27,6.58 171.03,6.58 170.74,6.88 PC543.1
  IN1 w0.254: v2(169.99,3.42) 169.06,4.35 167.76,4.35 165.27,6.84 165.27,9.55 162.97,11.84 162.3,11.84 160.51,13.63 134.81,13.63 134.06,14.38 130.83,14.38 122.19,5.74 114.02,5.74 113.4,6.36 111.49,6.36 111.49,6.36 111.06,6.36 106.95,4.66 104.04,4.66 103.51,4.13 96.45,4.13 v2(95.12,2.8)
N132640310: length 4.5
  TOP w0.127: v1(166.89,1.86) 166.87,1.87 PR542.2
  TOP w0.203: PR542.2 166.87,3.33 165.91,4.3 165.05,4.3 164.69,4.65 PU501.24
N132640368: length 1.2
  BOTTOM w0.508: PR505.1 PC525.1
N132640406: length 3.2
  TOP w0.127: v1(170.98,6.11) 170.66,6.43 169.58,6.43 169.12,6.89 PC542.1
  TOP w0.203: PR527.2 168.65,6.5 PC542.1
N132640440: length 12.6
  TOP w0.254: v9(147.35,3.08) 146.81,3.63 146.81,6.06 148.26,7.51 v1(149.39,7.51) PR502.1
  BOTTOM w0.254: PR500.3 147.05,2.77 v9(147.35,3.08)
N132640444: length 14.8
  TOP w0.254: PR503.1 v1(151.55,8.73) 148.85,8.73 145.97,5.85 145.97,3.75 v9(147.35,2.37)
  BOTTOM w0.254: v9(147.35,2.37) 147.76,2.77 PR500.2
N132640459: length 43.2
  TOP w0.127: v1(163.42,14.5) 163.42,14.12 v9(163.29,13.99)
  TOP w0.254: PR521.1 163.34,13.94 v9(163.29,13.99)
  IN3 w0.254: v9(163.29,13.99) 163.29,13.62 165.78,11.13 165.78,6.18 166.49,5.47 166.49,3.1 165.78,2.38 162.33,2.38 161.27,3.44 155.76,3.44 155.47,3.16 150.17,3.16 147.96,5.37 145.57,5.37 144.84,6.1 141.4,6.1 141.07,6.43 139.77,6.43 v3(139.26,5.92)
N132937298: length 3
  TOP w0.127: v1(11.71,22.56) PR602.2
  TOP w0.508: PR602.2 12.23,24.21 12.61,23.83 PC611.1
N132937413: length 2.5
  TOP w0.127: v1(125.89,26.63) 125.21,25.94 PC635.1
  TOP w0.508: PC635.1 125.17,25.39 PR615.2
N132938140: length 2.8
  BOTTOM w0.254: PR613.2 127.3,27.16 127.3,27.02 v1(126.81,26.53) 126.2,25.91 PU602.12
N132938170: length 7.8
  TOP w0.127: v9(125.69,21.56) v1(125.69,21.02)
  IN1 w0.254: v9(124.7,26.21) 124.7,26.21 124.7,25.72 125.7,24.72 125.7,21.59 125.69,21.58 v9(125.69,21.56)
  BOTTOM w0.254: 124.7,26.21 124.55,26.36 PC634.1 ; 124.7,26.21 v9(124.7,26.21) ; 124.7,26.21 PU602.9 ; PR616.2 125.31,21.18 v9(125.69,21.56)
N132938202: length 4.9
  IN3 w0.635: v3(124.05,24.91) 123.92,25.04 123.92,27.39 124.69,28.15 v3(126.02,28.15)
N132938321: length 1.4
  BOTTOM w0.508: PR601.2 15.66,24.34 15.03,24.96 PC600.1
N132938373: length 4.1
  BOTTOM w0.127: PR626.1 52.81,78.39 v1(52.49,78.06)
  BOTTOM w0.203: PU601.3 54.23,79.53 53.95,79.81 53.13,79.81 PR610.1 53.11,79.35 PR626.1
N132938377: length 1.6
  BOTTOM w0.203: PU601.12 58.52,79.53 58.75,79.3 59.03,79.3 PR607.2
N132938389: length 14.5
  IN3 w0.203: v3(52.2,79.83) 52.2,78.23 54.3,76.13 55.32,76.13 57.91,78.72 57.91,80.88 58.11,81.08 59.56,81.08 v3(59.71,81.24)
  BOTTOM w0.127: v3(52.2,79.83) 52.2,80.4 v1(51.83,80.77)
N132938405: length 3
  BOTTOM w0.127: v1(63.45,83.54) 62.59,82.67 PC612.1
  BOTTOM w0.508: PR608.2 61.34,82.67 PC612.1
N132940037: length 5.2
  BOTTOM w0.254: PU800.3 77.56,93.54 76.98,92.97 76.98,92.89 PC814.1 76.43,91.59 76.04,91.2 75.64,91.2 75.21,90.77 PR810.2 PR806.2
N132940047: length 4.6
  BOTTOM w0.127: PR800.1 83.91,97.31 v1(84.49,96.73)
  BOTTOM w0.508: PR800.1 82.28,97.31 81.77,96.79 80.36,96.79
N132940049: length 2.6
  BOTTOM w0.127: v1(85.7,97.75) 85.7,98.23 PC800.1
  BOTTOM w0.508: PC800.1 84.74,98.44 PR800.2
N132940086: length 2.6
  TOP w0.127: v1(77.99,99.55) 78.1,99.43 PC801.1
  TOP w0.508: PC801.1 78.42,98.52 78.77,98.16 PR801.2
N132940160: length 7.7
  TOP w0.203: PD800.2 78.39,97.17 PR812.1 79.43,96.84 PR813.2 PR814.2 79.93,95.28 80.13,95.08 81.06,95.08 v1(81.6,94.54) 82.27,93.87 v7(82.27,93.73)
  GND2 w0.203: v7(82.27,93.73) 82.39,93.73 v5(82.65,93.48)
  GND3 w0.203: v6(82.2,93.47) 82.64,93.47 v5(82.65,93.48)
N132946501: length 4.1
  TOP w0.127: v1(52.71,78.63) 52.71,80.35 52.97,80.61 PC623.1
  TOP w0.508: PC623.1 53.81,80.92 PR609.2
N132946510: length 3.2
  BOTTOM w0.127: PR600.2 v1(12.34,19.72)
  BOTTOM w0.203: PR600.2 12.34,21.82 12.26,21.9 12.26,22.21 12.03,22.45 PU600.12
N132946538: length 2.2
  BOTTOM w0.254: PU602.3 126.2,20.99 PR616.1 PR627.1
N132946554: length 1
  BOTTOM w0.508: PR614.2 124.43,28.34 PC624.1
N132946567:
  vias: v1(12.93,24.85)
N132946609:
  vias: v1(58.39,82.38)
N132948439: length 1.7
  BOTTOM w0.203: PC812.1 76.55,95.01 77.08,95.54 PU800.7
N132948454: length 1.3
  BOTTOM w0.203: PU800.14 82,94.54 PR809.1
N133127797: length 1.5
  TOP w0.127: PR621.2 67.41,100.62 v1(67.41,100.03)
N133127826: length 6.1
  TOP w0.127: v1(59.28,100.86) 60.49,100.86 60.68,100.67 PR629.1
  TOP w0.203: PU603.3 63.18,100.48 ; 63.18,100.48 63.18,99.86 PR622.1 ; 63.18,100.48 PR629.1
N133127858: length 2.6
  TOP w0.127: PR620.2 65.63,106.83 v1(65.25,107.21)
  TOP w0.508: PR620.2 67.54,106.83 PC636.1
N133127913: length 8.8
  TOP w0.254: PR622.2 63.73,99.93 v2(63.73,100.77)
  IN1 w0.254: v2(63.73,100.77) 65.48,100.77 66.14,101.43 66.14,105.11 65.44,105.81 v2(65.44,106.06)
N133127927: length 3.6
  TOP w0.127: v1(61.19,107.14) 62.02,106.3 PR619.2
  TOP w0.203: PU603.12 63.18,105.23 62.97,105.43 62.7,105.43 62.25,105.87 PR619.2
N133127941:
  vias: v1(66.01,104.35)
N133318440: length 11.3
  TOP w0.254: PR131.1 PR128.2 24.63,95.75 PC114.2 23.62,95.98 22.93,96.67 PQ112.1 22.26,97.5 v7(22.01,97.75)
  GND2 w0.254: v7(22.01,97.75) 21.59,98.18 v5(21.59,98.6)
  GND3 w0.254: v5(21.59,98.6) v8(22.13,98.6)
  IN3 w0.254: v3(22.35,101.85) 22.13,101.63 v8(22.13,98.6)
  BOTTOM w0.127: v1(21.25,102.34) 21.74,101.85 v3(22.35,101.85)
N133318479: length 3.2
  TOP w0.254: PQ112.2 21.17,95.07 20.95,95.28 20.95,96.49 20.67,96.77 PR129.1 PR127.2
N133318745: length 6
  TOP w0.127: PR136.2 18.7,93.07 PQ144.2 19.35,93.33 20.01,92.66 21.31,92.66 22.07,91.9 22.36,91.9 22.81,92.35 PQ217.5
N133320954: length 11.7
  TOP w0.203: PR144.1 24.44,97.36 v1(23.59,97.36) 23.08,97.36 21.34,99.11 20.87,99.11 v9(20.65,99.33) 19.92,100.06 PQ116.1 19.34,99.09 PC124.2 PR137.2
  BOTTOM w0.254: v9(20.65,99.33) 21.12,99.33 21.28,99.17 21.41,99.17 21.73,98.85 21.73,98.21 21.9,98.04 PQ113.4
