# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VGA_CORE_LX1: length 1.8
  TOP w0.127: PC1909.1 v1(86.59,39.45)
  TOP w0.508: PC1909.1 88.16,39.45 v9(88.3,39.59)
+VGA_CORE_LX2: length 2
  TOP w0.127: PC1919.1 69.87,39.53 v16(69.44,39.96)
  TOP w0.508: v9(71.22,39.69) 71.05,39.53 PC1919.1
+VGA_CORE_LX3: length 0.7
  TOP w0.508: PC2009.1 77.9,39.83 v9(78.52,39.83)
+VGA_CORE_LX4: length 1.4
  TOP w0.127: v9(95.6,39.58) v1(95.09,39.58)
  TOP w0.508: v9(95.6,39.58) 95.82,39.36 PC2019.1
+VPP_25: length 9
  IN2 w1.016: 61.69,68.6 62.77,67.52 69.88,67.52
  GND3 w0.254: v6(79.17,65.57) 79.17,65.71 v5(79.02,65.87)
  vias: v4(71.65,67.52) v4(78.52,65.74) v5(60.6,69.37) v5(60.98,69.75) v5(70.76,67.52) v5(71.27,67.52) v5(78.77,65.42) v6(60.17,69.68) v7(79.55,65.37) v9(80.17,65.17) v16(80.74,65.61)
+VR_CAP: length 17.8
  TOP w0.254: CE64.1 38.5,11.85 38.54,11.82 38.6,11.82 39.52,10.9 v9(40.03,10.9) 40.66,10.9 UE3.J1
  GND2 w0.254: v7(47.95,15.79) 48.07,15.91 48.23,15.91 v5(48.31,15.98)
  GND3 w0.508: v5(48.31,15.98) 48.92,15.37 v8(48.92,15.21)
  IN3 w0.508: v3(49.48,12.41) 49.48,14.64 v8(48.92,15.21)
  BOTTOM w0.508: v9(40.03,10.9) 40.36,11.23 45.09,11.23 45.45,11.59 48.85,11.59 v1(49.01,11.75) 49.48,12.22 v3(49.48,12.41)
+VREFEXTA: length 2.8
  TOP w0.508: RH484.1 83.98,62.45 84.38,62.06 RH485.1 v7(84.38,60.92)
  GND2 w0.305: v5(84.78,60.92) v7(84.38,60.92)
  GND3 w0.305: v6(84.93,60.55) 84.9,60.57 84.9,60.79 v5(84.78,60.92)
+VSYS: length 8.4
  TOP w0.127: v1(34.77,63.33) 34.77,63.47 33.63,64.61 RP99.1
  TOP w0.508: RP94.1 31.72,65.7 CP7.1 CP8.1 33.08,66.3 v7(33.38,66) 33.58,65.8 33.58,64.76 RP99.1
  GND2 w0.508: v5(33.32,66.4) 33.32,66.06 v7(33.38,66)
  IN2 w0.508: v5(33.04,65.48) 33.04,66.12 v5(33.32,66.4)
  GND3 w0.508: v5(33.04,65.48) 33,65.53 v6(32.68,65.53)
AC1_OVP: length 7.4
  TOP w0.127: v1(33.5,92.47) 33.84,92.82 PR168.2
  TOP w0.254: PR168.2 v7(34.73,93.44)
  GND2 w0.203: v7(34.73,93.44) 34.73,93.66 v5(35.03,93.96)
  GND3 w0.203: v6(35.51,94.25) 35.33,94.25 v5(35.03,93.96)
  BOTTOM w0.203: PR242.1 38.41,93.62 37.25,93.62 36.76,94.1 PR241.1 v6(35.51,94.25)
AC2_OVP: length 25.4
  TOP w0.203: v2(31.47,104.22) 31.09,104.6 30.06,104.6 29.68,104.98 v1(29.21,104.98) 29.21,104.63 29.22,104.62 29.22,104.6 29.24,104.58 PR174.2 29.21,104.06 29.21,103.29 PC137.1
  TOP w0.254: PR239.1 v2(45.16,99.78) 44.6,99.78 PR237.1 PR238.1
  IN1 w0.064: v2(45.16,99.78) 45.74,100.36 45.74,101.3 45.68,101.36 41.74,101.36 39.36,103.75 39.04,103.75 36.72,106.07 33.49,106.07 31.64,104.22 v2(31.47,104.22)
AC_DIS: length 21.6
  TOP w0.089: v7(44.34,16.08) 44.46,16.08 UE3.C6
  TOP w0.127: v7(39.47,6.62) 38.48,5.63 PR541.1 38.46,5.19 37.67,5.19 37.38,5.48 PQ501.2
  GND2 w0.102: v5(39.15,7.27) 39.47,6.95 v7(39.47,6.62) ; v7(44.34,16.08) 44.34,16.07 v5(44.62,15.79)
  GND3 w0.102: v8(44.15,15.77) 44.6,15.77 v5(44.62,15.79) ; v6(39.34,7.65) 39.34,7.46 v5(39.15,7.27)
  IN3 w0.064: v8(44.15,15.77) 43.72,15.77 43.26,16.23 38.56,16.23 38.36,16.03 v3(38.36,15.73)
  BOTTOM w0.127: v6(39.34,7.65) 39.34,8.48 37.63,10.19 v1(37.63,15.26) 38.1,15.73 v3(38.36,15.73)
AC_DIS#: length 18.1
  TOP w0.203: PR193.2 PR153.1 32.95,102.14 PR156.2 32.86,102.25 v7(32.42,102.7)
  TOP w0.254: PR192.2 40.67,105.96 40.08,105.37 PR162.2 PC127.1 v7(40.09,104.31)
  GND2 w0.203: v5(31.95,103.01) 32.1,103.01 v7(32.42,102.7)
  GND2 w0.254: v5(39.6,103.81) 39.6,103.82 v7(40.09,104.31)
  IN2 w0.203: v5(31.95,103.01) 32.9,103.01 34.36,104.48 35.92,104.48 36.59,103.81 v5(39.6,103.81)
  GND3 w0.203: v6(31.56,103.05) 31.59,103.01 v5(31.95,103.01)
  BOTTOM w0.203: v6(31.56,103.05) 31.2,103.41 PQ146.3 30.03,103.41 29.69,103.07 PR163.2 28.67,103.07 PR158.1
AC_DISC#: length 261.4
  TOP w0.127: v2(87.09,12.3) 87.09,9.86 v1(86.78,9.54) 86.61,9.38 v2(86.61,5.54) ; v7(51.3,13.39) 51.23,13.39 50.43,14.19 UE3.E13
  IN1 w0.064: v2(26.16,73.41) 26.16,71.67 25.84,71.35 25.84,67.33 24.46,65.95 24.46,62.86 21.54,59.94 17.83,59.94 v4(17.75,60.01) 17.74,60 15.9,60 14.39,58.5 9.59,58.5 4.26,53.17 4.26,49.11 5.19,48.19 5.19,44.07 4.81,43.69 4.81,35.82 5.64,34.99 5.64,33.84 4.97,33.18 4.97,27.29 3.69,26 3.69,19.7 3.43,19.44 3.43,12.27 7.34,8.36 11.95,8.36 13.63,6.69 20.94,6.69 22.23,5.4 36.32,5.4 36.71,5.78 37.83,5.78 38.21,6.17 39.63,6.17 40.38,6.92 42.93,6.92 45.85,9.84 45.85,10.41 45.85,10.53 46.68,11.35 46.85,11.35 47.94,12.44 48.55,12.44 49.04,12.93 50.52,12.93 50.97,13.39 v7(51.3,13.39) 51.68,13.39 52.26,12.81 52.26,12 54.56,9.7 55.71,9.7 55.86,9.55 59.07,9.55 59.53,9.09 64.35,9.09 65.27,8.18 67.85,8.18 69.6,6.43 70.65,6.43 70.89,6.67 76.23,6.67 76.77,6.13 78,6.13 78.3,5.83 79.95,5.83 80.2,5.58 83.99,5.58 84.06,5.5 85.11,5.5 85.58,5.04 86.01,5.04 86.51,5.54 v2(86.61,5.54) ; v2(87.09,12.3) 90.13,12.3 90.85,11.58 96.81,11.58 97.37,12.15 98.07,12.15 98.67,12.74 102.51,12.74 102.93,13.17 103.5,13.17 103.82,13.49 104.54,13.49 104.86,13.81 108.99,13.81 109.55,13.26 110.36,13.26 111.02,13.92 111.2,13.92 111.68,13.43 v4(111.68,12.32)
  IN1 w0.203: v2(33.63,101.22) 33.63,100.79 32.94,100.11 32.94,96.7 v7(33.17,96.48)
  GND2 w0.102: v4(17.75,60.01) v5(18.13,60.01) ; v7(33.17,96.48) v5(32.84,96.48) ; v4(111.68,12.32) 111.99,12.62 v5(112.01,12.62)
  IN2 w0.074: v5(32.84,96.48) 32.84,96.01 31.53,94.69 27.34,94.69 27.09,94.44 27.09,94.44 26.79,94.15 26.79,93.34 26.06,92.62 26.06,92.08 23.8,89.82 23.8,86.83 24.66,85.97 24.66,80.91 22.77,79.02 22.77,70.94 21.59,69.76 21.59,67.28 21.12,66.81 21.12,63.54 18.13,60.55 v5(18.13,60.01)
  GND3 w0.102: v6(112.57,12.62) v5(112.01,12.62)
  BOTTOM w0.102: JIO1.H3 112.29,12.9 v6(112.57,12.62)
AC_DISC_OUT#: length 225.6
  TOP w0.127: v1(169.14,5.01) 168.41,5.01 v9(168.25,4.84) 168.2,4.79 PR525.1
  IN1 w0.064: v4(131.16,13.9) 131.16,13.44 133.75,10.85 133.75,8.67 135.1,7.32 144.24,7.32 144.75,7.83 v4(144.93,7.83)
  GND2 w0.102: v4(131.16,13.9) 131.16,14.03 v5(131.37,14.23) ; v5(145.28,7.83) v4(144.93,7.83)
  IN2 w0.074: v5(145.28,7.83) 145.59,7.52 153.21,7.52 154.15,6.58 156.24,6.58 158.88,3.94 165.13,3.94 165.91,4.72 168.12,4.72 v9(168.25,4.84) ; v5(131.37,14.23) 130.81,14.79 130.81,16.06 130.22,16.64 130.22,20.21 129.24,21.19 115.7,21.19 113.83,23.06 113.83,25.11 112.44,26.5 110.39,26.5 108.7,28.19 97.53,28.19 96.06,29.66 86.6,29.66 84.83,27.89 78,27.89 76.71,29.17 72.95,29.17 70.38,26.6 60.1,26.6 54.71,31.99 54.71,33.66 53.16,35.21 53.16,43.82 54.39,45.05 54.39,51.17 50.53,55.04 50.53,61.46 51.91,62.85 51.91,63.49 55.53,67.11 55.53,70.27 56.59,71.32 56.59,74.31 54.8,76.1 53.68,76.1 52.19,77.59 52.19,83.27 51.13,84.33 51.13,88.59 48.8,90.92 46.77,90.92 46.5,91.19 43.39,91.19 42.03,92.54 42.03,93.56 41.73,93.86 40.43,93.86 v5(40.24,93.67)
  GND3 w0.102: v8(40.18,94.06) 40.18,93.73 v5(40.24,93.67)
  IN3 w0.064: v6(35.19,101.3) 35.37,101.3 36.59,100.08 36.59,97.49 40.01,94.06 v8(40.18,94.06)
AC_PRESENT: length 19
  TOP w0.127: v2(57.55,7.87) 57.81,8.12 57.81,8.58 v1(58.07,8.85) 57.81,9.11 57.81,11.82 57.54,12.09 RH601.1 ; UE3.K8 46.84,9.7 v2(46.9,9.7)
  IN1 w0.064: v2(57.55,7.87) 57.38,7.87 57.15,8.1 53.95,8.1 53.49,8.56 53.49,9.09 52.49,10.09 52.49,10.14 51.8,10.83 50.85,10.83 50.58,11.09 49,11.09 48.84,10.93 48.35,10.93 48.15,10.73 47.84,10.73 47.8,10.77 47.58,10.77 47.43,10.62 47.43,10.37 46.9,9.84 v2(46.9,9.7)
AC_PRESENT_DGFX: length 250.3
  TOP w0.127: v2(62.06,12.05) 61.85,12.05 61.47,12.43 61.46,12.43 61.25,12.64 QC6.6 61.36,12.78 RH583.2 62.87,13.23 63.62,13.23 64.02,13.62 QC2.6 ; v7(75.05,21.82) 75.06,21.82 v1(75.06,21.35) 75.06,21.1 73.48,19.52 73.48,16.2 73.01,15.73 73.01,14.18 70.27,11.43 v2(70.27,8.27)
  IN1 w0.064: v2(70.27,8.27) 69.93,8.27 68.08,10.12 65.85,10.12 65.35,10.62 62.46,10.62 62.06,11.01 v2(62.06,12.05)
  GND2 w0.102: v7(75.05,21.82) v5(75.05,21.1)
  IN2 w0.074: v5(56.97,99.32) 56.97,99.96 53.59,103.33 48.33,103.33 42.14,97.14 40.76,97.14 37.31,100.59 36.64,100.59 35.27,101.96 32.67,101.96 31.86,101.16 31.86,98.48 29.59,96.21 26.71,96.21 26.16,95.66 23.41,95.66 21.85,94.1 21.85,89.91 19.62,87.68 19.62,84.89 20.68,83.83 21.76,83.83 22.53,83.05 22.53,81.79 20.67,79.93 20.67,72.14 18.8,70.27 18.8,64.55 16.47,62.21 15.88,62.21 14.73,61.06 14.73,59.49 16.34,57.87 20.67,57.87 22.6,55.94 22.6,55.1 23.7,54 23.7,50.76 24.15,50.31 24.15,42.07 24.4,41.82 24.4,36.63 24.02,36.26 24.02,35.46 24.58,34.9 25.82,34.9 28.29,32.43 30.26,32.43 31.73,30.96 31.73,27.89 33.89,25.73 35.09,25.73 38.13,22.69 38.13,20.79 38.59,20.33 45.16,20.33 45.76,20.93 49.56,20.93 50.16,20.33 52.45,20.33 52.63,20.15 55.72,20.15 56.61,19.27 61.18,19.27 63.2,21.29 74.86,21.29 v5(75.05,21.1)
  GND3 w0.102: v8(57.35,99.4) 57.04,99.4 v5(56.97,99.32)
  IN3 w0.064: v3(87.17,83.82) 86.86,83.82 86.53,83.5 83.66,83.5 83.46,83.29 82.75,83.29 82.5,83.55 80.78,83.55 79.89,84.44 78.71,84.44 78.33,84.82 78.33,84.94 76.83,86.44 76.83,87.42 71.45,92.81 71.45,94.4 70.68,95.17 70.34,95.17 66.54,98.96 57.78,98.96 v8(57.35,99.4)
AC_PRESENT_GPU: length 13.4
  TOP w0.127: v2(56.9,10.41) 56.57,10.09 56.57,10.01 55.98,9.42 54.53,9.42 54.28,9.18 51.98,9.18 50.58,10.57 49.96,10.57 49.55,10.98 UE3.J12 ; RE300.1 59.62,10.2 RH604.1 59.58,10.83 v2(59.79,11.03)
  IN1 w0.064: v2(56.9,10.41) 57.1,10.41 57.72,11.03 v2(59.79,11.03)
AC_PRESENT_INV: length 3.6
  TOP w0.127: QC2.3 62.72,15.53 62.86,15.39 63.24,15.39 63.37,15.51 QC2.2 63.37,16.22 63.55,16.4 RH581.2 64.42,16.85 v1(64.55,16.72)
AC_PRESENT_R: length 89.7
  TOP w0.127: v9(55.47,3.89) 56.17,4.59 v1(56.17,4.78) 56.17,7.75 57.6,9.18 57.6,11.63 56.96,12.28 RH601.2 RH600.1 56.83,13.29 RH602.2
  IN3 w0.064: v3(22.6,42.96) 22.33,42.96 21.61,43.68 19.45,43.68 18.3,42.53 18.3,41.71 18,41.42 18,40.29 19.02,39.27 19.02,35.79 19.76,35.04 19.76,34.54 24.62,29.69 24.62,29.49 26.68,27.43 26.68,27.05 27.13,26.6 27.47,26.6 29.17,24.9 29.17,23.35 28.08,22.26 28.08,19.55 28.4,19.22 28.4,17.96 30.22,16.14 30.22,15.45 31.73,13.94 31.73,13.33 32.56,12.5 32.56,12.36 34.05,10.86 38.36,10.86 39.01,10.22 40.25,10.22 41.23,11.19 44.12,11.19 44.94,10.38 44.94,6.5 45.7,5.75 45.91,5.75 46.49,5.16 51.79,5.16 53.36,5.16 53.63,4.89 54.47,4.89 v9(55.47,3.89)
  BOTTOM w0.076: UH4.BB15 27.21,42.32 27,42.53 26.74,42.53 26.64,42.63 25.33,42.63 24.9,43.06 23.14,43.06 23.09,43.11 22.75,43.11 v3(22.6,42.96) 22.45,43.11 22.07,43.11
  BOTTOM w0.127: RH126.1 21.48,43.11 22.07,43.11
ACAV_IN: length 58.8
  TOP w0.127: v2(54.71,17.61) 54.57,17.47 54.57,15.88 ; v2(24.86,8.5) v1(24.86,8.03) 24.86,7.64 26.36,6.14 PR547.1 PR546.2 PR554.2 ; 54.57,15.88 54.68,15.77 55.42,15.77 56.88,14.31 DV9.3 57.19,14.25 57.76,14.81 UC10.2 ; 54.57,15.88 54.12,15.44 54.12,15.13 55.04,14.22 55.04,13.95 55.56,13.43 RH602.1
  IN1 w0.064: v2(54.71,17.61) 54.69,17.61 54.01,18.29 47.29,18.29 46.2,17.2 46.2,16.44 v7(45.55,15.79) 45.35,15.79 43.98,17.16 39.56,17.16 39.05,17.66 36.83,17.66 36.59,17.89 35.24,17.89 33.99,16.64 29.92,16.64 28.96,15.69 28.96,15.09 26.77,12.9 26.77,8.72 26.56,8.5 v2(24.86,8.5)
ACAV_IN1: length 148.2
  TOP w0.127: v2(51.79,1.67) 51.7,1.58 46.82,1.58 v1(46.71,1.69) 42.82,1.69 42.71,1.58 41.38,1.58 39.26,3.7 38.62,3.7 PR518.1 38.47,3.84 36.73,3.84 PQ501.1 36.73,4.6 36.26,5.07 35.09,5.07 PR545.1
  TOP w0.254: v2(168.88,2.36) 167.99,2.36 167.79,2.56 PR542.1
  IN1 w0.064: v2(51.79,1.67) 51.66,1.8 51.66,3 52.21,3.55 53.09,3.55 54.27,2.37 55.6,2.37 56.68,3.45 59.56,3.45 60.62,2.39 73.35,2.39 73.45,2.29 82.65,2.29 82.8,2.44 83.89,2.44 84.04,2.29 89.64,2.29 89.93,2.58 91.52,2.58 91.81,2.29 95.21,2.29 96.67,3.75 100.02,3.75 101.48,2.29 106.33,2.29 106.65,2.61 106.65,3.46 106.65,3.57 107.53,4.45 109.74,5.37 124.47,5.37 126.6,7.49 128.22,7.49 130.03,5.68 146.91,5.68 149.62,2.96 152.98,2.96 153.97,3.96 164.86,3.96 165.98,2.84 166.7,2.84 167.19,2.36 v2(168.88,2.36)
ACC1_INT1: length 288.2
  TOP w0.127: v7(69.31,2.65) 69.69,3.03 69.69,11.15 72.81,14.26 72.81,15.81 73.28,16.28 73.28,19.6 74.74,21.07 v1(74.74,26.37) 74.74,26.91 v2(73.89,27.77) ; RR20.2 16.94,47.33 15.57,48.69 v7(15.57,49.04)
  IN1 w0.064: v2(73.89,27.77) 74.46,28.34 78,28.34 78.7,27.64 79.81,27.64 80.28,27.18 85.28,27.18 85.52,26.93 94.83,26.93 97.63,24.13 103.23,24.13 104.13,25.03 104.74,25.03 108.31,28.6 111.85,28.6 113.02,29.77 133.27,29.77 136.52,33.03 136.52,34.92 136.99,35.39 137.52,35.39 138.44,36.3 143.59,36.3 144.4,37.11 144.4,41.73 143,43.12 136.75,43.12 134.65,45.23 134.65,47.63 132.73,49.55 132.04,49.55 127.99,53.61 127.99,59.42 127.81,59.59 127.55,59.59 126.66,60.48 126.66,62.3 125.89,63.07 125.89,65.02 127.68,66.81 127.68,69.89 129.47,71.67 132.14,71.67 133.71,73.24 133.71,73.42 136.42,76.13 136.42,76.7 137.84,78.12 137.84,82.06 137.24,82.67 137.24,85.19 137.51,85.46 137.51,86.52 143.53,92.54 143.53,97.12 144.18,97.77 v4(144.18,98.66)
  GND2 w0.102: v5(69.7,2.3) 69.35,2.65 v7(69.31,2.65) ; v4(144.18,98.66) 144.03,98.51 143.86,98.51 143.86,98.5 v5(143.83,98.5) ; v5(15.2,49.01) 15.24,49.04 v7(15.57,49.04)
  GND3 w0.102: v6(144.16,98.55) 143.88,98.55 v5(143.83,98.5) ; v8(69.95,1.99) 69.95,2.06 v5(69.7,2.3) ; v5(15.2,49.01) v8(14.86,49.01)
  IN3 w0.064: v8(69.95,1.99) 69.83,1.87 57.76,1.87 56.43,3.21 55.08,3.21 54.72,3.56 53.4,3.56 52.99,3.16 46.21,3.16 45.55,3.82 44.81,3.82 44.54,4.08 40.2,4.08 39.41,4.88 38.73,4.88 37.52,6.08 33.85,6.08 32.3,7.63 29.34,7.63 25.78,11.2 25.24,11.2 22.84,13.6 22.84,14.27 19.45,17.66 19.32,17.66 15.78,21.2 15.78,24.64 16.58,25.44 16.58,26.91 14.8,28.69 14.8,33 14.01,33.79 14.01,37.3 15.74,39.02 15.74,48.13 v8(14.86,49.01)
ACC2_ADD_SEL: length 3
  BOTTOM w0.127: R1207.1 v1(67.27,20.96)
  BOTTOM w0.254: U18.3 67.28,18.51 67.27,18.52 R1206.1 R1207.1
ACC2_I2C_SCK: length 2.5
  BOTTOM w0.127: U18.1 66.28,18.14 66.12,18.29 65.06,18.29 R373.2 v1(65.06,17.23)
ACC2_I2C_SCK1: length 6.2
  BOTTOM w0.127: JKB1.13 31.92,8.54 31.98,8.59 31.98,9.31 31.47,9.82 31.47,10.56 v9(30.96,11.07) 31.78,11.89 32.48,11.89 32.61,12.02 32.61,12.13 R5838.2
ACC2_I2C_SDA: length 2.8
  BOTTOM w0.127: v1(70.14,18.24) 68.93,18.24 68.68,18.5 67.98,18.5 67.78,18.3 U18.4
ACC2_I2C_SDA1: length 6.2
  BOTTOM w0.127: JKB1.12 32.42,8.54 32.23,8.73 32.23,9.42 31.72,9.92 31.72,10.56 v9(32.23,11.07) 31.83,11.46 31.83,11.58 31.89,11.64 32.59,11.64 32.86,11.91 32.86,12.07 R5839.2
ACC2_INT1: length 141.9
  TOP w0.127: v7(12.42,56.19) 12.42,53.7 v1(14.3,51.81) 14.88,51.23 14.88,48.95 17.14,46.69 RR21.2
  GND2 w0.102: v5(12.01,56.19) v7(12.42,56.19)
  IN2 w0.074: v5(66.28,17.1) 64.58,15.41 57.72,15.41 57.24,15.88 54.3,15.88 53.59,16.59 51.41,16.59 51.05,16.95 36.03,16.95 33.42,19.55 31.72,19.55 31.16,20.11 27.81,20.11 25.56,22.36 19.47,22.36 17.03,24.8 v5(12.43,24.8)
  GND3 w0.102: v5(12.43,24.8) 12.19,25.04 v8(12.1,25.04) ; v8(11.68,56.19) v5(12.01,56.19) ; v6(66.28,17.46) v5(66.28,17.1)
  IN3 w0.064: v8(11.68,56.19) 10.06,56.19 6.92,53.05 6.92,38.05 7.04,37.93 7.04,37.45 7.76,36.73 7.76,28.13 7.93,27.95 7.93,25.69 8.7,24.92 11.98,24.92 v8(12.1,25.04) 12.81,25.04 14.97,22.89 14.97,21.22 19.08,17.1 19.22,17.1 22.26,14.07 22.26,12.72 24.71,10.27 25.91,10.27 29.89,6.3 v3(32.77,6.3)
  BOTTOM w0.127: JKB1.11 32.92,6.44 v3(32.77,6.3)
ALW_PWRGD_3V_5V: length 275.8
  TOP w0.127: v7(17.05,18.8) 16.65,18.4 v1(14.96,18.4) 13.4,18.4 10.91,15.91 7.46,15.91 v9(6.52,16.85) ; PQ322.2 50.8,71.82 49.86,70.87 v7(49.86,70.77) ; v2(59.98,92.92) 59.85,93.05 59.85,94.32 59.51,94.66 59.51,99.89 PR629.2
  IN1 w0.064: v2(59.98,92.92) 59.94,92.96 59.23,92.96 58.93,92.66 55.49,92.66 54.82,91.99 54.82,89.71 50.64,85.54 v9(50.64,79.46) ; v7(17.05,18.8) 17.51,19.26 17.51,20.68 16.17,22.02 16.17,23.3 17.09,24.21 17.09,25.94 17.54,26.39 17.54,30.09 17.12,30.51 17.12,36.06 16.43,36.74 16.43,37.55 17.08,38.19 17.08,38.82 16.79,39.11 16.79,46.54 17.02,46.77 17.02,52.36 18.21,53.55 18.21,55.55 20.77,58.11 21.89,58.11 27.02,63.24 27.02,64.56 26.32,65.26 26.32,66.81 26.62,67.11 26.62,69.18 28.24,70.81 29.33,70.81 30.2,71.67 31.4,71.67 31.65,71.42 33.79,71.42 v4(33.88,71.33)
  GND2 w0.102: v4(33.88,71.33) 33.98,71.43 v5(34.24,71.43) ; v5(49.48,70.9) 49.73,70.9 v7(49.86,70.77) ; v5(17.7,18.78) 17.08,18.78 v7(17.05,18.8)
  IN2 w0.074: v5(17.7,18.78) 18.2,18.78 19.94,17.04 22.96,17.04 25.98,14.01 33.61,14.01 34.26,13.35 43.39,13.35 44.24,12.5 78,12.5 78.59,13.09 83.19,13.09 85.72,15.62 85.72,17.2 88.26,19.74 88.26,20.6 91.14,23.48 95.78,23.48 96.6,24.29 98.48,24.29 98.65,24.12 103.86,24.12 104.25,24.52 106.41,24.52 110.69,20.24 112.87,20.24 113.75,19.36 120.64,19.36 122.23,17.78 122.23,16.48 123.01,15.7 123.01,14.39 v9(124.49,12.91)
  GND3 w0.102: v5(49.48,70.9) 49.26,71.11 v6(49.16,71.11) ; v5(34.24,71.43) 34.29,71.38 v6(34.58,71.38)
  BOTTOM w0.127: v9(6.52,16.85) 7.08,17.4 7.08,22.17 PR624.1 ; v9(50.64,79.46) 51.06,79.04 PR626.2 52.23,78.42 50.49,76.69 50.49,71.53 50.07,71.11 v6(49.16,71.11) 48.82,71.46 34.65,71.46 v6(34.58,71.38) ; v9(124.49,12.91) 125.07,13.48 125.07,15.51 125.85,16.3 125.85,18.42 125.7,18.57 125.7,19.89 126.21,20.4 127.35,20.4 127.58,20.63 PR627.2
ALWON: length 332.6
  TOP w0.122: v7(43.95,17.81) UE3.A5
  TOP w0.127: v9(16.15,21.44) 15.57,20.86 15.57,19.69 15.96,19.3 17.39,19.3 17.84,18.85 17.84,18.54 19.24,17.14 v1(22.7,17.14) v2(29.94,17.14) ; v2(91.3,18.19) 91.4,18.09 91.4,14.44 90.38,13.42 90.38,9.99 90.24,9.86 90.24,8.18 90,7.94 90,7.21 v2(89.23,6.43)
  IN1 w0.064: v4(40.28,90.28) 40.56,90.28 41.2,90.92 41.2,97.03 42.78,98.61 48.08,98.61 49.44,99.97 58.4,99.97 58.61,100.17 58.61,104.01 60.85,106.25 62.26,106.25 63.03,107.02 v7(63.03,107.22) ; v4(38.32,73.87) 38.32,73.88 38.07,74.13 37.86,74.13 37.35,73.62 35.36,73.62 34.05,72.31 31.99,72.31 31.63,71.95 28.62,71.95 26.45,69.78 26.45,67.14 26.18,66.87 26.18,65.2 26.88,64.5 26.88,63.3 21.83,58.25 20.67,58.25 17.98,55.56 17.98,53.55 16.88,52.46 16.88,46.83 16.62,46.57 16.62,39.08 16.94,38.76 16.94,38.25 16.29,37.6 16.29,36.68 16.95,36.02 16.95,30.46 17.37,30.04 17.37,26.43 16.93,25.98 16.93,24.25 16.03,23.35 16.03,21.97 16.15,21.85 v9(16.15,21.44) ; v2(91.3,18.19) 91.3,18.02 92.29,17.03 98.15,17.03 98.57,17.45 103.5,17.45 105.2,19.14 105.2,19.5 106.29,20.59 v4(106.4,20.59) ; v2(29.94,17.14) 30.3,16.78 33.93,16.78 35.42,18.27 38.69,18.27 39.44,17.53 43.63,17.53 43.91,17.81 v7(43.95,17.81) 46.57,17.81 47.2,18.43 54.07,18.43 54.63,17.87 55.39,17.87 56,17.25 56,15.5 57.61,13.9 61.84,13.9 64.04,11.7 67.9,11.7 70.5,9.1 71.2,9.1 71.79,8.51 76.76,8.51 77.46,7.81 78.73,7.81 78.91,7.63 82.47,7.63 83.1,7 84.58,7 84.95,6.63 89.03,6.63 v2(89.23,6.43) 91.09,6.43 91.28,6.63 93.95,6.63 94.19,6.39 97.67,6.39 98.05,6.77 100.22,6.77 100.34,6.89 v4(100.34,6.89)
  GND2 w0.102: v4(38.32,73.87) 38.33,73.87 38.35,73.89 v5(38.35,74.43) ; v5(63.47,106.51) 63.47,106.57 63.03,107.02 v7(63.03,107.22) ; v5(100.67,6.83) 100.4,6.83 v4(100.34,6.89) ; v4(40.28,90.28) v5(40.28,89.87) ; v5(123.83,18.44) 123.68,18.3 v7(123.29,18.3) ; v4(106.4,20.59) v5(106.4,20.92)
  IN2 w0.074: v5(40.28,89.87) 41.12,89.03 41.86,89.03 42.9,87.99 42.9,86.37 44.58,84.69 44.58,76.77 43.66,75.85 40.99,75.85 39.57,74.43 v5(38.35,74.43) ; v5(63.47,106.51) 64.06,106.51 66.05,104.51 66.05,98.74 65.78,98.47 65.78,95.97 67.28,94.47 67.28,89.57 v5(67.46,89.39)
  GND3 w0.102: v6(67.31,89.03) 67.31,89.24 v5(67.46,89.39) ; v5(106.4,20.92) v6(106.4,21.34) ; v6(101.02,6.83) v5(100.67,6.83) ; v5(123.83,18.44) v8(123.83,19.18)
  IN3 w0.064: v6(106.4,21.34) 110.01,21.34 110.33,21.01 114.48,21.01 115.8,19.69 123.32,19.69 v8(123.83,19.18) 124.66,19.18 126.65,21.18 129.4,21.18 129.89,21.67 129.89,27.15 v3(128.63,28.4)
  BOTTOM w0.127: R5869.2 101.66,1.78 101.27,2.18 101.27,6.58 v6(101.02,6.83) ; PR611.1 60.64,80.92 61.91,82.19 62.9,82.19 64.11,83.39 64.11,85.83 v6(67.31,89.03) ; R5835.2 104.47,21.67 106.07,21.67 v6(106.4,21.34) ; v9(16.15,21.44) 15.8,21.8 PR604.1
  BOTTOM w0.203: PR605.1 PR604.1
AUD_AZA_CPU_SCLK: length 82.6
  TOP w0.127: v2(72.23,55.38) v1(75.99,59.14) 78.51,59.14 79.7,60.33 v7(79.7,60.97)
  IN1 w0.064: v2(72.23,55.38) 72.23,55.35 71.71,54.83 64.13,54.83 60,50.69 60,47.28 59.45,46.74 59.2,46.74 57.03,44.56 57.03,42.36 59.19,40.2 59.19,36.85 v4(59.24,36.8)
  GND2 w0.102: v5(59.24,36.44) v4(59.24,36.8) ; v5(79.85,61.35) 79.7,61.19 v7(79.7,60.97)
  GND3 w0.102: v6(59.24,36.06) v5(59.24,36.44) ; v5(79.85,61.35) 80.01,61.2 v6(80.2,61.2)
  BOTTOM w0.127: v6(59.24,36.06) 60.05,35.25 60.05,30.69 55.03,25.67 53.84,25.67 51.2,23.03 44.21,23.03 41.13,26.12 37.14,26.12 32.36,30.91 RH133.1
AUD_AZA_CPU_SCLK_R: length 4.3
  BOTTOM w0.076: UH4.AM2 32.26,36.03 31.93,35.7 31.93,33.91 32.17,33.67 32.17,33.36
  BOTTOM w0.127: RH133.2 32.17,32.31 v1(32.17,33.04) 32.17,33.36
AUD_AZA_CPU_SDI_R: length 95.4
  TOP w0.127: v2(71.45,55.3) 71.93,54.82 72.53,54.82 75.88,58.17 v1(79.66,58.17) 80.92,58.17 82.8,60.05 82.8,61.63 82.23,62.2 81.96,62.2 81.84,62.32 81.84,63.2 RH38.2
  IN1 w0.064: v2(71.45,55.3) 71.43,55.3 71.26,55.12 63.91,55.12 59.72,50.93 59.72,47.4 59.34,47.01 58.96,47.01 56.75,44.81 56.75,42.24 58.33,40.67 58.33,37.33 v4(58.25,37.25)
  GND2 w0.102: v5(58.86,37.06) 58.67,37.25 v4(58.25,37.25)
  GND3 w0.102: v6(59.33,36.94) 58.99,36.94 v5(58.86,37.06)
  BOTTOM w0.076: 31.85,33.36 31.85,33.61 31.76,33.7 31.76,35.92 UH4.AN2
  BOTTOM w0.127: 31.85,33.36 31.85,31.13 37.09,25.89 41.07,25.89 44.18,22.78 51.23,22.78 53.92,25.47 55.12,25.47 60.28,30.63 60.28,36.06 59.39,36.94 v6(59.33,36.94)
AUD_AZA_CPU_SDO: length 84.1
  TOP w0.127: v7(81.15,60.31) 81.07,60.23 81.07,59.8 79.97,58.69 v1(77.7,58.69) 76.08,58.69 72.43,55.05 72.08,55.05 71.85,55.28 v2(71.85,55.35)
  IN1 w0.064: v2(71.85,55.35) 71.85,55.3 71.52,54.97 63.99,54.97 59.86,50.84 59.86,47.34 59.39,46.88 59.06,46.88 56.89,44.71 56.89,42.3 58.52,40.68 58.52,35.63 v4(58.54,35.6)
  GND2 w0.102: v7(81.15,60.31) 81.38,60.53 v5(81.38,60.86) ; v4(58.54,35.6) 58.54,35.41 v5(58.77,35.18)
  GND3 w0.102: v5(81.38,60.86) 81.05,61.2 v6(80.99,61.2) ; v5(58.77,35.18) 59.17,35.18 v6(59.28,35.3)
  BOTTOM w0.127: v6(59.28,35.3) 59.82,34.76 59.82,30.75 54.95,25.88 53.76,25.88 51.11,23.23 44.3,23.23 41.19,26.35 37.2,26.35 32.99,30.56 RH130.1
AUD_AZA_CPU_SDO_R: length 5.4
  BOTTOM w0.076: UH4.AM1 32.16,33.96 32.69,33.43 32.69,33.36
  BOTTOM w0.127: v1(33.37,30.69) 33.37,31.9 33.14,32.12 RH130.2 32.99,32.49 32.69,32.8 32.69,33.36
AUD_PWR_EN: length 131.7
  TOP w0.127: RH177.1 33.11,59.31 RH612.1 33.1,59.02 v7(33.31,58.8) 33.49,58.8 35.09,60.41 36.75,60.41 37.22,60.88 39.23,60.88 44.11,55.99 44.65,55.99 45.6,55.04 45.6,35.99 46.98,34.61 48.07,34.61 v2(48.41,34.27) ; v2(73.5,12.91) 73.5,13.14 76.67,16.3 76.67,21.58 77.97,22.89 77.97,24.8 79.19,26.02 79.19,27.16 79.04,27.31 v1(79.04,27.96) v2(79.04,28.53)
  IN1 w0.064: v2(73.5,12.91) 73.96,12.45 77.92,12.45 79.71,10.66 83.75,10.66 84.13,10.29 85.14,10.29 85.54,9.89 93,9.89 93.7,10.59 98.23,10.59 99.23,11.59 103.69,11.59 104.4,12.3 104.68,12.3 105.03,12.66 105.66,12.66 105.9,12.9 107.46,12.9 107.56,13 108.37,13 v4(108.66,13.29) ; v2(48.41,34.27) 48.51,34.17 53.15,34.17 55.14,32.17 55.37,32.17 56.13,31.41 58.1,31.41 58.3,31.62 61.98,31.62 62.93,30.67 64.87,30.67 65.58,29.97 67.84,29.97 68.91,28.9 78.67,28.9 v2(79.04,28.53)
  GND2 w0.102: v7(33.31,58.8) 33.31,58.39 v5(33.36,58.34) ; v5(108.74,13.69) 108.66,13.61 v4(108.66,13.29)
  GND3 w0.102: v6(109.06,13.9) 108.95,13.9 v5(108.74,13.69) ; v5(33.36,58.34) 33.36,57.94 v6(33.5,57.8)
  BOTTOM w0.076: v6(33.5,57.8) 33.5,57.69 33.65,57.54 33.65,57.23 33.21,56.79 UH4.AK44
AUX_EN_WOWL: length 90.8
  TOP w0.127: v2(81.47,7.16) 81.44,7.13 81.44,3.38 v2(81.42,3.35)
  IN1 w0.064: v4(113.05,12.9) 113.05,12.07 111.88,10.91 111.88,9.63 111.65,9.39 110.48,9.39 109.99,9.88 109.41,9.88 109.21,10.07 106.66,10.07 104.12,7.53 104.12,6.88 103.29,6.05 103.26,6.05 98.94,6.05 98.13,5.24 95.17,5.24 v2(94.97,5.04) 93.58,3.65 92.14,3.65 91.96,3.83 88.46,3.83 87.92,4.37 86.62,4.37 86.11,3.86 84.71,3.86 84.55,3.71 83.97,3.71 83.79,3.89 81.95,3.89 v2(81.42,3.35) ; v2(42.35,14.99) 42.62,14.99 42.75,14.86 43.87,14.86 43.96,14.95 44.42,14.95 44.64,14.73 46.46,14.73 47.05,15.32 47.05,15.7 47.23,15.88 47.23,17.13 48.12,18.01 53.89,18.01 54.31,17.6 54.31,17.44 54.54,17.21 54.96,17.21 55.61,16.56 55.61,15.5 57.55,13.57 61.77,13.57 63.92,11.42 66.76,11.42 67.38,10.8 68.36,10.8 70.34,8.82 71.08,8.82 71.68,8.23 76.65,8.23 77.35,7.53 78.62,7.53 78.79,7.35 81.27,7.35 v2(81.47,7.16)
  GND2 w0.102: v5(113.43,12.87) 113.08,12.87 v4(113.05,12.9)
  GND3 w0.102: v6(113.51,12.38) 113.43,12.46 v5(113.43,12.87)
  BOTTOM w0.127: JIO1.H2 113.06,12.83 v6(113.51,12.38)
B+: length 37.4
  TOP w0.254: v9(141.83,11.26) 142.39,11.82 153.06,11.82 153.6,12.36 158.72,12.36 159.65,13.29 PR516.2
  IN1 w0.381: v2(68.93,97.31) 68.45,97.8 68.45,98.84 67.81,99.47 61.41,99.47 v7(61.2,99.68)
  GND2 w0.254: v7(60.68,99.14) 60.35,99.14 v5(60.25,99.04) ; v5(60.32,98.51) 60.47,98.66 v7(60.65,98.66) ; v7(60.35,99.52) 60.04,99.52 v5(59.99,99.47) 59.99,99.75 v7(60.12,99.88) ; v7(61.19,98.76) 61.19,98.53 v5(61.01,98.35)
  IN2 w1.016: 99.25,29.24 105.44,29.24
  vias: v3(5.89,10.08) v3(6.22,10.3) v3(6.22,9.93) v3(104.67,33.97) v3(104.67,33.25) v3(104.67,32.52) v3(104.67,31.83) v3(104.67,31.12) v3(105,33.97) v3(105,33.25) v3(105,32.52) v3(105,31.83) v3(105,31.12) v3(105.42,33.97) v3(105.42,33.25) v3(105.53,32.48) v3(105.53,31.82) v3(105.53,31.11) v3(105.77,33.97) v3(105.77,33.25) v3(105.89,32.48) v3(105.89,31.82) v3(105.89,31.11) v3(106.13,33.97) v3(106.13,33.25) v3(106.24,32.48) v3(106.24,31.82) v3(106.24,31.11) v3(131.8,27.32) v3(131.8,26.82) v3(131.8,26.31) v3(131.8,25.8) v3(132.24,27.32) v3(132.24,26.82) v3(132.24,26.31) v3(132.24,25.8) v3(132.69,27.32) v3(132.69,26.82) v3(132.69,26.31) v3(132.69,25.8) v3(133.13,27.32) v3(133.13,26.82) v3(133.13,26.31) v3(133.13,25.8) v3(133.58,27.32) v3(133.58,26.82) v3(133.58,26.31) v3(133.58,25.8) v3(138.21,33.48) v3(138.21,33.1) v3(138.21,32.72) v3(138.21,32.34) v3(138.21,31.96) v3(138.21,31.58) v3(138.21,31.2) v3(138.66,33.48) v3(138.66,33.1) v3(138.66,32.72) v3(138.66,32.34) v3(138.66,31.96) v3(138.66,31.58) v3(138.66,31.2) v3(139.1,33.48) v3(139.1,33.1) v3(139.1,32.72) v3(139.1,32.34) v3(139.1,31.96) v3(139.1,31.58) v3(139.1,31.2) v5(57.72,74.39) v5(57.78,74.89) v5(57.79,73.83) v5(58.33,74.42) v5(58.33,73.86) v5(58.49,74.86) v5(58.92,74.58) v5(58.92,73.87) v5(59.53,74.38) v5(59.53,73.87) v5(60.04,74.38) v5(60.04,73.87) v5(82.29,91.01) v5(82.35,90.51) v5(82.83,91.09) v5(82.83,90.48) v5(83.23,90.18) v5(83.36,91.12) v5(83.41,91.58) v5(83.44,90.66) v5(83.83,90.96) v5(97.89,29.23) v5(98.4,29.23) v5(101.83,11.86) v5(106.21,28.91) v5(106.71,28.91) v5(109.83,12.13) v5(118.11,18.59) v5(118.56,18.83) v5(118.57,18.38) v5(119.02,18.59) v5(141.65,83.38) v5(141.65,82.92) v5(141.92,61.32) v5(142,58.12) v5(145.83,94.42) v5(145.82,93.97) v5(146.22,94.18) v6(57.46,74.64) v6(57.46,74.14) v6(58.02,74.58) v6(57.97,74.14) v6(58.2,75.14) v6(58.63,74.17) v6(58.82,75.11) v6(59.24,75.1) v6(59.28,74.64) v6(59.28,74.14) v6(59.79,74.64) v6(59.79,74.14) v6(82.1,91.36) v6(82.25,91.7) v6(82.61,91.36) v6(82.61,90.79) v6(82.57,90.15) v6(82.85,91.8) v6(83.06,91.36) v6(83.06,90.79) v6(83.74,91.37) v6(145.2,94.33) v6(145.19,93.94) v6(145.44,94.1) v7(97.63,29.48) v7(98.14,29.48) v7(118.16,18.99) v7(119.01,18.97) v7(140.91,83.22) v7(140.91,82.89) v9(8.61,56.6) v9(8.61,55.96) v9(9.39,17.19) v9(9.57,17.76) v9(9.63,16.57) v9(9.94,17.05) v9(10.33,16.63) v9(10.72,17.06) v9(12.42,10.81) v9(12.98,10.83) v9(13.54,10.82) v9(53.77,63.48) v9(54.2,63.94) v9(54.68,64.24) v9(58.33,106.25) v9(58.26,105.68) v9(58.26,105.11) v9(58.26,104.54) v9(58.95,106.29) v9(59.52,106.29) v9(107.1,32.91) v9(107.67,32.78) v9(108.39,32.52) v9(108.39,31.93) v9(108.39,31.35) v9(108.98,32.52) v9(108.98,31.93) v9(108.98,31.35) v9(109.56,32.52) v9(109.56,31.93) v9(109.56,31.35) v9(110.17,32.52) v9(110.17,31.93) v9(110.17,31.35) v9(110.78,32.52) v9(110.78,31.93) v9(110.78,31.35) v9(131.16,25.99) v9(131.16,25.36) v9(131.16,24.72) v9(131.16,24.09) v9(131.16,23.51) v9(131.16,22.94) v9(131.21,22.27) v9(131.73,24.72) v9(132.31,24.72) v9(132.77,24.12) v9(132.88,24.72) v9(133.45,24.72) v9(134.21,26.12) v9(134.21,25.55) v9(134.21,24.97) v9(134.21,24.4) v9(134.78,26.12) v9(134.78,25.55) v9(134.78,24.97) v9(134.78,24.4) v9(135.35,26.12) v9(135.35,25.55) v9(135.35,24.97) v9(135.35,24.4) v9(136.18,12.46) v9(136.18,11.7) v9(136.18,10.94) v9(136.18,10.18) v9(136.18,9.42) v9(136.18,8.65) v9(136.62,12.08) v9(136.62,11.32) v9(136.62,10.56) v9(136.62,9.8) v9(136.62,9.04) v9(137.92,10.72) v9(137.92,9.45) v9(138.93,10.72) v9(138.93,9.45) v9(139.95,10.72) v9(139.95,9.45) v9(141.26,11.26) v9(141.26,10.69) v9(141.26,10.12) v9(141.26,9.54) v9(141.26,8.97) v9(141.51,8.46) v9(141.83,10.69) v9(141.83,10.12) v9(150.66,46.31) v9(150.66,45.68) v9(151.23,46.31) v9(151.23,45.68) v9(151.74,45.99) v16(57.44,106.06)
B+_+0.95VSP:
  vias: v1(94.71,27.39)
B+_+1VALWP:
  vias: v1(6.7,52.66)
B+_AMP:
  vias: v1(116.07,13.9) v9(116.66,13.21) v9(116.66,12.6) v9(117.32,13.24) v9(117.29,12.6)
B+_CAM: length 17.2
  IN1 w1.016: 142.78,89.29 142.78,90.1 144.77,92.09 144.77,96.11 145.41,96.74 145.41,98.26
  IN2 w1.016: 146.94,100.38 148.12,101.57 148.12,106.6 147.78,106.94
  vias: v1(147.02,107.4) v2(142.53,88.62) v2(142.89,88.6) v4(145.27,98.79) v4(145.57,98.79) v5(145.96,98.84) v5(146.03,98.42) v9(146.15,107.91) v9(146.78,107.91) v9(147.35,107.91)
B+_VDD08:
  vias: v9(146.73,91.71)
B+_VDD12:
  vias: v1(54.52,61.11) v9(56.64,61.68) v9(57.12,61.98)
BAT1_LED#: length 70.3
  TOP w0.127: v2(97.95,11.83) v1(97.95,9.1) v2(97.95,6.06) ; v7(48.35,15.39) UE3.D10
  IN1 w0.064: v2(97.95,6.06) 91.29,6.06 90.89,5.66 87.5,5.66 86.96,6.21 84.78,6.21 84.41,6.57 83.3,6.57 83.01,6.28 81.09,6.28 80.71,6.65 78.47,6.65 78.29,6.83 77.06,6.83 76.36,7.53 69.88,7.53 68.03,9.38 65.66,9.38 65.04,10.01 62.24,10.01 59.93,12.32 57.14,12.32 52.87,16.59 51.6,16.59 51.16,16.15 49.71,16.15 49.29,15.73 48.74,15.73 48.4,15.39 v7(48.35,15.39) ; v4(105.37,13.55) 104.8,13.55 104.6,13.35 103.88,13.35 103.12,12.58 98.7,12.58 v2(97.95,11.83)
  GND2 w0.102: v4(105.37,13.55) v5(105.69,13.86)
  GND3 w0.102: v6(106.06,13.9) 106.03,13.86 v5(105.69,13.86)
BAT2_LED#: length 65.7
  TOP w0.127: v7(49.15,15.39) UE3.D11
  IN1 w0.064: v4(103.68,7.85) 103.68,7.09 103.05,6.47 98.76,6.47 97.95,5.66 95.3,5.66 95.03,5.92 91.35,5.92 90.95,5.52 87.45,5.52 86.9,6.07 84.71,6.07 84.35,6.43 83.36,6.43 83.07,6.14 80.43,6.14 80.19,6.39 78.54,6.39 78.23,6.69 77,6.69 76.3,7.39 69.83,7.39 67.97,9.25 65.56,9.25 64.97,9.84 62.17,9.84 59.83,12.18 57.08,12.18 52.85,16.41 51.74,16.41 50.94,15.61 50.56,15.61 50.42,15.47 49.23,15.47 v7(49.15,15.39)
  GND2 w0.102: v5(103.95,8.1) 103.7,7.85 v4(103.68,7.85)
  GND3 w0.102: v6(104.52,8.42) 104.27,8.42 v5(103.95,8.1)
  BOTTOM w0.102: v6(104.52,8.42) 106.41,8.42 106.89,8.9 JIO1.N8
BAT_LED#_LV1: length 2
  GND2 w0.102: v7(4.41,44.44) 4.41,44.56 v5(4.24,44.73)
  GND3 w0.102: v5(4.24,44.73) 4.17,44.8 4.17,45.09 v6(4.02,45.23)
  BOTTOM w0.127: v6(4.02,45.23) v1(4.02,44.16)
BAT_LED#_LV2: length 2.5
  TOP w0.127: LED5.1 3.83,41.42 v9(3.83,41.66)
  BOTTOM w0.127: RL4.2 4.33,41.17 v9(3.83,41.66) v1(3.18,41.66)
BAT_LED#_LV3: length 2.5
  TOP w0.127: LED4.1 4.41,37.58 v9(3.84,38.14)
  BOTTOM w0.127: RL3.2 v9(3.84,38.14) v1(3.09,38.14)
BAT_LED#_LV4: length 2.9
  TOP w0.127: v9(3.92,34.77) 4.41,34.28 LED3.1
  BOTTOM w0.127: v1(3.1,34.77) v9(3.92,34.77) 4.15,34.54 RL2.2
BAT_LED#_LV5: length 2.3
  TOP w0.127: LED2.1 3.73,30.72 v9(3.73,30.77)
  BOTTOM w0.127: RL1.2 v9(3.73,30.77) v1(3.06,30.77)
BATBTN#: length 110.7
  TOP w0.122: v7(43.58,16.77) 43.77,16.77 UE3.B5
  TOP w0.127: v2(23.47,1.66) v16(23.47,3.51) 23.47,6.71 v2(23.31,6.86) ; RE137.1 35.86,15.83 36.22,16.19 36.22,17.58 v2(36.27,17.63) ; DL1.3 6.8,52.33 5.41,53.72 4.45,53.72 SW3.3 3.58,52.22 3.58,48.8 SW3.4
  IN1 w0.064: SW3.4 3.46,48.49 4.7,47.25 4.7,44.28 4.31,43.9 4.31,27.56 3.12,26.37 3.12,20.91 1.98,19.77 1.98,9.69 5.67,6 12.01,6 16.35,1.66 v2(23.47,1.66) ; v7(43.58,16.77) 43.36,16.99 39.49,16.99 39.02,17.46 36.45,17.46 v2(36.27,17.63) 36.22,17.68 35.23,17.68 34.02,16.48 30.16,16.48 29.13,15.45 29.13,15.02 26.91,12.8 26.91,8.66 25.63,7.37 23.82,7.37 v2(23.31,6.86)
BATT++: length 1.9
  TOP w0.127: v9(132.37,7.08) v16(133.05,7.08) ; v9(130.97,7.08) v16(130.97,7.77) ; v9(129.71,7.08) v16(129.14,7.08)
  vias: v3(130.08,18.37) v3(130.08,17.99) v3(130.46,18.37) v3(130.46,17.99) v3(130.84,18.37) v3(130.84,17.99) v3(130.84,17.61) v3(131.23,18.37) v3(131.23,17.99) v3(131.23,17.61) v3(131.28,19.33) v3(131.61,18.37) v3(131.61,17.99) v3(131.61,17.61) v3(131.92,19.51) v3(131.92,19.13) v3(131.92,18.75) v3(131.92,18.37) v3(131.92,17.99) v3(131.92,17.61) v3(133.96,6.88) v3(133.96,6.56) v3(133.96,6.24) v3(133.96,5.92) v3(133.96,5.61) v3(134.27,6.88) v3(134.27,6.56) v3(134.27,6.24) v3(134.27,5.92) v3(134.27,5.61) v3(134.59,6.88) v3(134.59,6.56) v3(134.59,6.24) v3(134.63,5.92) v3(134.91,6.88) v3(134.91,6.56) v3(134.91,6.24) v3(134.95,5.92) v3(135.23,6.88) v3(135.23,6.56)
BATT_LED#_LV1: length 72.6
  TOP w0.127: v7(52.76,14.81) 52.57,15 52.23,15 51.98,14.75 51.98,13.53 51.48,13.04 51.2,13.04 50.49,13.75 49.91,13.75 UE3.F12
  GND2 w0.102: v5(52.77,14.27) 52.76,14.28 v7(52.76,14.81)
  GND3 w0.102: v5(52.77,14.27) v6(52.44,14.61)
  IN3 w0.064: v3(8.06,38.93) 8.06,38.93 8.06,33.66 8.45,33.27 13.39,33.27 13.77,32.89 13.77,28.93 15.97,26.73 15.97,26.31 15.67,26.01 15.67,25.58 v3(15.8,25.46)
  BOTTOM w0.127: v6(52.44,14.61) 50.66,16.39 46.77,16.39 46.1,17.06 42.81,17.06 42.54,16.79 39.62,16.79 39.27,17.14 37.89,17.14 37.38,16.63 36.85,16.63 28.45,25.04 26.37,25.04 26.13,24.8 23.02,24.8 22.6,25.21 21.83,25.21 21.6,24.99 21.03,24.99 20.63,24.59 16.66,24.59 v3(15.8,25.46) ; v3(8.06,38.93) v1(7.12,39.87) 6.18,40.81 Q4.3
BATT_LED#_LV2: length 83.2
  TOP w0.127: UE3.G10 48.14,12.4 48.14,12.28 v2(48.05,12.18) ; RE267.1 52.73,14.18 52.41,13.86 52.41,13.19 v2(51.86,12.64)
  IN1 w0.064: v9(5.23,34.84) 4.81,34.42 4.81,27.35 3.54,26.08 3.54,20.74 2.87,20.06 2.87,19.32 3.07,19.12 3.07,12.4 7.24,8.22 11.89,8.22 13.57,6.55 20.89,6.55 22.2,5.23 36.35,5.23 36.77,5.64 37.89,5.64 38.27,6.03 39.69,6.03 40.44,6.78 42.99,6.78 45.99,9.78 45.99,10.47 46.73,11.21 46.92,11.21 47.89,12.18 v2(48.05,12.18) 48.81,12.18 48.92,12.29 51.51,12.29 v2(51.86,12.64)
  BOTTOM w0.127: v1(4.62,35.18) 4.96,34.84 v9(5.23,34.84) 5.23,35.34 5.39,35.5 QH2.1
BATT_LED#_LV3: length 77.8
  TOP w0.127: UE3.H12 49.98,12.22 49.98,12.73 50.19,12.93 50.7,12.93 51.29,12.35 52.01,12.35 52.61,12.95 52.61,13.39 RE268.1 52.76,13.48 53.08,13.16 53.76,13.16 54.07,13.48 54.07,13.67 v1(54.26,13.86) 54.41,13.86 v7(54.6,14.05)
  GND2 w0.102: v7(54.6,14.05) 55.16,14.05 v5(55.55,13.66)
  GND3 w0.102: v5(55.55,13.66) 55.29,13.66 v6(54.84,13.21)
  IN3 w0.064: v3(15.97,25.86) 16.13,26.02 16.13,26.78 13.92,28.99 13.92,32.94 13.44,33.41 8.51,33.41 8.2,33.72 8.2,38.59 v3(8.51,38.89)
  BOTTOM w0.127: v3(8.51,38.89) 8.28,38.66 8.28,37.23 QH2.4 ; v3(15.97,25.86) 17.04,24.8 20.55,24.8 20.94,25.19 21.52,25.19 21.74,25.42 22.69,25.42 23.1,25 25.99,25 26.23,25.24 28.53,25.24 36.94,16.83 37.29,16.83 37.8,17.34 39.36,17.34 39.71,16.99 42.46,16.99 42.73,17.26 46.18,17.26 46.86,16.59 51.29,16.59 53.55,14.33 53.55,13.08 53.86,12.77 54.4,12.77 v6(54.84,13.21)
BATT_LED#_LV4: length 72.2
  TOP w0.127: v7(44.41,10.46) 44.52,10.57 45.13,10.57 UE3.J7 ; v7(52.48,5.27) 52.49,5.27 53.1,4.65 RE269.1 53.15,4.08 v1(53.43,3.8)
  IN1 w0.064: v7(44.41,10.46) 43.99,10.04 43.56,10.04 42.82,9.3 41.75,9.3 40.81,8.36 38.36,8.36 37.87,8.84 37.15,8.84 36.95,9.04 35.24,9.04 33.63,7.42 v4(30.4,7.42)
  GND2 w0.102: v7(52.48,5.27) 52.49,5.27 52.14,5.62 v5(52.12,5.62) ; v5(30.11,7.13) v4(30.4,7.42) ; v5(45.01,10.22) 44.76,10.46 v7(44.41,10.46)
  GND3 w0.102: v5(30.11,7.13) 29.83,7.13 v8(29.74,7.04) ; v8(45.2,9.86) 45.2,10.12 45.1,10.22 v5(45.01,10.22) ; v8(51.79,5.62) v5(52.12,5.62)
  IN3 w0.064: v8(29.74,7.04) 29.34,7.04 25.96,10.43 24.76,10.43 22.4,12.78 22.4,14.13 19.28,17.24 19.14,17.24 15.36,21.03 15.36,25.89 15.74,26.28 15.74,26.76 13.61,28.89 13.61,32.39 13,33 v3(11.43,33) ; v8(45.2,9.86) 45.08,9.74 45.08,6.56 45.75,5.89 45.97,5.89 46.55,5.3 50.63,5.3 50.95,5.62 v8(51.79,5.62)
  BOTTOM w0.127: QH1.1 8,33.31 8.28,33.03 11.4,33.03 v3(11.43,33)
BATT_LED#_LV5: length 90.9
  TOP w0.127: v7(53.15,5.29) 52.88,5.56 52.54,5.56 52.22,5.88 52.22,6.04 50.71,7.55 50.71,7.94 50.35,8.3 UE3.M13 ; v9(23.87,6.84) v1(23.87,6.28)
  IN1 w0.064: v9(23.87,6.84) 25.51,6.84 27.05,8.38 27.05,12.56 v4(29.69,15.2)
  GND2 w0.102: v5(30.07,15.5) 29.77,15.2 v4(29.69,15.2) ; v5(53.31,5.67) 53.31,5.45 v7(53.15,5.29)
  GND3 w0.102: v6(30.65,15.5) v5(30.07,15.5) ; v5(53.31,5.67) 52.93,5.67 v8(52.87,5.67)
  IN3 w0.064: v3(7.31,31.1) 7.31,28.17 7.63,27.86 7.63,25.6 8.61,24.62 12.81,24.62 14.49,22.94 14.49,20.79 17.98,17.29 17.98,13.74 15.48,11.24 15.48,8.86 17.93,6.41 23.44,6.41 v9(23.87,6.84) ; v6(30.65,15.5) 31.87,14.29 31.87,13.39 32.71,12.54 32.71,12.4 34.11,11 38.46,11 39.08,10.38 40.18,10.38 41.13,11.33 44.18,11.33 45.46,10.05 45.46,9.73 45.22,9.48 45.22,6.62 45.81,6.03 46.03,6.03 46.61,5.44 50.57,5.44 51.07,5.94 52.6,5.94 v8(52.87,5.67)
  BOTTOM w0.127: v3(7.31,31.1) 6.4,32.01 QH1.4
BBS_BIT0: length 4.4
  TOP w0.127: v7(29.51,49.13) 30.68,49.13 v1(31.28,48.53) 31.28,48.23 30.83,47.79 RH194.2
  GND2 w0.102: v7(29.51,49.13) 29.77,49.13 v5(29.87,49.23)
  GND3 w0.102: v6(29.89,49.58) 29.89,49.25 v5(29.87,49.23)
  BOTTOM w0.076: UH4.AT29 v6(29.89,49.58)
BC_CLK_ECE1117: length 23.1
  TOP w0.127: v1(33.47,6.53) 33.69,6.75 v9(34.32,6.75) ; UE3.D13 50.35,14.78 50.01,14.43 50.01,14.15 49.68,13.82 48.59,13.82 48.31,13.54 v2(48.31,13.04)
  IN1 w0.064: v9(34.32,6.75) 34.84,7.27 36.6,7.27 36.78,7.45 37.44,7.45 37.69,7.2 42.8,7.2 44.94,9.34 44.94,10.62 45.71,11.4 46.32,11.4 46.56,11.63 46.74,11.63 48.14,13.04 v2(48.31,13.04)
  BOTTOM w0.127: v9(34.32,6.75) 34.42,6.85 JKB1.8
BC_DAT_ECE1117: length 27.6
  TOP w0.127: RE130.1 52.64,15.32 52.26,15.32 51.61,14.67 51.61,14.25 v2(51.2,13.84) 50.97,14.06 50.97,15.2 50.77,15.4 49.96,15.4 UE3.D12 ; v9(34.9,6.75) 34.58,7.07 v1(34.58,7.26)
  IN1 w0.064: v2(51.2,13.84) 51.19,13.84 50.45,13.1 48.98,13.1 48.46,12.58 47.88,12.58 46.79,11.49 46.62,11.49 46.38,11.26 45.77,11.26 45.08,10.57 45.08,9.28 42.86,7.06 37.64,7.06 37.38,7.31 36.84,7.31 36.65,7.13 35.27,7.13 v9(34.9,6.75)
  BOTTOM w0.127: v9(34.9,6.75) 34.92,6.77 JKB1.7
BC_INT#_ECE1117: length 32.1
  TOP w0.127: v9(35.48,6.77) 35.48,6.58 v1(34.9,5.99)
  IN1 w0.064: v9(35.48,6.77) 35.09,6.37 27.28,6.37 27.19,6.47 27.19,10.29 33.12,16.21 34.31,16.21 35.65,14.87 36.71,14.87 37.28,14.3 41.44,14.3 v2(41.55,14.19)
  BOTTOM w0.127: v9(35.48,6.77) 35.42,6.83 JKB1.6
BEEP: length 69.8
  TOP w0.127: v2(87.09,5.28) v1(87.09,5.86) 87.09,8.99 v2(86.94,9.14) ; UE3.H11 48.83,11.79 49.02,11.6 49.27,11.6 49.49,11.37 50.76,11.37 51.76,10.37 v2(51.88,10.37)
  IN1 w0.064: v2(86.94,9.14) 86.99,9.09 88.01,9.09 88.15,8.95 93.05,8.95 93.99,9.89 96.75,9.89 96.99,9.65 99.21,9.65 99.81,10.25 103.22,10.25 103.58,10.61 104.21,10.61 105.83,12.24 106.78,12.24 107.02,12.48 107.94,12.48 108.13,12.67 v4(108.13,12.68) ; v2(51.88,10.37) 52.01,10.37 53.35,9.03 53.35,8.5 53.89,7.96 57.1,7.96 57.44,7.61 62.23,7.61 62.56,7.28 67.35,7.28 68.47,6.15 71.79,6.15 71.97,6.34 76.37,6.34 76.71,5.99 77.94,5.99 78.25,5.69 79.9,5.69 80.14,5.44 83.93,5.44 84,5.37 85.05,5.37 85.52,4.9 86.07,4.9 86.45,5.28 v2(87.09,5.28)
  GND2 w0.102: v5(108.33,12.37) 108.33,12.48 v4(108.13,12.68)
  GND3 w0.102: v5(108.33,12.37) 108.06,12.63 v6(108.06,12.9)
BIA_PWM_EC: length 156.3
  TOP w0.127: UE3.N1 39.97,7.79 v7(39.08,8.68) ; v2(67.54,98.28) 68.02,98.28 68.23,98.06 68.23,97.46 67.36,96.58 67.36,95.51 67.09,95.24 v1(67.09,93.66) 67.09,92.59 66.34,91.84 64.97,91.84 64.47,92.34 DV6.3
  IN1 w0.064: v2(67.54,98.28) 67.46,98.35 60.14,98.35 58.68,99.82 50.03,99.82 48.64,98.43 42.79,98.43 41.35,96.98 41.35,90.84 40.93,90.42 40.93,89.05 40.33,88.45 40.33,86.87 40.74,86.47 40.74,81.47 40.09,80.82 40.09,74.7 39.79,74.4 39.79,71.92 38.87,71 38.87,68.41 38.71,68.25 38.71,63.86 36.9,62.05 33.9,62.05 33.72,61.87 26.64,61.87 21.95,57.18 21.95,55.33 20.4,53.78 20.4,51.37 19.72,50.69 19.72,49.1 20.16,48.66 20.16,47.59 19.9,47.32 19.9,43.35 20.09,43.16 20.09,42.47 19.23,41.62 19.23,35.32 v4(19.1,35.18)
  GND2 w0.102: v5(19.12,34.85) 19.1,34.88 v4(19.1,35.18) ; v7(39.08,8.68) 39.08,8.84 v5(38.71,9.2)
  GND3 w0.102: v5(38.71,9.2) 38.71,9.68 v8(38.6,9.78) ; v8(19.5,34.85) v5(19.12,34.85)
  IN3 w0.064: v8(19.5,34.85) 19.5,34.61 24.48,29.63 24.48,29.43 26.54,27.37 26.54,26.99 27.07,26.46 27.41,26.46 29.03,24.84 29.03,23.41 27.92,22.3 27.92,19.51 28.26,19.17 28.26,17.9 30.08,16.08 30.08,15.39 31.59,13.89 31.59,13.27 32.41,12.45 32.41,12.31 33.99,10.72 37.66,10.72 v8(38.6,9.78)
BIA_PWM_PCH: length 103.3
  IN1 w0.064: v7(64.11,91.51) 62.42,93.2 59.24,93.2 58.83,92.8 55.43,92.8 54.68,92.04 54.68,89.91 50.5,85.73 50.5,79.95 50.28,79.73 50.28,73.05 45.22,67.99 45.22,63.02 44.04,61.84 44.04,60.7 41.82,58.48 41.82,57.72 40.46,56.37 40.46,54.96 39.23,53.73 v4(39.23,53.04)
  GND2 w0.102: v7(64.11,91.51) 63.83,91.22 v5(63.83,91.14) ; v5(38.86,53.04) v4(39.23,53.04)
  IN2 w0.074: v5(67.33,85.3) 67.33,84.28 72.56,79.05 v5(72.56,59.82)
  GND3 w0.102: v5(63.83,91.14) v8(63.83,90.79) ; v5(72.56,59.82) 72.46,59.72 v6(72.46,59.44) ; v5(38.86,53.04) 38.82,53.01 v6(38.48,53.01) ; v8(67,85.3) v5(67.33,85.3)
  IN3 w0.064: v8(67,85.3) 65.5,86.8 65.5,88.09 63.89,89.7 63.89,90.72 v8(63.83,90.79)
  BOTTOM w0.127: v6(72.46,59.44) 72.46,53.57 72.82,53.21 76.13,53.21 76.46,53.55 RH36.2
BID_BC: length 11.7
  TOP w0.127: RH196.2 23.01,54.65 23.34,54.32 RH199.1 23.84,54.3 24.23,54.69 v1(24.23,54.76) v7(24.23,55.5)
  GND2 w0.102: v7(24.23,55.5) 24.23,55.4 24.38,55.25 v5(24.38,55.2)
  GND3 w0.102: v5(24.38,55.2) v8(24.38,54.82)
  IN3 w0.064: v3(29.08,54.96) 28.61,54.49 28.55,54.49 28.14,54.08 28.14,53.24 27.71,52.81 25.54,52.81 24.38,53.98 v8(24.38,54.82)
  BOTTOM w0.107: UH4.AU41 v3(29.08,54.96)
BID_DIS: length 11.6
  TOP w0.127: RH198.1 23.34,56.95 23.01,56.62 RH195.2 v1(24.1,56.08) 24.19,56.08 v7(24.43,55.84)
  GND2 w0.102: v7(24.43,55.84) v5(24.76,55.84)
  GND3 w0.102: v5(24.76,55.84) v8(24.76,55.5)
  IN3 w0.064: v3(28.65,54.95) 27.94,54.23 27.94,53.24 27.65,52.95 25.66,52.95 24.64,53.97 24.64,55.38 v8(24.76,55.5)
  BOTTOM w0.107: UH4.BA41 28.44,55.29 28.65,55.08 v3(28.65,54.95)
BOARD_ID: length 5.2
  TOP w0.127: RE194.2 54.23,9.4 53.31,9.4 52.93,9.78 CE75.1 v1(52.02,9.86) 51.58,9.86 50.45,10.99 UE3.J13
BREATH_LED#: length 71.3
  TOP w0.127: v7(49.15,16.19) UE3.C11 ; LED7.1 98.29,13.98 v2(98.29,10.33) ; v2(88.45,6.08) 88.42,6.1 v1(88.42,7.58) 88.42,8.94 88.62,9.14 v2(88.62,9.63)
  IN1 w0.064: v2(88.62,9.63) 88.8,9.63 88.92,9.75 93.06,9.75 93.76,10.45 97.38,10.45 97.5,10.33 v2(98.29,10.33) 99.41,11.45 103.75,11.45 104.46,12.16 104.9,12.16 v4(105.14,12.39) ; v7(49.15,16.19) 49.24,16.19 49.92,16.87 52.98,16.87 57.25,12.6 60.08,12.6 62.34,10.34 65.2,10.34 65.77,9.77 68.04,9.77 70,7.81 76.47,7.81 77.17,7.11 78.44,7.11 78.62,6.93 80.92,6.93 81.3,6.56 82.84,6.56 83.14,6.86 84.52,6.86 84.89,6.49 88.03,6.49 v2(88.45,6.08)
  GND2 w0.102: v4(105.14,12.39) 105.45,12.71 v5(105.68,12.71)
  GND3 w0.102: v6(106.06,12.9) 105.87,12.71 v5(105.68,12.71)
BST_1VALWP: length 3.1
  BOTTOM w0.127: v1(4.54,49.29) 4.8,49.29 5.05,49.55 6.96,49.55 7.2,49.31 PR701.1
BST_1VALWP_R:
  vias: v1(5.18,48.09)
BST_+0.95VSP_R: length 2.1
  TOP w0.127: v1(99.23,30.26) PC1002.1
  TOP w0.356: PC1002.1 100.36,30.05 100.1,29.79 PR1001.2
BST_VDD08: length 1.7
  BOTTOM w0.254: PR2330.1 146.18,88.98 146.53,89.32 PU2304.1
BST_VGT1:
  vias: v1(55.91,52.03)
BST_VGT1_R: length 3.6
  TOP w0.127: v1(54.85,57.8) 54.85,56.84 PC2206.1
  TOP w0.508: PR2200.2 55.83,55.16 55.66,55.33 PC2206.1
BT_RADIO_DIS#: length 102.9
  TOP w0.089: 41.28,16.06 UE3.C2
  TOP w0.127: v2(81.83,7.02) 81.83,6.96 81.95,6.85 81.95,3.96 82.41,3.49 v2(82.41,2.96) ; v7(37.98,15.2) 38.22,15.44 39.52,15.44 40.22,16.13 41.21,16.13 41.28,16.06
  IN1 w0.064: v4(114.02,13.53) 114.08,13.47 114.08,7.96 113.34,7.22 110.8,7.22 109.45,8.57 108.86,8.57 108.67,8.76 107.21,8.76 105.68,7.23 105.68,6.15 105.86,5.98 105.86,5.26 105.64,5.04 103.89,5.04 103.35,4.5 96.02,4.5 v2(94.71,3.19) 94.41,2.89 91.86,2.89 91.74,3 89.2,3 89.11,3.09 87.25,3.09 87.14,2.99 85.36,2.99 85.14,2.77 82.61,2.77 v2(82.41,2.96) ; v7(37.98,15.2) 38.36,14.81 41.96,14.81 42.04,14.73 42.64,14.73 42.64,14.73 43.93,14.73 44.02,14.81 44.36,14.81 44.59,14.59 46.52,14.59 47.19,15.26 47.19,15.65 49.02,17.48 54.07,17.48 54.48,17.07 54.87,17.07 55.47,16.47 55.47,15.45 57.51,13.4 61.74,13.4 63.86,11.28 66.67,11.28 67.29,10.65 68.31,10.65 70.29,8.68 71.03,8.68 71.62,8.09 76.59,8.09 77.29,7.39 78.56,7.39 78.74,7.21 81.04,7.21 81.36,6.9 81.71,6.9 v2(81.83,7.02)
  GND2 w0.102: v5(113.95,13.86) 114.02,13.79 v4(114.02,13.53)
  GND3 w0.102: v5(113.95,13.86) 113.95,13.86 v6(113.57,13.48)
  BOTTOM w0.127: JIO1.G1 113.8,13.68 v6(113.57,13.48)
CAM_CBL_DET#: length 235
  TOP w0.127: v2(54.02,14.8) 53.91,14.91 53.91,15.93 54.32,16.34 54.32,17.9 54.41,17.99 54.41,20.52 v1(54.95,21.06) 54.95,21.64 54.1,22.49 54.1,23.72 53.02,24.8 v7(52.99,24.8) ; v9(146.58,105.83) 146.52,105.77 D72.1 145.61,105.34 145.61,91.03 145.47,90.89 91.41,90.89 91.21,91.09 91.21,96.09 v2(90.64,96.67)
  IN1 w0.064: v2(54.02,14.8) 53.45,14.8 52.92,15.33 v4(51.88,15.33) ; v2(90.64,96.67) 90.31,96.67 90.06,96.42 88.64,96.42 87.88,97.19 84.16,97.19 82.93,95.95 81.54,95.95 80.96,95.37 79.5,95.37 79.32,95.19 77.56,95.19 75.34,92.98 72.69,92.98 68.98,89.26 67.04,89.26 63.66,85.87 63.66,84.36 62.72,83.42 62.03,83.42 60.34,81.73 58.58,81.73 57.09,80.24 57.09,78.99 52.73,74.63 52.31,74.63 47.14,69.46 47.14,68.97 46.53,68.36 46.09,68.36 45.5,67.77 45.5,62.73 44.5,61.73 v4(44.5,61.69)
  GND2 w0.102: v4(51.88,15.33) 51.58,15.33 v5(51.41,15.5) ; v5(44.71,61.18) 44.71,61.18 44.5,61.4 v4(44.5,61.69) ; v5(52.15,24.53) 52.72,24.53 v7(52.99,24.8)
  IN2 w0.074: v5(44.71,61.18) 44.71,59.23 44.16,58.68 44.16,56.79 44.61,56.34 44.96,56.34 45.19,56.1 45.19,54.07 49.1,50.16 49.1,40.3 48.25,39.44 48.25,36.09 48.67,35.67 49.12,35.67 49.37,35.42 49.37,31.88 48.08,30.58 45.57,30.58 45.02,30.03 45.02,28.33 45.57,27.78 45.57,26.41 46.26,25.72 47.68,25.72 47.88,25.91 51.1,25.91 52.15,24.86 v5(52.15,24.53)
  GND3 w0.102: v6(44.68,60.72) 44.68,61.14 v5(44.71,61.18) ; v6(51.65,14.81) 51.41,15.06 v5(51.41,15.5)
  BOTTOM w0.076: UH4.U43 39.47,56.5 39.62,56.65 39.62,57.5 40.4,58.29 40.9,58.29 41.37,58.76
  BOTTOM w0.127: RE435.1 43.45,10.68 43.79,10.34 44.5,10.34 44.84,10.67 RE434.2 45.1,10.68 45.61,11.19 47.64,11.19 48.05,10.79 48.05,10.16 48.99,9.21 50.05,9.21 51.07,10.23 51.07,14.22 v6(51.65,14.81) ; v6(44.68,60.72) 44.11,61.3 44.01,61.3 44.01,61.3 43.77,61.3 43.21,60.75 43.21,60.37 42.96,60.11 RH91.1 42.52,59.9 41.37,58.76 ; JCAM1.6 145.29,104.55 v9(146.58,105.83)
CCG5_AR_RST#: length 40.2
  TOP w0.127: v1(36.36,92.03) 36.61,91.78 v7(36.61,91.05)
  GND2 w0.102: v7(37.69,65.4) 37.69,65.4 v5(37.34,65.74) ; v7(36.61,91.05) v5(36.61,90.44)
  IN2 w0.074: v5(37.34,65.74) 37.34,66.04 38.66,67.35 38.66,68.52 37.03,70.15 37.03,70.65 36.23,71.45 36.23,71.84 34.79,73.28 34.79,74.56 32.82,76.54 32.82,84.44 32.64,84.61 31.8,84.61 31.64,84.77 31.06,84.77 29.18,86.65 29.18,87.35 28.46,88.06 28.46,89.45 29.63,90.62 36.44,90.62 v5(36.61,90.44)
CCG5_HOTPLUG_DET_P1: length 31.7
  TOP w0.127: v7(33.61,70.03) 33.53,70.03 33.22,70.33 RP31.2
  IN1 w0.064: v2(37.27,86.51) 37.74,86.51 38.89,85.36 38.89,82.92 39.54,82.28 39.54,81.76 39.68,81.62 39.68,79.79 39.41,79.52 39.41,79.16 39.26,79.01 38.2,79.01 38.17,78.98 34.99,78.98 33.48,77.46 33.48,75.99 34.38,75.09 37.04,75.09 37.65,74.48 37.67,74.48 37.84,74.31 38.26,74.31 38.58,73.99 38.58,73.75 38.32,73.49 38.32,72.36 37.65,71.68 36.34,71.68 35.09,70.44 34.02,70.44 v7(33.61,70.03)
  GND2 w0.102: v5(33.44,70.37) 33.61,70.11 v7(33.61,70.03)
  GND3 w0.102: v5(33.44,70.37) 33.68,70.13 v6(33.68,70.03)
CCG5_HOTPLUG_DET_P1_R: length 1.4
  TOP w0.127: v7(37.86,85.93) RT418.1
  GND2 w0.102: v7(37.86,85.93) v5(37.86,85.5)
  GND3 w0.102: v6(37.85,85.12) 37.86,85.12 v5(37.86,85.5)
CCG5_HOTPLUG_DET_P2: length 42.6
  IN2 w0.074: v5(36.93,68.76) 36.88,68.81 36.88,70.59 36.08,71.38 36.08,71.78 34.64,73.22 34.64,74.5 32.67,76.48 32.67,83.53 32.5,83.7 31.47,83.7 30.9,84.26 30.9,84.71 29.03,86.59 29.03,87.29 28.31,88 28.31,89.54 29.53,90.77 35.83,90.77 35.96,90.89 38.17,90.89 v5(38.46,90.59)
  GND3 w0.102: v5(38.46,90.59) v8(38.76,90.89) ; v6(37.09,68.46) 37.01,68.72 v5(36.93,68.76)
  IN3 w0.064: v8(38.76,90.89) 38.71,90.84 v3(38.71,88.51)
  BOTTOM w0.076: UPD1.E10 35.43,67.77 35.89,67.77 36.29,68.18
  BOTTOM w0.127: 36.29,68.18 36.39,68.28 36.92,68.28 v6(37.09,68.46) 37.09,68.42 37.45,68.07 RP73.2
CCG5_HOTPLUG_DET_P2_R: length 4.6
  BOTTOM w0.076: RT419.2 RT39.2 38.13,87.39 37.69,86.95 36.24,86.95 35.78,86.49 35.78,86.05 UT2.G2
CCG5_I2C_INT1#: length 101.9
  TOP w0.127: RE108.1 52.64,15.96 52.61,15.96 51.29,14.64 v2(51.29,14.64) ; UE3.F10 47.95,13.62 48.22,13.89 48.22,13.89 v7(48.27,13.95)
  IN1 w0.064: v2(51.29,14.64) 50.38,14.64 49.68,13.93 48.29,13.93 48.28,13.95 v7(48.27,13.95) ; v4(26.18,32.85) 24.18,34.85 24.18,36.26 23.81,36.64 23.81,44.3 24.34,44.83 24.34,50.72 27.42,53.8 27.42,54.96 27.9,55.44 27.9,56.92 30.01,59.03 32.28,59.03 33.11,59.86 36.1,59.86 37.29,61.05 38.23,61.05 39.68,62.5 39.68,64.27 41.49,66.07 41.49,69.75 v4(41.63,69.89)
  GND2 w0.102: v4(26.18,32.85) 26.31,32.85 v5(26.54,32.62) ; v7(48.27,13.95) 48.28,13.95 48.43,14.1 48.43,14.1 v5(48.51,14.18) ; v4(41.63,69.89) 41.63,70.08 v5(41.75,70.2)
  GND3 w0.102: v5(41.75,70.2) 41.45,70.2 v6(41.32,70.32) ; v5(48.51,14.18) 48.41,14.18 48.31,14.28 v8(47.98,14.28) ; v5(26.54,32.62) 26.56,32.64 26.74,32.64 v8(27.02,32.92)
  IN3 w0.064: v8(47.98,14.28) 47.74,14.28 46.63,15.38 46.63,15.76 45.89,16.5 37.27,16.5 34.31,19.46 34.31,21.08 33.75,21.64 33.75,27.1 32.79,28.07 32.79,29.29 29.16,32.92 v8(27.02,32.92)
  BOTTOM w0.076: UPD1.L5 32.68,70.7 32.8,70.82 33.31,70.82 33.44,70.69 33.44,70.38 33.53,70.29 33.84,70.29 33.94,70.39 33.94,70.7 34.03,70.8
  BOTTOM w0.127: 34.03,70.8 34.35,71.11 37.35,71.11 37.49,71.25 40.4,71.25 v6(41.32,70.32)
CCG5_I2C_INT2#: length 83.8
  TOP w0.127: v7(43.53,13.97) 43.95,13.54 UE3.F5 ; v2(35.87,14.56) RE109.1
  IN1 w0.064: v2(35.87,14.56) 36.83,14.56 37.23,14.16 41.21,14.16 41.58,13.79 43.35,13.79 v7(43.53,13.97) 43.65,14.09 46.41,14.09 47.52,15.2 47.73,15.2 48.42,15.89 49.22,15.89 49.64,16.31 51.13,16.31 51.55,16.73 52.93,16.73 57.2,12.46 60.02,12.46 62.31,10.17 65.1,10.17 65.71,9.56 68.05,9.56 69.94,7.67 76.42,7.67 77.12,6.97 78.35,6.97 78.53,6.79 80.77,6.79 81.14,6.42 82.95,6.42 83.24,6.71 84.47,6.71 84.83,6.35 87.02,6.35 87.56,5.8 90.84,5.8 91.42,6.39 93.93,6.39 94.12,6.2 97.72,6.2 97.91,6.39 98.14,6.39 98.36,6.61 102.87,6.61 103.41,7.15 103.41,7.96 103.6,8.15 104.14,8.15 106.61,10.61 107.46,10.61 107.53,10.69 v4(107.73,10.69)
  GND2 w0.102: v5(107.43,10.42) 107.69,10.69 v4(107.73,10.69)
  GND3 w0.102: v6(108.11,10) 107.85,10 v5(107.43,10.42)
  BOTTOM w0.127: v6(108.11,10) 108.06,9.95 JIO1.M7
