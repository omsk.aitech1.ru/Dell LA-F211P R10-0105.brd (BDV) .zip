# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N133320966: length 20.8
  TOP w0.127: PQ117.1 v1(26.29,90.02)
  TOP w0.254: v7(26.29,92.22) PQ117.1 24.89,91.43 PR138.2 PC125.2
  GND2 w0.254: v7(29.92,99.23) 30.26,99.23 v5(30.58,98.91) ; v5(25.69,92.19) 25.72,92.22 v7(26.29,92.22)
  GND3 w0.254: v5(25.69,92.19) 25.41,91.92 v6(25.23,91.92) ; v5(30.58,98.91) 30.31,98.65 v8(30.16,98.65)
  IN3 w0.254: v6(25.23,91.92) 26.43,91.92 27.02,92.51 27.44,92.51 28.04,93.11 30.31,93.11 31.56,94.35 31.56,97.25 v8(30.16,98.65)
  BOTTOM w0.254: v6(25.23,91.92) 24.9,92.25 PQ114.4
N133321002: length 25.5
  TOP w0.254: v2(43.02,100.98) 43.21,101.17 43.85,101.17 44.18,101.5 PR276.2 ; PQ139.5 34.58,95.98 PR151.2 34.05,96.51 PR155.1 34.05,97.45 33.75,97.75 33.21,97.75 32.55,97.08 32.55,95.37 31.5,94.32 v2(31.4,94.32)
  IN1 w0.254: v2(31.4,94.32) 32.63,94.32 33.01,93.94 35.09,93.94 35.55,94.4 38.61,94.4 39.91,95.7 39.91,98.08 40.17,98.33 40.17,98.34 42.81,100.98 v2(43.02,100.98)
N133321875: length 9.6
  TOP w0.203: PC100.2 20.14,75.67 PR101.2 20.68,75.88 21.11,76.31 PR104.1 21.5,76.89 v7(21.04,77.35)
  IN1 w0.203: v4(17.62,75.27) 17.87,75.27 19.95,77.35 v7(21.04,77.35)
  GND2 w0.254: v4(17.62,75.27) v5(17.62,75.69)
  GND3 w0.254: v6(18.12,75.69) v5(17.62,75.69)
  BOTTOM w0.254: v6(18.12,75.69) 18.39,75.69 18.59,75.48 PQ100.4
N133321877: length 3.5
  TOP w0.254: PQ143.2 21.98,72.47 21.99,72.47 PR110.2 21.56,71.84 21.37,72.03 20.55,72.03 20.42,71.9 PQ216.5
N133362817: length 20.7
  TOP w0.127: v1(28.42,91.84) 29.16,92.58 PR182.1
  TOP w0.254: PR167.1 PR169.2 30.97,91.37 30.55,91.79 PD103.1 30.16,92.16 v2(29.74,92.58) PR182.1 29.09,92.76 PU100.3 28.71,93.61 PC141.1
  IN1 w0.254: v4(39.06,97.77) 39.06,96.75 37.26,94.95 30.98,94.95 29.74,93.71 v2(29.74,92.58)
  GND2 w0.254: v4(39.06,97.77) 39.06,97.95 v5(39.24,98.13)
  GND3 w0.254: v5(39.24,98.13) 39.43,98.32 v6(39.72,98.32)
N133362852: length 3.2
  BOTTOM w0.203: PR157.1 PR152.2 33.92,101.95 PR159.1 33.18,102.13 33.17,102.11 PQ146.6
N133362857: length 3.4
  TOP w0.127: PR166.2 28.66,97.06 v1(28.99,96.73)
  TOP w0.254: PU100.1 28.66,95.51 PR183.1 PR166.2
N133362865: length 4.1
  BOTTOM w0.127: v1(35.47,106.7) 35.29,106.52 PQ147.6
  BOTTOM w0.203: PQ147.6 35.29,105.22 35.91,104.6 35.91,103.43 PR160.1
N133362867: length 14.7
  TOP w0.203: v2(35.56,105.57) PR171.2 PR184.1 34.3,105.59 PC140.1 PR173.1 33.97,106.64 PD102.1 32.82,105.91 32.89,105.84 PU101.3
  IN1 w0.203: v2(35.56,105.57) 35.68,105.69 36.61,105.69 38.3,104 38.3,101.25 37.44,100.39 v4(37.44,98.81)
  GND2 w0.203: v5(37.44,98.48) v4(37.44,98.81)
  GND3 w0.203: v6(37.12,98.32) 37.27,98.32 v5(37.44,98.48)
N133362892: length 3.5
  TOP w0.127: PR172.2 PR185.1 35.02,103 34.59,102.56 33.73,102.56 PU101.1
N133362902: length 11.5
  TOP w0.203: PR233.2 34.85,107.05 PR173.2 33.89,107.3 31.49,107.3 31.12,106.93 PD102.2 31.12,105.49 30.93,105.3 PU101.4 30.29,106.45 v1(30.14,106.6) 29.62,106.6 PC136.1 29.09,106.11 28.33,105.35 PR174.1
N133362952: length 12.5
  TOP w0.127: v2(39.34,104.63) 38.81,105.16 37.76,105.16 36.6,103.99 36.6,102.78 36.4,102.58 35.17,102.58 34.96,102.37 34.96,100.73 35.52,100.17 PQ149.6 ; v2(41.5,104.73) 41.5,105.1 41.41,105.19 PR162.1
  IN1 w0.064: v2(41.5,104.73) 41.4,104.63 v2(39.34,104.63)
N133362963: length 5.2
  BOTTOM w0.127: PQ150.3 31.86,106.19 31.99,106.06 32.23,106.06 v1(32.93,106.76)
  BOTTOM w0.203: PR179.1 29.67,106.51 PQ150.1 30.56,107 30.9,107.33 31.53,107.33 31.86,107 PQ150.3
N133362990: length 7.6
  TOP w0.127: v1(33.12,91.2) PR167.2
  TOP w0.254: PC138.1 32,94.35 31.69,94.04 PU100.4 31.69,92.72 PD103.2 32.25,91.22 PR167.2 ; PC138.1 32.95,94.9 33.17,95.12 PR234.2 ; PC138.1 PR168.1
N133363065: length 5.2
  TOP w0.127: v1(27.66,90.76) 26.94,91.48 PQ117.2
  TOP w0.254: PR141.1 27.62,93.22 27.43,93.03 PQ117.2 26.26,93.71 PR133.2
N133363071: length 3.1
  TOP w0.127: PR145.2 38.11,95.61 v1(38.2,95.52)
  TOP w0.254: PQ139.2 37.79,95.98 PR145.2 37.88,96.3 37.55,96.63 PQ139.3
N133363075: length 14.2
  TOP w0.254: PR141.2 28.04,91.65 29.31,90.38 33.31,90.38 33.7,90.77 33.7,91.98 34.13,92.41 35.12,92.41 35.98,93.26 v1(35.98,93.62) 35.98,93.98 35.02,94.93 35.02,95.15 35.2,95.33 PQ139.6
N133363089: length 3.8
  TOP w0.127: PQ154.5 29.76,97.55 29.24,98.07 29.24,99.59 29.64,99.98 PR147.2 PR143.1
N133363108: length 3.7
  TOP w0.127: PQ116.2 19.23,102.42 18.53,102.42 17.67,101.56 PR142.1 PR132.2
N133363166: length 4.9
  TOP w0.203: v2(20.72,74.25) 20.72,73.81 20.3,73.39 PR105.2 PR114.1
  IN1 w0.203: v2(22.88,76.24) 22.57,75.94 22.41,75.94 v2(20.72,74.25)
N133363167: length 3.3
  TOP w0.254: PQ136.2 28.39,71.28 28.24,71.43 28.24,71.74 28.43,71.93 PQ136.3 29.12,71.93 29.24,72.06 29.24,72.22 29.08,72.38 28.81,72.38 28.51,72.68 PR116.2
N133363171: length 5.6
  TOP w0.127: PR113.1 26.03,69.14 v1(26.51,68.66)
  TOP w0.203: PR106.2 25.49,73.25 26.03,72.7 26.03,72.7 26.39,72.35 26.44,72.29 26.44,71.5 PQ106.2 25.73,69.92 PR113.1
N133363182: length 2.5
  TOP w0.203: PQ155.5 29.98,75.58 30.18,75.38 PR119.1 30.18,74.33 PR121.2
N133363184: length 16.5
  TOP w0.203: v2(24.13,71.44) 24.13,72.05 23.96,72.22 23.96,72.71 23.87,72.8 PC112.2 PR109.2 PR112.1
  IN1 w0.064: v2(24.13,71.44) 25.12,70.45 25.12,68.73 22.28,65.89 18.87,65.89 v4(18.64,65.66)
  GND2 w0.102: v4(18.64,65.66) 18.44,65.66 v5(18.31,65.79)
  GND3 w0.102: v5(18.31,65.79) 18.16,65.64 v6(17.61,65.64)
  BOTTOM w0.127: PQ103.4 v6(17.61,65.64)
N133363191: length 23.8
  TOP w0.203: PR118.1 27.7,77.29 26.35,77.29 PC111.2 ; PR108.2 PC111.2 ; PC111.2 26.34,77.67 26.03,77.97 23.66,77.97 v2(23.53,77.84)
  IN1 w0.203: v4(13.82,71.88) 15.27,73.34 16.74,73.34 19.57,76.17 21.08,76.17 22.75,77.84 v2(23.53,77.84)
  GND2 w0.254: v5(13.82,71.42) v4(13.82,71.88)
  GND3 w0.254: v8(13.82,71.06) v5(13.82,71.42)
  IN3 w0.254: v8(13.82,71.06) 13.82,70.52 15.05,69.3 v3(15.67,69.3)
  BOTTOM w0.127: v3(15.67,69.3) v1(17.18,69.3)
  BOTTOM w0.254: v3(15.67,69.3) PQ102.4
N133363327: length 3.4
  TOP w0.254: PR202.1 42.01,103.48 PQ152.1 42.01,104.87 42.29,105.15 42.95,105.15 43.31,104.79 PQ152.3
N133363328: length 1.7
  TOP w0.254: PQ152.6 42.01,106.57 41.71,106.87 PR192.1
N133363339: length 7.5
  TOP w0.254: v7(34.54,97.82) 34.17,98.19 33.05,98.19 32.53,98.71 32.53,99.93 32.22,100.25 PR203.1
  GND2 w0.254: v7(34.54,97.82) 34.95,97.82 v5(34.97,97.8)
  GND3 w0.254: v6(35.21,98.11) 35.21,98.03 v5(34.97,97.8)
  BOTTOM w0.203: PQ153.1 34.72,99.41 34.45,99.14 34.45,98.38 34.72,98.11 v6(35.21,98.11)
N133363347: length 2.5
  IN1 w0.203: v2(34.52,101.22) 34.52,100.6 v4(33.66,99.75)
  GND2 w0.203: v5(33.31,99.76) 33.65,99.76 v4(33.66,99.75)
  GND3 w0.203: v6(33.31,99.41) v5(33.31,99.76)
N133363373: length 1.9
  TOP w0.203: PQ101.2 19.14,77.7 PR102.1 PR100.2
N133567403: length 41.7
  TOP w0.254: PR522.1 163.93,13.77 v9(163.85,13.85)
  IN3 w0.254: v3(141.04,5.92) 141.2,5.77 144.7,5.77 145.44,5.04 147.63,5.04 149.84,2.83 155.93,2.83 156.05,2.95 161.11,2.95 162.21,1.85 165.71,1.85 166.82,2.96 166.82,5.61 166.15,6.28 166.15,11.39 163.85,13.68 v9(163.85,13.85)
  BOTTOM w0.127: v9(163.85,13.85) 163.85,14.06 v1(163.36,14.56)
N134295234: length 6.2
  TOP w0.127: v16(52.75,91.4) 52.75,91.72 53.57,92.54 53.57,93.14 53.33,93.38 RR40.2 RR38.2 52.58,94.01 v7(52.61,94.04) 52.61,94.74 CV248.1
  GND2 w0.102: v5(53.01,94.82) 53.01,94.43 v7(52.61,94.04)
  GND3 w0.102: v6(52.91,94.24) 52.91,94.73 53,94.82 v5(53.01,94.82)
N134421677: length 2
  TOP w0.127: v7(58.33,93.6) v1(58.33,92.54)
  GND2 w0.102: v5(58.26,94.11) 58.33,94.05 v7(58.33,93.6)
  GND3 w0.102: v6(57.91,94.24) 58.14,94.24 v5(58.26,94.11)
N134515266: length 2.6
  TOP w0.127: v1(36.17,63.9) 35.37,64.69 CP6.2
  GND2 w0.305: v5(35.42,65.73) 35.32,65.66 v7(35.32,65.36)
  GND3 w0.305: v6(35.18,66.03) 35.18,65.97 v5(35.42,65.73)
N134825470: length 12.4
  TOP w0.127: PR233.1 35.84,106.28 v2(35.91,106.36)
  IN1 w0.064: v2(35.91,106.36) 36.03,106.24 36.75,106.24 38.39,104.6 38.9,104.6 39.28,104.98 41.25,104.98 v4(41.5,105.24)
  GND2 w0.102: v4(41.5,105.24) v5(41.5,105.59)
  GND3 w0.102: v5(41.5,105.59) 41.61,105.48 v6(41.88,105.48)
  BOTTOM w0.127: PD107.1 41.88,102.19 v1(42.45,101.62)
  BOTTOM w0.203: v6(41.88,105.48) PD107.1
N134826142: length 15.5
  IN1 w0.203: v2(34.08,95.59) 34.31,95.36 37.13,95.36 38.44,96.67 38.44,98.29 38.96,98.81 38.96,101.69 v4(38.67,101.99)
  GND2 w0.254: v5(38.67,102.42) v4(38.67,101.99)
  GND3 w0.254: v5(38.67,102.42) 38.58,102.51 v6(38.58,102.88)
  IN3 w0.254: v6(38.58,102.88) v3(38.58,105.48)
  BOTTOM w0.127: v1(38.96,104.03) 38.58,103.65 v6(38.58,102.88)
N134840260: length 2
  BOTTOM w0.127: PR242.2 v1(40.55,94.25)
  BOTTOM w0.203: PR242.2 39.63,94.42 39.99,94.78 PQ202.2
N134840264: length 2.6
  TOP w0.127: PQ203.2 47.44,98.41 v1(47.79,98.06)
  TOP w0.254: PR239.2 46.49,99.03 PQ203.2
N134840348: length 4.2
  TOP w0.127: PQ205.2 47.46,100.3 v1(47.98,99.78)
  TOP w0.254: PR237.2 44.37,100.75 44.83,100.3 PQ205.2
N134840369: length 2.3
  TOP w0.254: PR238.2 43.46,100.75 43.2,100.5 43.2,99.67 43.68,99.19 PQ204.2
N134840540: length 1.9
  BOTTOM w0.127: v1(38.2,94.13) 37.47,94.13 PR241.2
  BOTTOM w0.203: PQ201.2 37.45,94.71 37.35,94.61 PR241.2
N134860679: length 2.9
  TOP w0.203: PR122.2 28.7,74 PR170.1 28.04,74.03 28.04,75.33 27.78,75.58 PQ155.2
N134862674: length 4.1
  TOP w0.254: PQ154.2 32.48,97.55 v1(32.74,97.81) 32.74,97.96 31.53,99.17 PR175.1 PR125.2
N134862705: length 5.2
  TOP w0.254: PQ154.6 29.7,96.9 28.62,97.99 v1(28.13,97.99) 28.11,98 26.63,98 PR144.2
N134867729: length 8
  TOP w0.127: v1(171.17,3.45) 170.81,3.09 169.68,3.09 169.49,3.28 PR539.1
  TOP w0.203: PR539.1 169.49,3.59 PR540.2 168.68,4.4 167.71,4.4 PC546.1 166.7,3.9 165.77,4.84 165.77,5.48 165.65,5.6 PU501.25
N134888832: length 1.8
  BOTTOM w0.127: PR240.2 v1(34.07,94.25)
  BOTTOM w0.203: PQ200.2 34.91,94.26 PR240.2
N136079318: length 9.5
  TOP w0.203: PR1833.1 53.26,45.27 53.26,44.6 PC1807.2 52.68,43.15 PR1830.2 52.74,43.19 PR1827.1 53.74,43.17 PC1809.1 53.74,41.56 54.48,40.82 54.48,40.54 v1(54.92,40.11) 55.25,39.77 55.53,39.77 55.86,39.44 PU1800.48
N136079319: length 4.8
  TOP w0.203: PU1800.47 56.26,39.55 54.66,41.15 v1(54.66,41.36) PC1809.2 54.64,42.32 PC1808.2
N136079320: length 5.8
  TOP w0.203: PU1800.11 52.45,34.33 v1(52.12,34) 52.12,33.11 PC1800.1 51.85,32.61 51.15,31.91 51.15,30.92 51.3,30.77 PR1802.2
N136079322: length 8.8
  TOP w0.203: PR1867.1 62.65,27.13 62.32,27.46 PR1869.2 61.77,27.51 PC1827.2 PC1826.2 61.09,29.9 61.01,29.9 60.18,30.73 59.63,30.73 59.38,30.98 59.3,30.98 v1(59,31.29) 59,31.74 58.26,32.47 PU1800.24
N136079323: length 5.1
  TOP w0.203: PR1817.1 62.99,35.58 PR1818.2 62.94,35.63 PC1803.2 62.87,36.45 PC1805.2 61.93,36.33 PU1800.34
N136079324: length 5.8
  TOP w0.203: PU1800.5 52.12,36.73 52.1,36.75 v1(52.1,36.79) PC1804.2 51.01,36.65 50.49,36.12 49.02,36.12 48.69,36.45 PR1820.2
N136079325: length 6.9
  TOP w0.203: PR1826.1 51.79,43.15 PR1830.1 51.77,42.25 v1(51.72,42.19) 51.98,41.93 52.87,41.93 54.2,40.6 54.2,40.22 55.06,39.36 PU1800.50
N136079327: length 6.5
  TOP w0.203: PU1800.13 53.58,33.02 53.21,32.64 v1(53.21,31.71) 53.21,30.85 53.15,30.79 PC1801.2 53.15,29.9 53.97,29.07 53.97,28.14 PR1803.2
N136079328: length 6.3
  TOP w0.203: PR1838.2 PC1811.2 ; PC1811.2 PR1836.2 PR1834.1 ; PC1811.2 61.52,40.93 60.87,40.28 v1(60.87,40.09) 60.87,39.77 60.23,39.13 60.23,38.5 60.07,38.33 PU1800.39
N136079329: length 47.3
  TOP w0.127: v1(54.58,46.31) 54.58,45.93 55.91,44.6 PC1816.1
  TOP w0.203: PC1816.1 55.93,44.53 PR1843.1 56.79,43.74 PR1851.2 ; PU1800.44 57.46,40.45 56.93,40.98 PR1848.2 PR1853.1 57.18,42.35 57.18,43.15 PR1851.2 ; PR1851.2 57.68,43.64 v2(57.69,43.66)
  IN1 w0.254: v2(57.69,43.66) 59.94,45.9 60.7,45.9 62.23,47.43 69.11,47.43 70.72,49.04 75.88,49.04 76.68,48.24 91.07,48.24 v9(91.14,48.16)
  BOTTOM w0.254: PH1800.1 v9(91.14,48.16)
N136079332: length 7.4
  TOP w0.127: v1(49.88,29.61) 50.21,29.94 PR1880.2
  TOP w0.203: PR1880.2 PR1813.2 PC1802.2 50.21,32.24 50.69,32.72 50.69,33.1 52.33,34.73 PU1800.10
N136079336: length 7.1
  TOP w0.127: v1(65.06,41) 64.7,40.65 64.35,40.65 63.8,40.09 PR1821.1
  TOP w0.203: PR1821.1 62.79,40.09 PC1806.2 PR1822.2 61.56,40.09 60.51,38.99 60.51,38.22 60.23,37.93 PU1800.38
N136079340: length 3.3
  TOP w0.127: PR1826.2 51.67,44.93 51.34,45.26 51.34,46.14 v1(52.02,46.82)
  TOP w0.203: PC1807.1 PR1826.2
N136079349: length 2.3
  TOP w0.127: v1(53.63,45.42) 53.63,44.23 PR1827.2
  TOP w0.203: PC1808.1 PR1827.2
N136079350: length 19.2
  TOP w0.203: v9(65.16,41.47) 64.6,41.47 64.08,41.99 64.08,43.84 63.51,44.41 62.91,44.41 62.38,43.87 PR1858.2 61.38,42.82 v1(60.97,43.22) 60.05,42.31 60.05,41.29 PC1819.2 59.74,40.8 58.66,39.72 PU1800.41
  BOTTOM w0.254: PR1854.2 63.32,36.61 PR1857.2 63.32,39.88 PR1855.2 63.34,40.37 63.76,40.79 64.47,40.79 v9(65.16,41.47)
N136079351: length 9.6
  TOP w0.203: PU1800.51 54.66,39.36 53.48,40.53 v1(53.48,40.64) 52.89,41.23 52.71,41.23 PC1812.2 52,41.4 50.96,42.44 50.96,43.26 PC1813.2 51.1,44.42 51.1,45.84 PR1840.2
N136079355: length 56.8
  TOP w0.203: 60.45,27.26 60.12,27.59 PR1875.2 59.22,28.45 PR1876.1 59.23,28.49 58.75,28.97 57.98,28.97 57.95,29.01 57.89,29.01 57.77,29.13 57.77,30.72 57.88,30.84 57.88,31.12 PR1871.2 58.09,31.57 57.46,32.19 PU1800.22 ; 60.45,27.26 60.65,27.46 PR1868.1 60.93,27.9 60.85,27.97 PC1827.1 PC1826.1 ; 60.45,27.26 60.45,26.21 61.37,25.29 v1(62.07,25.29) 62.26,25.1 65.1,25.1 65.52,25.52 65.52,26.58 65.86,26.92 65.86,28.67 v7(65.69,28.83)
  GND2 w0.254: v7(65.69,28.83) 65.82,28.95 v5(65.82,29.13)
  IN2 w0.254: v5(62.86,50.83) 62.27,50.83 61.41,49.97 61.41,43.26 62.46,42.22 62.46,32.79 64.08,31.17 64.23,31.17 65.82,29.58 v5(65.82,29.13)
  GND3 w0.254: v6(62.96,50.48) 62.86,50.58 v5(62.86,50.83)
  BOTTOM w0.203: v6(62.96,50.48) 62.66,50.78 62.66,53.55 63.7,54.59 68.47,54.59 69.3,55.42 PH1801.1
N136079371: length 6.5
  TOP w0.127: v1(48.17,32.78) 48.29,32.66 49.82,32.66 50.21,33.05 PR1823.2
  TOP w0.203: PU1800.9 52.32,35.13 50.29,33.1 PR1823.2
N136079373: length 4.1
  TOP w0.203: PR1856.2 50.59,34.25 50.96,34.25 v1(52.18,35.46) 52.25,35.53 PU1800.8
N136079381: length 10.1
  TOP w0.203: PR1842.2 49.76,45.98 49.76,44.47 PC1814.2 49.69,43.14 49.89,43.14 v1(50.46,42.57) 50.46,42.43 52.41,40.48 PC1812.1 52.76,40.26 53.32,40.26 54.26,39.33 PU1800.52
N136079383: length 5
  TOP w0.203: PR1824.2 62.79,39.2 PC1806.1 PR1822.1 61.27,39.19 v1(60.87,38.78) 60.87,38.06 60.35,37.53 PU1800.37
N136079389: length 4.6
  TOP w0.203: PU1800.33 v1(60.87,35.93) 61.65,35.93 PC1805.1 62.11,35.54 PR1818.1 63.83,34.68 PR1819.2
N136079393: length 11
  TOP w0.203: PC1822.1 v1(56.41,25.93) 56.22,25.74 54.84,25.74 54.71,25.86 54.71,26.36 54.5,26.56 PR1860.1 54.92,27.5 54.95,27.5 PR1864.1 55.19,28.2 55.19,29.19 PC1820.2 55.04,30.33 PR1862.2 55.04,30.87 55.19,31.02 55.19,31.83 55.06,31.96 PU1800.16
N136079397: length 44.5
  TOP w0.203: v7(65.31,28.83) 65.36,28.78 65.36,28.69 65.56,28.5 65.58,28.5 65.58,27.07 65.24,26.73 65.24,25.63 64.98,25.38 63.8,25.38 v1(63.53,25.65) 63.12,25.65 62.21,26.55 PR1869.1 PR1868.2
  GND2 w0.254: v7(65.31,28.83) v5(65.31,29.17)
  IN2 w0.254: v5(65.31,29.17) 65.31,29.58 64.08,30.82 63.93,30.82 62.12,32.62 62.12,42.08 61.06,43.15 61.06,50.12 62.35,51.42 v5(62.61,51.42)
  GND3 w0.254: v6(63.01,51.34) 62.68,51.34 v5(62.61,51.42)
  BOTTOM w0.254: v6(63.01,51.34) 62.96,51.39 62.96,53.42 63.83,54.29 69.39,54.29 70.21,55.11 PH1801.2
N136079415: length 20.2
  TOP w0.203: v2(57.69,42.74) 57.69,41.12 57.86,40.95 PU1800.43 ; v2(60.92,44.77) 61.01,44.68 63.94,44.68 64.11,44.85 PR1841.1 64.47,44.83 64.47,44.23 64.93,43.77 PR1845.1 64.94,43.63 64.94,42.45 PR1847.1
  TOP w0.254: v2(60.92,44.77) 60.91,44.79 60.04,44.79 v1(59.22,45.61) 58.88,45.95 57.32,45.95 PR1844.2 55.93,45.42 PC1816.2
  IN1 w0.254: v2(60.92,44.77) 60.92,44.21 59.45,42.74 v2(57.69,42.74)
N136079430: length 3.5
  TOP w0.203: PR1878.2 50.92,34.75 52.1,35.93 PU1800.7
N136079431: length 3.3
  TOP w0.203: PU1800.6 51.84,36.33 51.09,35.58 PR1877.2
N136079436: length 6.4
  TOP w0.203: PR1863.2 63.47,29.1 62.59,29.98 PC1823.2 61.73,31.04 PC1824.2 60.94,31.04 v1(60.16,31.83) 59.81,31.83 59.06,32.58 PU1800.26
N136079438: length 7.7
  TOP w0.203: PU1800.25 58.66,32.5 59.37,31.79 59.37,31.38 59.75,31.01 60.3,31.01 61.13,30.18 PC1823.1 62.33,29.53 62.33,28.97 v1(62.74,28.56) 63.09,28.21 PR1866.1
N136079473: length 9.9
  TOP w0.127: PR1879.2 52.74,27.27 52.74,26.43 v1(52.1,25.8)
  TOP w0.203: PU1800.12 53.13,33.93 52.75,33.56 52.75,31.21 52.47,30.92 52.17,30.92 51.96,30.71 51.96,29.74 52.22,29.49 52.22,28.1 52.17,28.05 PR1879.2
N136079494: length 3.7
  TOP w0.203: PR1870.2 54.21,30.12 PC1825.2 54.21,30.63 54.89,31.3 54.89,31.71 54.66,31.93 PU1800.15
N136079497: length 9
  TOP w0.127: PC1822.2 57.32,24.69 v1(57.25,24.61)
  TOP w0.203: PU1800.19 56.26,32.49 55.95,32.19 55.95,31.4 56.41,30.94 56.41,30.67 57.07,30.01 57.07,28.03 PC1821.2 57.32,27.78 PC1822.2
N136079500: length 3.6
  TOP w0.203: PR1859.1 56.57,29.94 PR1862.1 55.55,30.97 v1(55.55,31.64) 55.55,32.26 55.46,32.35 PU1800.17
N136079512: length 2.3
  TOP w0.127: v1(55.15,26.12) 55.42,26.38 PR1860.2
  TOP w0.203: PR1860.2 56.24,27.91 PC1821.1
N136079514: length 0.9
  TOP w0.203: PR1859.2 PC1820.1
N136079517: length 3.9
  TOP w0.203: PR1850.1 PC1817.2 58.26,41.56 v1(58.26,40.09) PU1800.42
N136079518: length 4.9
  TOP w0.127: PR1872.1 59.97,30.38 v1(60.17,30.18)
  TOP w0.203: PU1800.23 57.86,32.44 58.54,31.76 58.54,30.89 58.26,30.61 PC1828.2 PR1872.1
N136079531: length 11.4
  TOP w0.203: PU1800.40 59.06,39.55 v1(59.53,40.02) 60.04,40.02 60.6,40.58 PC1811.1 v2(60.6,41.93) ; v2(62.18,45.12) 62.33,44.96 63.46,44.96 63.73,45.23 PR1839.1
  TOP w0.254: PR1837.2 62.91,46.28 PR1839.1
  IN1 w0.203: v2(60.6,41.93) 60.6,42.6 62.18,44.18 v2(62.18,45.12)
N136079564: length 38.9
  TOP w0.203: PR1844.1 PR1843.2
  TOP w0.254: PR1843.2 58.34,43.9 v1(59.28,43.9) 59.79,43.9 v2(60.07,44.18)
  IN1 w0.254: v9(91.79,48.15) 91.29,47.65 90.89,47.65 90.69,47.86 76.59,47.86 75.74,48.71 70.87,48.71 69.15,47 62.38,47 60.07,44.68 v2(60.07,44.18)
  BOTTOM w0.254: v9(91.79,48.15) 92.06,48.42 PH1800.2
N136079606: length 4.2
  TOP w0.203: PR1831.2 63.64,37.41 PR1829.1 PC1810.1 61.21,36.73 PU1800.35
N136079607: length 4.4
  TOP w0.203: PU1800.36 60.52,37.13 v1(60.87,37.48) 61.71,38.32 PC1810.2 PR1829.2 63.64,38.32 PR1828.1
N136081679: length 2.8
  TOP w0.127: PR1902.1 v1(90.36,40.38)
  TOP w0.508: PC1909.2 88.92,40.37 PR1902.1
N136082763: length 2.3
  TOP w0.127: v1(77.82,41.61) PC2009.2
  TOP w0.508: PC2009.2 77.83,40.68 PR2002.1
N136142149: length 6.5
  TOP w0.127: v1(34.68,72.22) 33.78,72.22 PQ199.1
  TOP w0.203: PQ199.1 33.27,72.45 32.19,73.53 PR246.1 32.17,74.01 31.58,74.01 31.45,73.88 29.54,73.88 29.36,74.06 PR122.1
N136143941: length 4.2
  TOP w0.127: v1(30.26,70.57) 31.34,70.57 31.66,70.89 31.66,71.78 PQ199.3
  TOP w0.203: PR248.1 PR247.2 30.99,71.52 31.27,71.8 PQ199.3
N136149398: length 9.3
  TOP w0.127: PR254.1 31.56,101.86 v2(31.57,101.87)
  TOP w0.203: PR125.1 31.53,101.47 PR254.1
  TOP w0.254: PQ213.1 37.44,103.9 37.18,103.64 v1(37.18,102.38) 36.93,102.38 36.48,101.94 v2(35.47,101.94)
  IN1 w0.064: v2(31.57,101.87) 31.68,101.99 35.42,101.99 v2(35.47,101.94)
N136149487: length 3.5
  TOP w0.127: PR257.1 36.83,106.74 v1(36.29,107.27)
  TOP w0.203: PR257.1 37.55,106.66 PQ213.3 37.42,105.67 PR255.2
N136513978: length 5.2
  IN1 w0.064: v4(154.16,7.17) 153.34,7.17 v2(153.32,7.16)
  GND2 w0.102: v5(154.49,7.17) v4(154.16,7.17)
  GND3 w0.102: v6(155,7.17) v5(154.49,7.17)
  BOTTOM w0.127: v6(155,7.17) 155,7.67 155.28,7.94 155.81,7.94 156.16,7.59 R5837.2 156.16,7.23 156.24,7.15 156.24,6.94 156.41,6.77 JFP1.2
N136517178: length 3.5
  BOTTOM w0.127: v1(88.06,20.67) RD20.1 88.76,22.37 JNGFF2.60
N136517525: length 4.4
  TOP w0.127: RD58.2 v7(96.49,23.5) v1(97.44,23.5)
  GND2 w0.102: v7(96.49,23.5) 96.49,23.17 v5(96.47,23.15)
  GND3 w0.102: v6(96.16,22.87) 96.44,23.15 v5(96.47,23.15)
  BOTTOM w0.127: JNGFF2.61 96.51,22.62 96.26,22.87 v6(96.16,22.87)
N137153189: length 10
  TOP w0.254: PQ322.1 49.1,72.47 PR367.1 48.04,71.91 v1(47.65,71.53) 46.65,70.52 v7(46.65,69.05)
  GND2 w0.254: v5(46.33,68.73) 46.33,68.73 v7(46.65,69.05)
  GND3 w0.254: v5(46.33,68.73) 46.24,68.81 v6(46,68.81)
  BOTTOM w0.254: PR363.2 44.63,69.37 PC332.1 44.75,69.25 PU300.4 45.32,68.14 v6(46,68.81)
N137153247: length 5.1
  TOP w0.127: v1(47.91,62.38) 48.75,63.21 PR375.1
  TOP w0.254: PR375.1 48.85,64.07 48.87,64.09 ; 48.87,64.09 PC341.1 ; 48.87,64.09 PR378.1 47.98,64.6 48.1,64.73 48.1,65.1 48.33,65.32 PQ325.2
N137153255: length 12.5
  TOP w0.127: PR383.1 52.49,63.96 v1(52.74,63.71)
  TOP w0.508: PC341.2 50.42,64.1 50.56,63.96 PR383.1 51.15,64.4 PR384.2 ; PC341.2 49.86,64.16 49.86,65.77 49.01,66.61 PQ325.3 48.39,67.24 47.75,67.24 47.22,67.77 47.22,69.27 47.33,69.39 PQ328.3 ; PC341.2 49.77,64.07 PR375.2
N137153265: length 4.4
  TOP w0.127: PQ330.5 50.72,70.24 50.77,70.3 PR392.2 51.55,70.77 51.71,70.62 52.16,70.62 52.22,70.68 PC342.1 v1(53.87,70.68)
N137153271: length 5.6
  TOP w0.127: PQ328.2 48.63,68.96 48.93,68.66 50.35,68.66 50.72,68.3 PQ330.2 50.72,67.09 50.53,66.9 PR389.1 50.53,65.94 PR384.1
N138665035: length 3.1
  BOTTOM w0.127: v1(64.93,20.28) 66.07,19.13 R1090.1
  BOTTOM w0.254: R1090.1 66.78,18.4 U18.2
N139457740: length 3.1
  TOP w0.127: PR2202.1 64.17,54.05 v1(63.96,53.83)
  TOP w0.508: PC2207.2 64.39,56.22 64.17,56 PR2202.1
N139473162: length 3.5
  TOP w0.127: QE25.5 68.81,95.94 68.93,96.07 R116.2 67.97,96.4 67.79,96.22 v1(67.79,96.16) 67.79,96.03 68.16,95.66 QE25.6
N139473177: length 2.2
  TOP w0.127: QE25.3 69.46,92.48 R115.2 69.82,92.41 v1(70.39,91.84)
N139718579: length 4.5
  BOTTOM w0.076: UC1.DF25 131.44,70.86 131.44,71.53 131.72,71.81 132.76,71.81
  BOTTOM w0.127: RH56.2 133.04,72.09 132.76,71.81
N139726036: length 10.8
  BOTTOM w0.127: UC1.CW46 126.66,55.87 126.87,55.66 126.87,55.48 126.71,55.32 126.71,55.14 126.88,54.97 127.09,54.97 127.22,55.09 127.43,55.09 127.58,54.94 127.58,54.73 127.45,54.61 127.45,54.4 128.93,52.92 130.69,52.92 130.78,52.84 130.78,51.98 130.38,51.57 RH228.1 130.2,51.45 v1(129.38,51.45) 129.38,51.77 129.49,51.87 RH467.2
N139733440: length 3.8
  BOTTOM w0.127: RH75.1 115.81,54.4 RH74.1 116.42,55.05 UC1.CD46
N139735474: length 4.9
  BOTTOM w0.127: UC1.CD45 116.81,56.91 v1(116.81,54.44) 116.81,53.63 RH77.1 RH76.1
N139809782: length 11.7
  BOTTOM w0.127: UC1.DA45 127.82,56.93 127.82,56.01 130.16,53.66 132.29,53.66 133,52.95 133,51.99 133.41,51.57 RH80.2 RH81.1 134.77,51.57 v1(135.42,52.22)
N139810461: length 9.5
  BOTTOM w0.127: RH466.1 RH465.1 131.4,51.57 131.01,51.97 131.01,52.93 130.79,53.15 129.27,53.15 v1(127.99,54.44) 127.99,54.91 127.05,55.84 127.05,56.9 UC1.CW45
N139810762: length 0.7
  GND2 w0.107: v5(89.66,83.4) v6(89.89,83.17)
  GND3 w0.127: v6(89.89,83.17) v5(89.66,83.4)
N139810763: length 1
  GND2 w0.102: v5(89.66,84.05) 90.02,84.42 v7(90.02,84.56)
  GND3 w0.127: v6(89.89,83.82) v5(89.66,84.05)
N139810764: length 0.9
  GND2 w0.102: v7(88.57,82.89) 88.57,83.36 v5(88.62,83.4)
  GND3 w0.127: v6(88.85,83.17) v5(88.62,83.4)
N139810769: length 5.9
  TOP w0.127: v7(87.94,84.5) 87,83.56 87,82.3 86.71,82.01 RH559.2 86.71,81.87 87.16,81.43 v1(87.16,80.03)
  GND2 w0.102: v7(87.94,84.5) 87.73,84.71 v5(87.67,84.71)
  GND3 w0.102: v5(87.67,84.71) 87.72,84.71 v6(87.96,84.47)
N139810770: length 7.2
  TOP w0.127: v7(87.98,85.12) 86.57,83.71 86.57,82.58 85.93,81.95 RH560.2 85.7,81.87 86.14,81.43 86.14,80.22 v1(85.89,79.97)
  GND2 w0.102: v7(87.98,85.12) 88.19,84.91 v5(88.19,84.87)
  GND3 w0.102: v5(88.19,84.87) 88.19,84.89 v6(87.96,85.12)
N139810780: length 7.3
  IN3 w0.064: v3(82.57,59.89) 82.85,59.61 82.85,56.56 82.69,56.39 82.69,55.2 82.99,54.9 84.3,54.9 v3(84.81,54.39)
N139885150: length 13.8
  BOTTOM w0.127: v1(135.42,50.88) 134.83,50.29 132.58,50.29 132.32,50.55 RH78.2 RH79.1 132.37,51.57 132.77,51.97 132.77,52.85 132.2,53.43 130.07,53.43 129.82,53.68 129.61,53.68 129.51,53.57 129.3,53.57 129.15,53.72 129.15,53.93 129.25,54.04 129.25,54.25 127.59,55.91 127.59,56.5 UC1.DA46
N140304666: length 1.2
  TOP w0.127: v1(60.87,51.77) 60.8,51.71 PC2208.1
N140390697: length 0.8
  BOTTOM w0.127: XDP_SPI_IO2.1 17.5,55.37 RC21.2
N140856784: length 2
  TOP w0.127: UD1.F9 130.29,100.29 RD157.1
N140856890: length 2.1
  TOP w0.127: RD158.1 119.81,100.31 121.85,100.31 UD2.F9
N140858392: length 3.2
  BOTTOM w0.127: RD164.1 140.62,98.04 138.67,99.99 UD3.F9
N140858498: length 2.2
  BOTTOM w0.127: RD163.1 129.3,100.82 128.77,100.29 UD4.F9
N140860614: length 2.1
  TOP w0.127: v1(137.09,89.35) 137.43,89.68 RD159.1 138.31,89.83 CD291.2
N141215433: length 3.8
  TOP w0.127: v9(69.58,79.98) 69.58,78.01 v1(69.44,77.87)
  TOP w0.203: v9(69.58,79.98) 69.33,79.72 PR1506.1
  BOTTOM w0.203: PU1500.4 69.27,80.28 v9(69.58,79.98)
N141215514: length 2.8
  TOP w0.127: PU900.4 18.07,21.48 PR906.1 v1(17.24,19.64)
N141299283: length 1.2
  TOP w0.254: PU2200.3 58.04,51.06 PR2250.2
N142043368: length 1
  TOP w0.254: PD509.2 50.25,104.06 PR549.2
N142043371: length 2.4
  TOP w0.127: v1(51.19,100.22) PD508.2
  TOP w0.254: PR548.2 51.03,101.76 PD508.2
N142043374: length 0.9
  TOP w0.254: PR544.2 50.31,102.81 PD506.2
N142043377: length 3.7
  TOP w0.127: v1(50.07,107.08) 49.82,106.83 49.82,105.68 50.33,105.17 PR543.2
  TOP w0.254: PR543.2 51.79,105.17 PD500.2
N142043380: length 184.7
  TOP w0.127: v1(36.04,1.42) 35.42,1.42 v2(35.3,1.53) 35.1,1.73 PR555.2 PR552.1 33.44,1.23 32.87,1.23 32.87,1.23 32.23,1.23 31.99,1.48 PU503.1
  TOP w0.254: PD500.1 52.25,106.88 52.9,106.22 52.9,104.07 PD509.1 PD506.1 v7(52.89,101.59)
  IN1 w0.064: v4(15.54,60.36) 14.21,59.02 9.57,59.02 3.93,53.39 3.93,48.98 4.86,48.05 4.86,44.21 4.48,43.83 4.48,27.49 3.26,26.27 3.26,20.85 2.12,19.71 2.12,9.79 5.74,6.17 12.04,6.17 16.27,1.94 31.37,1.94 31.78,1.53 v2(35.3,1.53)
  GND2 w0.102: v7(52.89,101.59) 52.89,102.05 v5(52.68,102.27) ; v4(15.54,60.36) 15.54,60.66 v5(15.57,60.69)
  IN2 w0.074: v5(15.57,60.69) 15.91,61.03 16.7,61.03 19.44,63.76 19.44,70.01 21.3,71.88 21.3,79.67 23.18,81.54 23.18,83.3 22.02,84.46 20.95,84.46 20.25,85.15 20.25,87.42 22.49,89.65 22.49,93.84 23.67,95.03 26.42,95.03 26.97,95.58 31.16,95.58 31.75,96.17 31.75,96.91 32.52,97.68 33.85,97.68 34.23,97.3 35.67,97.3 36.51,98.14 37.68,98.14 38.73,97.08 39.33,97.08 39.89,96.53 42.2,96.53 47.95,102.27 v5(52.68,102.27)
N142043409: length 6.7
  TOP w0.127: v1(32.97,1.55) 32.64,1.88 PU503.2 32.64,3.19 32.9,3.46 34.4,3.46 PR545.2 34.18,3.78 33.66,4.3 33.66,4.93 PR554.1
N142043653: length 4.6
  TOP w0.127: PU503.4 33.29,4.78 33.09,4.97 31.01,4.97 30.59,5.39 PR546.1 v1(29.35,5.44)
N142748714: length 3.5
  BOTTOM w0.127: v1(5.47,23.42) PR624.2
  BOTTOM w0.203: PU600.3 7.67,22.45 PR628.2
  BOTTOM w0.254: PR624.2 6.69,23.42 PR628.2
N142919796: length 3.7
  BOTTOM w0.127: v1(83.22,24.78) 83.03,24.59 CZ17.1
  BOTTOM w0.254: UZ5.6 82.07,22.87 82.29,23.09 82.29,23.68 82.01,23.96 CZ17.1
N142919801:
  vias: v1(81.63,20.78)
N142919814: length 3.8
  BOTTOM w0.127: RZ16.2 77.83,22.87 UZ5.3 ; RZ16.2 RZ17.2 ; RZ16.2 77.77,23.46 v1(78.24,23.92)
N142976385: length 2.5
  TOP w0.127: PR216.1 v9(127.23,18.37) 127.54,18.69 v1(127.92,18.69)
  BOTTOM w0.127: v9(127.23,18.37) 127.53,18.68 BAT100.4
N142999005: length 9.2
  TOP w0.127: v2(57.04,32.16) 57.06,32.18 PU1800.21 ; v1(57.95,25.74) 57.82,25.86 57.82,27.01 58.33,27.51 PC1829.1
  TOP w0.203: PC1829.1 58.31,27.6 PR1876.2 57.69,28.47 57.38,28.78 57.38,30.1 56.71,30.76 56.71,31.07 56.38,31.4 v2(56.38,32.14)
  IN1 w0.254: v2(57.04,32.16) 57.02,32.14 v2(56.38,32.14)
N142999049: length 1.9
  TOP w0.127: PR1875.1 v1(59.22,25.67)
  TOP w0.203: PC1829.2 PR1875.1
N143000945: length 4.3
  TOP w0.203: PU1800.45 57.06,39.7 v2(56.61,40.15) ; PC1818.1 v2(55.77,41.87)
  IN1 w0.254: v2(56.61,40.15) 55.77,40.99 v2(55.77,41.87)
N143001150: length 3
  TOP w0.127: v1(54.9,45.04) 55.28,44.66 55.28,44.21 55.77,43.72 PR1851.1
  TOP w0.203: PC1818.2 55.8,43.64 PR1851.1
N143002608: length 1.7
  TOP w0.203: PR1871.1 57.17,31.55 56.71,32.01 56.71,32.52 56.66,32.57 PU1800.20
N143002632: length 2.3
  TOP w0.203: PR1848.1 55.77,40.52 56.66,39.64 PU1800.46
N143012284:
  vias: v1(150.34,1.92)
N143161530: length 3.9
  BOTTOM w0.127: RL1.1 5.5,30.54 v1(6.7,30.54) 7.36,30.54 7.84,31.02 QH1.3
N143162018: length 2.8
  BOTTOM w0.127: Q4.1 6.83,44.85 6.46,45.22 v1(6.13,45.22) RL5.1
N143162021: length 7
  BOTTOM w0.127: QH2.6 7.17,35.5 6.75,35.92 6.75,38.72 v1(5.63,39.84) 5.24,40.23 RL4.1
N143162024: length 2.8
  BOTTOM w0.127: v1(4.86,37.17) 4.86,37.65 RL3.1 5.94,37.56 QH2.3
N143162027: length 2.5
  BOTTOM w0.127: QH1.6 5.57,33.31 5.26,32.99 4.84,32.99 v1(4.76,33.08) 4.76,33.84 RL2.1
N143222923: length 1.7
  TOP w0.635: PR903.2 21.94,23.78 PC905.1
N143225221: length 2.5
  BOTTOM w0.127: PR1503.2 v1(70.79,75.32)
  BOTTOM w0.508: PR1503.2 69.44,75.34 PC1505.1
N143441121: length 2.2
  TOP w0.127: CH223.2 78.5,62.03 v1(78.08,61.61)
  TOP w0.203: RH547.1 79.47,62.22 CH223.2
N143441124: length 1.8
  TOP w0.127: v1(80.49,59.9) 80.17,60.22 CH224.2
  TOP w0.203: RH548.1 80.2,60.84 CH224.2
N143441520: length 0.8
  GND2 w0.102: v5(75.69,81.55) 75.34,81.2 v7(75.34,81.19)
  GND3 w0.127: v6(75.92,81.32) v5(75.69,81.55)
N143441540: length 0.8
  GND2 w0.102: v7(76.65,81.23) 76.65,81.24 v5(76.34,81.55)
  GND3 w0.127: v6(76.57,81.32) v5(76.34,81.55)
N143487757: length 1
  GND2 w0.102: v7(81.38,62.74) 81.4,62.72 v5(81.4,62.31)
  GND3 w0.102: v5(81.4,62.31) v6(80.99,61.9)
N143514000: length 1.3
  BOTTOM w0.127: YC1.1 82.43,52.38 RH568.2
N143614360: length 3.8
  TOP w0.127: v1(83.16,110.76) 83.58,110.34 PR2305.1
  TOP w0.254: PU2300.5 84.22,109.27 84.4,109.45 84.4,109.92 84.35,109.98 PR2305.1 PR2301.1
N144321040: length 2.8
  TOP w0.127: v1(126.38,19.4) 126.59,19.19 v9(126.59,18.37) 126.53,18.31 PR217.1
  BOTTOM w0.127: v9(126.59,18.37) 126.28,18.68 BAT100.5
N144321105: length 3
  TOP w0.127: v1(124.69,19.33) 125.32,18.7 v9(125.32,18.31) PR218.1
  BOTTOM w0.127: v9(125.32,18.31) 125.04,18.59 BAT100.6
N144552000: length 1.3
  BOTTOM w0.508: RTCR2.1 161.97,8.92 RTCD1.1
N144553377: length 4.4
  TOP w0.127: v1(20.23,32.09) 20.09,32.23 C3007.1
  TOP w0.254: C3007.1 17.82,32.23 16.92,31.33 U736.6
N144678545: length 3.5
  TOP w0.127: RH604.2 60.5,11.61 60.91,12.02 QC6.5 61.5,12.02 61.95,11.58 v1(62.26,11.58)
N144683203: length 6.4
  TOP w0.127: RH600.2 58.39,13.16 v1(58.45,13.1) 58.77,13.1 58.96,13.29 62.61,13.29 62.78,13.46 63.19,13.46 63.37,13.63 QC2.5
N144759893: length 2.7
  TOP w0.127: v1(158.28,8.91) 157.58,9.61 PC502.1
  TOP w0.254: PR550.2 PC502.1
N144759896: length 3.3
  TOP w0.127: v1(159.67,19.26) 159.48,19.07 PC501.1
  TOP w0.508: PR551.2 159.33,16.76 159.48,16.91 PC501.1
N144829640: length 1.2
  GND2 w0.102: v4(131.41,57.15) 131.84,57.15 v5(132.17,57.47)
  GND3 w0.102: v14(132.4,57.24) v5(132.17,57.47)
N144830107: length 0.8
  GND2 w0.102: v4(132.44,56.33) 132.14,56.63 v5(132.14,56.64)
  GND3 w0.102: v14(131.81,56.64) v5(132.14,56.64)
N145583891: length 2.8
  BOTTOM w0.127: v1(146.02,7.7) 146.4,7.32 PC503.1
  BOTTOM w0.508: PL502.2 148.12,7.32 PC503.1
N146334871: length 4.3
  BOTTOM w0.127: 91.73,28.15 91.73,27.79 91.45,27.51 87.98,27.51 v1(87.92,27.45)
N146334885: length 6
  BOTTOM w0.127: v1(88.05,26.12) 91.16,26.12 91.87,26.83 CZ3.1 92.12,27.01 92.44,27.33 UZ2.6
N146336831: length 2
  TOP w0.127: 27.59,28.58 27.8,28.38 28.38,28.38 29.05,27.7 v1(29.24,27.7)
N146336845: length 2.9
  TOP w0.127: v1(26.58,26.82) 26.58,27.15 CZ4.1 26.69,28.28 UZ23.6
N146376252: length 3.7
  BOTTOM w0.254: RE271.2 27.68,15.07 27.09,14.47 v1(27.09,13.99) 27.09,13.37 26.83,13.11 UE2.3
N146376256: length 3.5
  BOTTOM w0.127: UE2.4 26.49,12.61 26.64,12.46 v1(27.09,12.46) 27.26,12.46 RE29.1 RE27.2
N146376264: length 2.4
  BOTTOM w0.127: v1(24.74,16.34) 24.56,16.16 RE17.2 23.59,16.09 UE2.29
N146376360: length 1.8
  BOTTOM w0.127: RE19.2 19.92,12.27 20.26,12.61 UE2.21
N146376362: length 3.6
  BOTTOM w0.127: UE2.24 20.17,14.11 20.09,14.03 19.12,14.03 RE18.2 19.41,14.37 19.47,14.37 19.78,14.69 19.78,15.2 v1(19.53,15.45)
N146376375: length 2.9
  BOTTOM w0.127: v1(20.74,16.27) 20.85,16.16 RE23.2 22.11,16.16 22.59,15.68 UE2.27
N146376404: length 2
  BOTTOM w0.127: RE31.2 CE12.1 v1(17.05,8.72)
N146468390: length 1
  GND2 w0.102: v5(35.28,52.1) 35.1,52.28 v7(34.78,52.28)
  GND3 w0.102: v6(34.95,52.27) 35.1,52.27 v5(35.28,52.1)
N146468421: length 0.8
  GND2 w0.102: v5(36.37,52.08) 36.17,52.28 v7(36.08,52.28)
  GND3 w0.102: v6(36.04,52.25) 36.2,52.25 v5(36.37,52.08)
N146468481: length 1.4
  GND2 w0.102: v7(36.04,50.17) 36.22,50.35 v5(36.34,50.35)
  GND3 w0.102: v5(36.34,50.35) 36.5,50.5 v6(36.5,50.65)
  BOTTOM w0.076: UH4.AD31 v6(36.5,50.65)
N146468484: length 0.8
  GND2 w0.102: v5(36.37,53.6) 36.19,53.78 v7(36.04,53.78)
  GND3 w0.102: v6(36.04,53.77) 36.2,53.77 v5(36.37,53.6)
N146468556: length 1.5
  GND2 w0.102: v7(33.75,51.49) 33.85,51.49 v5(34.06,51.29)
  GND3 w0.102: v6(34.16,50.91) 34.06,51.01 v5(34.06,51.29)
  BOTTOM w0.076: UH4.AJ33 v6(34.16,50.91)
N146468597: length 3.3
  BOTTOM w0.076: 41.76,58.7 40.65,57.58 UH4.R44
  BOTTOM w0.145: 41.76,58.7 T49.1
N146726464: length 2.1
  BOTTOM w0.127: RP96.1 59.03,22.69 v1(59.15,22.56) 58.86,22.26 JCCG1.8
N146726467: length 2.4
  BOTTOM w0.127: JCCG1.9 58.36,22.08 v1(57.88,22.56) 58.39,23.07 RP97.1
N146924879: length 5.8
  TOP w0.127: RH574.1 60.85,19.59 61.19,19.26 61.19,18.12 v1(61.41,17.9)
  TOP w0.254: UC9.2 59.41,20.53 58.77,19.89 RH573.2 CH237.1 RH574.1
N146924926: length 2.3
  TOP w0.127: UZ22.4 64.09,21.09 64.36,21.35 v1(64.63,21.35) RH575.1
N146931353: length 3.3
  BOTTOM w0.127: T824.1 74.9,55.07 75.83,56 UC1.B46
N146931355: length 3.2
  BOTTOM w0.127: UC1.C46 76.61,56.02 75.79,55.2 T825.1
N146931673: length 3.2
  BOTTOM w0.127: T826.1 76.88,86.77 UC1.C1
N146931999: length 3.9
  BOTTOM w0.127: T827.1 75.93,89.21 UC1.B2
N146932713: length 6.1
  BOTTOM w0.127: T829.1 73.26,89.48 74.76,87.99 74.76,84.97 UC1.A4
N146932715: length 4.8
  BOTTOM w0.127: UC1.A3 75.27,88.62 T828.1
N146933033: length 5.2
  BOTTOM w0.127: T822.1 73.12,54.57 74.71,56.15 74.71,57.44 UC1.A44
N146933035: length 4
  BOTTOM w0.127: T823.1 74.01,54.95 75.27,56.21 UC1.A45
N146940805: length 4.8
  BOTTOM w0.076: 131.47,86.63 131.47,85.96 131.71,85.72 UC1.DG2
  BOTTOM w0.127: T818.1 131.48,86.65 131.47,86.63
N146940807: length 5.8
  BOTTOM w0.076: UC1.DG3 131.75,85.13 132.05,85.43 132.05,86.04 132.32,86.3
  BOTTOM w0.127: T819.1 132.81,86.8 132.32,86.3
N146940809: length 4.4
  BOTTOM w0.127: T820.1 130.15,89.74 131.11,88.78 UC1.DF1
N146940811: length 5.8
  BOTTOM w0.076: UC1.DF2 131.05,85.74 130.73,86.06 130.73,87.39
  BOTTOM w0.127: 130.73,87.39 128.81,89.31 T821.1
N146941849: length 1
  GND2 w0.102: v5(132.07,58.77) 131.49,58.77 v4(131.44,58.83)
  GND3 w0.102: v14(132.4,58.77) v5(132.07,58.77)
N146941851: length 0.7
  GND2 w0.102: v5(132.63,58.2) v14(132.4,57.96)
  GND3 w0.102: v14(132.4,57.96) v5(132.63,58.2)
N146979809: length 5
  TOP w0.127: U14.8 68.54,88.54 68.67,88.66 69,88.66 69.29,88.37 v1(69.63,88.37) 69.72,88.46 69.72,88.96 69.25,89.43 R95.1 68.14,88.7 U14.9
N146979831: length 1.3
  TOP w0.127: C99.1 67.74,89.31 U14.10
N146979833: length 4.8
  TOP w0.127: U14.13 66.54,88.7 R93.1 65,88.6 65,88.41 v1(65.12,88.28) 65.44,88.28 65.8,88.64 66.05,88.64 66.14,88.54 U14.14
N146979857: length 1.3
  TOP w0.127: C97.1 66.94,89.31 U14.12
N146979907: length 7.4
  BOTTOM w0.127: C3023.1 60.18,72.33 59.62,72.9 v1(58.15,72.9)
  BOTTOM w0.254: R1321.1 58.97,71.2 U15.2 ; R1321.1 58.7,70.7 U15.3 ; R1321.1 60.16,71.09 R1319.1 60.17,72.19 C3023.1
N146979931: length 3.4
  BOTTOM w0.127: R1322.1 59.14,69.31 59.92,68.54 v1(60.04,68.54)
  BOTTOM w0.254: U15.4 59.06,70.2 R1321.2 R1322.1
N146979951: length 5.1
  BOTTOM w0.127: v1(56.94,68.52) DV11.2
  BOTTOM w0.254: U15.6 54.19,69.7 53.95,69.46 53.95,69 53.73,68.79 R1323.2 54.7,68.54 DV12.2 DV11.2
N146980009: length 6.6
  TOP w0.127: C3313.1 68.74,84.7 67.74,85.7 U14.5 ; C3313.1 v1(69.74,84.55) ; C3313.1 68.65,84.46 DV14.1 67.17,84.46 67.08,84.55 R5840.2 66.71,85.32 66.94,85.55 U14.3
N147032589: length 5.1
  TOP w0.203: PR104.2 21.31,75.54 21.31,74 20.49,73.18 PR264.1 19.77,71.94 PQ216.6
N147034069: length 5.7
  TOP w0.127: PQ217.6 22.16,93.29 21.97,93.48 PR266.1 22.5,94.39 25.03,94.39 PR131.2
N147095163: length 2.6
  BOTTOM w0.127: PR708.1 11.39,53.99 11.4,53.98 v1(11.4,53.1) 11.4,52.91 10.63,52.14 PU700.9
N147128984: length 5
  TOP w0.127: PR901.2 15.8,23.06 v1(14.7,24.15)
  TOP w0.203: PR901.2 PR907.2 16.42,22.18 17.08,21.52 17.44,21.52 17.62,21.7 PU900.3
N147189904: length 1.6
  BOTTOM w0.203: PR1507.2 69.27,80.73 PU1500.3
N147237479: length 6.2
  TOP w0.127: v1(81.24,110.89) 80.86,111.27 v2(80.25,111.27)
  TOP w0.254: PD2300.2 76.87,110.29 77.7,109.47 v2(78.08,109.47)
  IN1 w0.254: v2(80.25,111.27) 80.15,111.27 78.34,109.47 v2(78.08,109.47)
N147237510: length 2.4
  TOP w0.127: PD2300.1 v1(76.87,108.18)
  TOP w0.203: PD2300.1 77.2,109.16 77.68,108.68 PR2306.1
N147264426: length 1
  TOP w0.203: PR811.2 PD800.1
N147648876: length 2.3
  BOTTOM w0.127: R531.2 29.16,22.33 29.56,21.93 v1(30.07,21.93)
  BOTTOM w0.254: LED_RST.2 28.93,21.39 R531.2
N147648878: length 2.9
  BOTTOM w0.127: R530.2 27.5,22.33 27.28,22.56 27.28,23.45 v1(27.72,23.89)
  BOTTOM w0.254: LED_RUN.2 R530.2
N148537289: length 2.4
  TOP w0.127: UD2.E9 121.14,99.49 120.28,98.63 RD231.2
N148539009: length 2
  TOP w0.127: UD1.E9 132.21,99.55 RD230.2
N148539686: length 4
  BOTTOM w0.127: RD232.2 140.66,96.39 139.95,97.1 139.95,98.21 UD3.E9
N148539959: length 2.1
  BOTTOM w0.127: UD4.E9 129.96,99.49 RD233.2
N148540239: length 2.1
  TOP w0.127: RD234.2 104.63,99.49 UD5.E9
N148540518: length 2.4
  TOP w0.127: UD6.E9 95.2,99.49 94.36,98.65 RD235.2
N148541018: length 2.1
  BOTTOM w0.127: UD7.E9 114.82,99.49 RD236.2
N148541530: length 2
  BOTTOM w0.127: RD237.2 102.38,99.48 UD8.E9
N148566755: length 13.5
  TOP w0.127: UD1.M9 132.27,105.09 132.65,104.72 132.65,103.28 132.86,103.07 133.32,103.07 133.45,102.94 133.45,102.53 133.65,102.33 139.06,102.33 140.37,101.02 RD239.1 ; RD239.1 RD238.1 ; RD239.1 140.65,101.04 140.97,101.36 141.77,101.36 v1(142.15,100.98)
N148569917: length 12.7
  TOP w0.127: RD240.1 RD241.1 129.69,104.43 129.1,103.84 129.1,102.65 128.8,102.34 123.24,102.34 123.08,102.49 123.08,102.78 122.76,103.1 122.51,103.1 122.3,103.32 122.3,104.72 121.92,105.09 UD2.M9
N148572207: length 13
  BOTTOM w0.127: UD3.M9 138.46,105.09 138.25,104.88 138.25,103.29 138.08,103.13 137.6,103.13 137.47,103 137.47,102.61 137.18,102.32 131.72,102.32 131.23,102.81 131.23,103.98 130.4,104.81 RD243.1 130.3,104.81 RD242.1
N148574907: length 11.6
  BOTTOM w0.127: RD244.1 119.74,102.43 RD245.1 120.66,102.42 120.78,102.3 126.93,102.3 127.09,102.46 127.09,102.9 127.31,103.13 127.76,103.13 127.87,103.24 127.87,104.9 128.07,105.09 UD4.M9
N148577773: length 11.3
  TOP w0.127: RD246.1 RD247.1 114.45,102.65 114.16,102.36 107.67,102.36 107.54,102.48 107.54,102.81 107.25,103.1 106.93,103.1 106.8,103.23 106.8,104.74 106.45,105.09 UD5.M9
N148578659: length 12.3
  TOP w0.127: UD6.M9 96.13,105.09 96.41,104.81 96.41,103.29 96.63,103.08 97.01,103.08 97.16,102.93 97.16,102.51 97.35,102.32 103.39,102.32 103.72,102.65 103.72,103.33 104.32,103.93 RD248.1 RD249.1
N148580948: length 12.7
  BOTTOM w0.127: UD7.M9 112.56,105.09 112.32,104.84 112.32,103.19 112.21,103.09 111.72,103.09 111.55,102.93 111.55,102.6 111.29,102.33 105.61,102.33 105.37,102.57 105.37,103.64 104.77,104.24 RD251.1 104.39,103.62 RD250.1
N148582662: length 11.9
  BOTTOM w0.127: RD252.1 93.91,102.94 RD253.1 94.27,103.54 95.49,102.32 101.05,102.32 101.2,102.47 101.2,102.88 101.42,103.09 101.81,103.09 101.99,103.27 101.99,104.82 102.26,105.09 UD8.M9
N148592442: length 1.9
  BOTTOM w0.127: v1(84.43,32.09) 85.35,31.16 PC1907.2
N148592463: length 2.4
  BOTTOM w0.127: v1(83.92,33.36) 84.62,33.36 85.42,32.56 PC1907.1
N148596615: length 2.5
  TOP w0.127: PC1919.2 70.58,41.36 v1(70.39,41.55)
  TOP w0.508: PR1905.1 71.9,40.44 PC1919.2
N148599112: length 1.7
  BOTTOM w0.127: v1(75.98,32.02) 76.84,31.16 PC2007.2
N148599118: length 2.2
  BOTTOM w0.127: PC2007.1 76.65,32.56 76.04,33.17 v1(75.35,33.17)
N148600856: length 1.8
  BOTTOM w0.127: v1(93.19,32.02) 94.09,31.12 PC2018.2
N148600862: length 2.2
  BOTTOM w0.127: PC2018.1 93.9,32.52 93.19,33.23 v1(92.68,33.23)
N148600909: length 3.1
  BOTTOM w0.127: v1(101.14,32.26) 100.63,31.75 99.34,31.75 98.68,31.1 PR2203.1
N148600976: length 2.9
  BOTTOM w0.127: PU2201.13 99.8,36.54 99.98,36.72 101.06,36.72 101.63,36.16 v1(101.63,35.77)
N148601051: length 2.8
  TOP w0.127: PC2019.2 95.92,40.28 v1(95.22,40.98)
  TOP w0.508: PR2205.1 96.38,40.29 PC2019.2
N148672855: length 8.8
  TOP w0.127: D321.1 67.31,24.38 R3.2 66.27,22.69 66.42,22.54 R277.1 66.42,21.85 66.27,21.7 C4.1 66.91,20.73 QRTC.2 68.68,19.78 R5851.1 69.36,19.02 v1(69.76,18.62)
N148672909: length 2.5
  TOP w0.127: R276.2 71.21,23.7 v1(71.21,24.66) 71.21,25.23 71,25.43 QRTC1.1
N148880847: length 2.5
  TOP w0.127: LED7.2 98.12,16.69 RW1.2 98.52,17.35 v1(99.29,18.12)
N149074452: length 20
  TOP w0.127: v9(30.58,9.23) 30.77,9.04 RE193.1 29.8,8.1 v1(29.63,8.27)
  IN3 w0.064: v9(30.58,9.23) 30.58,9.42 29.88,10.12 29.88,10.74 28.77,11.85 28.77,12.18 25.64,15.31 25.64,15.93 24.99,16.58 24.99,17.74 24.7,18.02 24.7,18.47 25.59,19.35 25.59,21.07 v3(25.43,21.23)
  BOTTOM w0.127: v3(25.43,21.23) 25.74,21.53 RE428.1 25.53,21.86 24.79,22.6 JESPI1.8
N149118427: length 3
  BOTTOM w0.127: v1(26.8,17.43) 26.76,17.43 25.56,18.62 LED_PRI.2 R532.2
N149279356: length 4.7
  TOP w0.127: PT501.1 39.32,2.37 35.76,2.37 PR555.1
N149282761: length 1.7
  BOTTOM w0.127: UPD1.H11 35.96,69.03 36.37,69.44 36.94,69.44 RP102.2
N149282764: length 1.7
  BOTTOM w0.127: UPD1.J11 36.12,69.53 36.34,69.75 36.57,69.75 37.03,70.21 RP103.2
N149282893: length 2
  BOTTOM w0.127: UPD1.A8 34.18,65.23 33.99,65.05 33.99,64.62 33.28,63.91 RP104.1
N149282896: length 2
  BOTTOM w0.127: UPD1.A9 35.37,64.84 35.37,64.31 35.06,64 RP105.1
N149284474: length 2
  TOP w0.127: v1(161.26,17.23) 161.58,16.91 RTCR1.1 161.58,16.31 RTCD2.1
N149439645: length 3.7
  BOTTOM w0.127: v1(41.69,64.73) 41.69,65.36 41.02,66.03 QP1.1 40.49,67.19 RP110.2
N149440260: length 1.5
  BOTTOM w0.127: RP111.2 39.62,69.37 QP2.1
N149551327: length 8
  IN1 w0.064: v2(100.07,16.39) 100.41,16.39 100.74,16.72 105.83,16.72 v4(106.08,16.98)
  GND2 w0.102: v5(106.53,16.89) 106.44,16.98 v4(106.08,16.98)
  GND3 w0.102: v5(106.53,16.89) 106.71,16.71 v6(106.83,16.71)
  BOTTOM w0.127: v6(106.83,16.71) 106.83,16.13 JIO1.E8
N149709154: length 2.1
  TOP w0.127: v1(64.3,82.7) 64.19,82.8 RH633.2 64.07,83.91 QC3.3
N149709174: length 2.3
  TOP w0.127: v1(62.61,82.66) 63.01,83.06 RH635.2 63.01,84.07 62.77,84.31 QC3.2
N150381253: length 3.1
  TOP w0.127: v1(66.04,15.23) R5830.2 66.04,17.86 Q3.1
N150410925: length 3.4
  BOTTOM w0.127: US5.5 23.51,69.46 23.91,69.07 CP15.1 24.04,69.41 24.24,69.61 25.14,69.61 v1(25.5,69.97)
N150410947: length 2.6
  BOTTOM w0.127: CP14.2 20.29,69.69 20.02,69.96 20.02,70.88 20.21,71.07 US5.10
N150411001: length 2.1
  BOTTOM w0.127: US5.12 20.19,72.07 19.48,71.35 RP112.2
N150411007: length 1.1
  BOTTOM w0.127: US5.9 21.51,69.12 RP114.2
N150411478: length 2.9
  TOP w0.127: CP17.1 27.56,102.89 26.52,102.89 26.21,102.57 US6.5
N150411512: length 1.2
  TOP w0.127: US6.10 22.41,101.11 CP16.2
N150411564: length 1.8
  TOP w0.127: RP115.2 21.76,99.57 22.15,99.95 22.55,99.95 22.7,100.11 US6.12
N150411570: length 2.6
  TOP w0.127: US6.9 24.21,102.24 24.08,102.37 23.58,102.37 22.7,101.49 RP117.2
N150412363: length 31.2
  TOP w0.127: v2(16.6,71.89) 16.43,71.89 16.18,71.63 16.18,71.06 RP143.1 ; v1(34.58,73.87) 34.58,74.06 35.04,74.52 v2(35.72,74.52)
  IN1 w0.064: v2(35.72,74.52) 35.57,74.38 32.95,74.38 32.37,74.96 32.02,74.96 30.79,76.18 30.79,77.6 29.74,78.66 27.47,78.66 26.54,77.73 26.54,74.82 26.29,74.56 25.35,74.56 24.33,73.54 24.33,73.21 v4(23.96,72.84) 23.96,72.66 23.22,71.93 16.63,71.93 v2(16.6,71.89)
  GND2 w0.102: v5(24.33,72.46) v4(23.96,72.84)
  GND3 w0.102: v5(24.33,72.46) 24.33,72.17 v6(24.44,72.07)
N150412421: length 76.1
  TOP w0.127: v1(33.48,62.06) v2(32.99,62.55)
  TOP w0.254: RP144.1 25.33,89.77 v2(25.87,89.77) ; UC5.4 32.54,62.09 v2(32.99,62.55)
  IN1 w0.254: v7(27.21,100.11) 26.98,100.11 26.79,100.3 26.79,101.97 26.33,102.43 18.36,102.43 15.63,99.7 15.63,92.17 19.49,88.31 v4(25.66,88.31) 27.42,88.31 28.3,89.19 28.3,89.78 28.05,90.03 26.13,90.03 v2(25.87,89.77) ; v2(32.99,62.55) 29.82,62.55 27.59,64.78 27.53,64.78 27.12,65.18 v4(27.12,66.55)
  GND2 w0.254: v5(27.17,66.93) 27.12,66.88 v4(27.12,66.55) ; v5(25.25,88.31) v4(25.66,88.31)
  IN2 w0.254: v5(27.17,66.93) 26.46,66.93 25.52,67.88 25.52,78.26 26.35,79.1 26.35,86.3 25.25,87.41 v5(25.25,88.31)
N150849033:
  vias: v1(157.96,21.8)
N150886581: length 3.7
  TOP w0.127: v1(153.9,19.96) 154.56,19.3 155.42,19.3 C3311.1 155.88,20.39 155.87,20.4 UZ24.6
N150930373: length 3.6
  TOP w0.127: v1(40.61,64.34) 40.27,64.69 RP121.2 40.27,67.01 40.14,67.14 QP3.1
N150931521: length 3.7
  TOP w0.127: RP124.2 37.98,71.14 QP4.1 v1(40.74,71.14)
N151109456: length 1.7
  BOTTOM w0.203: PQ146.5 32.93,102.76 33.18,103.02 PR161.1
N151119190: length 1.3
  TOP w0.203: PQ155.6 28.85,76.23 28.62,76.46 PR118.2
N151119548: length 2.8
  TOP w0.203: PR112.2 25.54,74.99 v1(25.82,75.27) 26.45,75.27 26.78,74.93 PQ155.3
N151120235: length 67.3
  TOP w0.203: PR123.2 26.67,73.82 26.67,72.7 26.96,72.41 27.51,72.41 27.75,72.65 27.81,72.79 PR126.1 27.93,72.68 27.93,71.42 27.8,71.28 PQ136.5
  TOP w0.254: v2(26.16,74.86) PR123.2
  IN1 w0.254: v4(17.92,89.38) 19.32,87.98 22.64,87.98 23.29,87.32 23.29,82.07 25.24,80.12 25.24,78.32 25.12,78.2 25.12,76.33 23.53,74.75 23.53,74.44 23.78,74.19 24.65,74.19 25.32,74.86 v2(26.16,74.86)
  GND2 w0.254: v5(18.15,89.87) 17.92,89.64 v4(17.92,89.38) ; v7(44.27,106.14) 44.27,106.02 v5(44.1,105.85)
  IN2 w0.254: v5(18.15,89.87) 19.3,91.01 19.3,95.05 22.38,98.13 24.54,98.13 25.47,99.06 25.47,100.66 31.6,106.8 36.42,106.8 37.1,106.12 38.37,106.12 38.47,106.22 42.39,106.22 42.5,106.12 43.84,106.12 v5(44.1,105.85)
N151120414: length 2.5
  TOP w0.127: v1(27.53,69.55) 27.47,69.61 PR113.2
  TOP w0.203: PR113.2 26.62,70.35 26.9,70.63 PQ136.6
N151122655: length 1.6
  TOP w0.254: PQ154.3 31.3,98.2 30.83,98.67 PR140.2
N151130119: length 2.2
  BOTTOM w0.203: PR158.2 29.55,102.11 30.2,102.76 PQ146.2
N151130610: length 1.9
  BOTTOM w0.203: PR159.2 PR161.2 34.64,103.03 PQ147.2
N151131381: length 1.1
  TOP w0.203: PQ149.2 33.58,99.52 PR164.2
N151131403: length 3.4
  TOP w0.203: PR178.2 33.82,100.48 34.12,100.17 PQ149.1 34.75,100.17 35.04,99.89 35.04,99.16 34.75,98.87 PQ149.3
N151132228: length 2.2
  TOP w0.127: PR186.2 37.18,98.63 v1(37.12,98.57)
  TOP w0.254: PR186.2 PQ149.5
N151132921: length 2.7
  BOTTOM w0.127: v1(28.55,104.03) 28.6,103.98 PR163.1
  BOTTOM w0.203: PQ150.6 30.56,104.4 30.15,103.98 PR163.1
N151132926: length 3.3
  BOTTOM w0.127: v1(28.55,105.49) 28.81,105.76 PR165.2
  BOTTOM w0.203: PR165.2 30.91,105.76 31.21,106.06 PQ150.2
N151132940: length 4.6
  BOTTOM w0.127: PR187.2 32.93,105.75 v1(34.2,107.02)
  BOTTOM w0.203: PR187.2 32.53,105.44 32.17,105.81 31.66,105.81 31.21,105.37 PQ150.5
N151133179: length 1
  TOP w0.254: PQ152.2 PR195.2
N151134696: length 2.2
  TOP w0.254: PR196.2 35.16,98.14 35.39,98.37 v9(35.96,98.37)
  BOTTOM w0.254: v9(35.96,98.37) 35.57,98.76 PQ153.2
N151134710: length 3.1
  BOTTOM w0.203: PQ153.5 33.07,98.76 32.93,98.9 32.93,99.84 33.13,100.04 33.8,100.04 PR212.2
N151134873: length 3.9
  TOP w0.254: PQ152.5 42.66,106.58 v1(42.18,107.06) 41.88,107.35 40.26,107.35 PR209.2
N151135547: length 9.2
  TOP w0.127: v1(46.78,63.14) 47.06,63.42 PR378.2
  TOP w0.254: PQ330.6 50.07,69.87 49.81,70.12 49.63,70.12 49.42,69.92 v2(49.42,69.83) ; PR378.2 47.06,65.26 46.73,65.6 46.73,66.21 46.83,66.32 v2(46.83,66.65)
  IN1 w0.254: v2(49.42,69.83) 49.42,69.45 46.83,66.86 v2(46.83,66.65)
N151135923: length 2.9
  TOP w0.127: v1(51.72,65.23) 51.44,65.51 PR389.2 51.44,67.35 51.37,67.42 PQ330.3
N151224419: length 3.4
  TOP w0.127: QE30.6 60.54,76.47 60.66,76.35 61.12,76.35 61.19,76.41 QE30.5 61.19,77.43 61.16,77.45 R5843.2 v1(62,77.81)
N151224429:
  vias: v1(62.26,74.12)
N151224638: length 5.1
  TOP w0.127: v1(56.83,75.99) 57.3,76.45 57.3,77.08 58.03,77.81 R5845.2 58.16,77.47 58.06,77.36 QE31.6 58.06,76.47 58.19,76.35 58.65,76.35 58.71,76.41 QE31.5
N151224640:
  vias: v1(56.23,73.55)
N151224855:
  vias: v1(49.12,54.69)
N151224873: length 2.4
  TOP w0.127: QE32.3 50.72,50.94 R5846.2 v1(52.17,50.76)
N151327329: length 13.1
  IN1 w0.064: v2(46.35,11.79) 45.91,11.79 44.8,10.68 44.8,9.4 42.86,7.45 37.89,7.45 37.65,7.7 36.39,7.7 36.27,7.58 v2(35.95,7.58)
N151525675: length 1.2
  BOTTOM w0.127: RT233.1 43.2,89.67 U4253.1
N151525680: length 1.2
  BOTTOM w0.127: RT234.1 43.27,90.97 U4253.3
N151525769: length 2.6
  TOP w0.127: v1(46.9,85.3) 46.2,86 v7(46.2,86.28) RT236.1
  GND2 w0.102: v7(46.2,86.28) 46.27,86.35 v5(46.27,86.62)
  GND3 w0.102: v5(46.27,86.62) 46.27,86.62 46.15,86.74 v6(45.96,86.74)
N151525780: length 1.4
  BOTTOM w0.127: RT237.1 44.76,88.51 45.22,88.04 U4254.3
N151529874: length 9.1
  TOP w0.127: v2(44.48,3.9) 44.51,3.87 RE429.2 45.14,3.87 45.35,3.66 45.35,2.58 v1(45.56,2.37)
  IN1 w0.064: v2(47.15,9.39) 47.15,9.05 46.87,8.77 46.87,6.69 45.56,5.38 45.56,5.1 45.18,4.72 44.96,4.72 44.83,4.59 44.83,4.37 44.48,4.01 v2(44.48,3.9)
N151793519: length 4.5
  TOP w0.127: JAPS1.7 76.83,9.18 77.35,9.7 v9(77.35,11.1)
  BOTTOM w0.127: R5854.2 R5855.2 77.47,10.98 v9(77.35,11.1)
N151793539: length 2.4
  TOP w0.127: v9(74.71,9.62) 74.83,9.51 JAPS1.3
  BOTTOM w0.127: R5853.2 R5852.2 74.73,9.61 v9(74.71,9.62)
N151919506: length 2
  BOTTOM w0.254: LP1.2 23.42,67.76 23.78,67.39 UP1.B1
N151919537: length 4.1
  BOTTOM w0.127: UP1.C2 24.9,68.14 RP138.2 26.07,68.22 26.83,68.98 RP137.1 27.2,69.42 v1(27.85,69.42)
N151922365: length 5.1
  BOTTOM w0.127: v1(31.13,100.86) LP2.2
  BOTTOM w0.254: UP2.B1 30.19,96.42 30.44,96.68 30.77,96.68 31.13,97.04 LP2.2
N151922410: length 3.2
  BOTTOM w0.127: v1(32.55,94.32) 32.04,94.82 RP139.1 31.61,95.23 31.64,95.27 RP140.2 31.23,95.71 31.04,95.89 UP2.C2
N152653463: length 2.2
  GND2 w0.102: v7(45.55,10.19) 45.55,10.48 v5(45.48,10.56)
  GND3 w0.102: v5(45.48,10.56) 45.72,10.8 v6(45.72,10.89)
  BOTTOM w0.127: v1(45.64,9.68) 45.47,9.85 45.47,10.38 RE430.2 45.72,10.62 v6(45.72,10.89)
