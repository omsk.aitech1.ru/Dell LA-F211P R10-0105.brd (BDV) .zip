# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D0: length 30.5
  IN3 w0.064: v14(137.07,101.89) 137.38,101.58 139.57,101.58 141.39,99.77 141.39,93.1 139.9,91.61 139.9,91.52 140.47,90.95 140.47,90.86 140.38,90.77 140.29,90.77 139.72,91.34 139.63,91.34 139.54,91.25 139.54,91.16 140.11,90.59 140.11,90.5 140.02,90.41 139.93,90.41 139.36,90.98 139.27,90.98 137.98,89.69 137.98,88.39 133.86,84.27 133.08,84.27 132.31,83.5 131.43,83.5 v3(131.06,83.13)
DDR_A_D1: length 30.3
  IN3 w0.064: v3(132.4,82.83) 133.32,83.75 134.03,83.75 138.78,88.5 138.78,88.59 138.41,88.95 138.41,89.04 138.5,89.13 138.59,89.13 138.96,88.77 139.05,88.77 139.14,88.86 139.14,88.95 138.61,89.48 138.61,89.57 138.7,89.66 138.79,89.66 139.32,89.13 139.41,89.13 141.82,91.53 141.82,100.24 139.67,102.39 137.37,102.39 v14(137.07,102.69)
DDR_A_D2: length 27.9
  IN3 w0.064: v3(130.41,85.77) 132.05,85.77 134.82,88.54 134.82,90.7 138.94,94.82 138.94,98.02 137.8,99.16 136.18,99.16 136.12,99.1 136.12,98.63 136.05,98.57 135.92,98.57 135.86,98.63 135.86,99.1 135.8,99.16 135.67,99.16 135.61,99.1 135.61,98.63 135.54,98.57 135.42,98.57 135.35,98.63 135.35,99.1 135.29,99.16 135.16,99.16 135.1,99.1 135.1,98.63 135.04,98.57 134.91,98.57 134.85,98.63 134.85,99.1 134.78,99.16 133.82,99.16 132.8,100.18 132.8,100.82 v14(133.07,101.09)
DDR_A_D3: length 30.3
  IN3 w0.064: v3(130.56,83.67) 132.15,83.67 132.99,84.51 133.71,84.51 137.76,88.56 137.76,89.78 141.17,93.19 141.17,99.65 139.47,101.36 135.2,101.36 v14(133.87,102.69)
DDR_A_D4: length 28
  IN3 w0.061: 135.25,88.32 135.25,88.46
  IN3 w0.064: 135.25,88.32 131.86,84.94 v3(131.11,84.94) ; v14(133.87,101.89) 133.6,101.62 133.6,100.16 133.75,100.01 137.33,100.01 137.66,99.68 138.53,99.68 139.39,98.81 139.39,94.66 139.24,94.51 139.24,94.42 139.4,94.25 139.4,94.16 139.31,94.07 139.22,94.07 139.06,94.24 138.97,94.24 138.88,94.15 138.88,94.06 139.36,93.58 139.36,93.49 139.27,93.4 139.18,93.4 138.7,93.88 138.61,93.88 135.25,90.52 135.25,88.46
DDR_A_D5: length 29.4
  IN3 w0.064: v14(137.87,101.89) 138.13,102.15 139.38,102.15 141.6,99.93 141.6,91.67 139.82,89.88 139.72,89.88 139.14,90.46 139.05,90.46 138.96,90.37 138.96,90.28 139.54,89.7 139.54,89.61 139.45,89.52 139.36,89.52 138.78,90.1 138.69,90.1 138.2,89.6 138.2,88.26 133.92,83.98 133.12,83.98 132.37,83.23 v3(131.73,83.23)
DDR_A_D6: length 28.7
  IN3 w0.061: 135.03,88.44 135.03,88.46
  IN3 w0.064: v3(130.47,85.12) 130.78,85.12 130.92,85.26 131.86,85.26 135.03,88.44 ; v14(133.07,101.89) 133.37,101.59 133.37,100.04 133.63,99.78 134.06,99.78 134.12,99.71 134.12,99.46 134.18,99.4 134.31,99.4 134.37,99.46 134.37,99.71 134.44,99.78 134.56,99.78 134.63,99.71 134.63,99.46 134.69,99.4 134.82,99.4 134.88,99.46 134.88,99.71 134.95,99.78 135.07,99.78 135.14,99.71 135.14,99.46 135.2,99.4 135.33,99.4 135.39,99.46 135.39,99.71 135.45,99.78 135.58,99.78 135.64,99.71 135.64,99.46 135.71,99.4 135.83,99.4 135.9,99.46 135.9,99.71 135.96,99.78 137.19,99.78 137.55,99.41 138.41,99.41 139.17,98.66 139.17,94.74 135.03,90.61 135.03,88.46
DDR_A_D7: length 29.2
  IN3 w0.061: 135.46,88.46 135.46,88.17
  IN3 w0.064: 135.46,88.46 135.46,90.43 137.15,92.11 137.23,92.11 137.72,91.63 137.81,91.63 137.9,91.72 137.9,91.81 137.41,92.29 137.41,92.38 137.5,92.47 137.59,92.47 138.08,91.99 138.17,91.99 138.26,92.08 138.26,92.17 137.77,92.65 137.77,92.74 137.86,92.83 137.95,92.83 138.44,92.35 138.53,92.35 138.62,92.44 138.62,92.53 138.13,93.01 138.13,93.1 138.22,93.19 138.31,93.19 138.8,92.71 138.89,92.71 138.98,92.8 138.98,92.89 138.49,93.37 138.49,93.46 138.58,93.55 138.67,93.55 139.16,93.06 139.25,93.06 139.62,93.44 139.62,98.94 138.53,100.02 137.72,100.02 137.45,100.29 v14(137.07,100.29) ; v3(130.4,84.32) 130.94,84.32 131.39,84.77 132.07,84.77 132.44,85.14 132.44,85.15 135.46,88.17
DDR_A_D8: length 17.5
  IN3 w0.064: v3(129.21,85.77) 129.53,86.09 129.65,86.09 130.03,86.48 131.25,86.48 133.91,89.14 133.91,91.07 137.47,94.62 137.47,96.03 137.71,96.28 137.71,96.79 137.57,96.93 137.57,97.69 137.33,97.94 137.33,98.06 137.45,98.19 137.57,98.19 v14(137.87,97.89)
DDR_A_D9: length 17.3
  IN3 w0.064: v14(137.07,97.89) 137.36,97.6 137.36,96.84 137.5,96.7 137.5,96.37 137.25,96.12 137.25,95.97 137.19,95.9 136.4,95.9 136.34,95.84 136.34,95.71 136.4,95.65 137.19,95.65 137.25,95.59 137.25,94.71 133.7,91.16 133.7,89.26 131.15,86.71 129.87,86.71 v3(129.59,86.42)
DDR_A_D10: length 19.6
  IN3 w0.064: v14(133.87,97.89) 134.21,97.55 134.21,95.15 134.02,94.96 132.95,94.96 132.88,94.89 132.88,94.52 132.96,94.44 134.18,94.44 134.25,94.37 134.25,94.25 134.18,94.18 132.93,94.18 132.88,94.14 132.88,93.95 132.37,93.45 132.37,92.55 131.99,92.17 131.99,90.25 129.87,88.12 129.49,88.12 128.33,86.97 128.33,86.19 128.12,85.98 128.12,84.72 v3(128.37,84.47)
DDR_A_D11: length 20
  IN3 w0.064: v3(128.37,83.82) 127.86,84.34 127.86,86.06 128.09,86.29 128.09,87.06 129.42,88.4 129.82,88.4 131.78,90.36 131.78,92.26 132.16,92.64 132.16,93.53 132.67,94.04 132.67,95.09 132.75,95.17 133.45,95.17 133.51,95.24 133.51,95.36 133.45,95.43 132.72,95.43 132.67,95.48 132.67,95.68 132.73,95.74 133.89,95.74 133.96,95.81 133.96,95.93 133.89,96 132.73,96 132.67,96.06 132.67,96.2 132.76,96.29 v14(133.87,96.29)
DDR_A_D12: length 20.4
  IN3 w0.064: v3(129.16,83.82) 129.64,84.3 129.64,84.92 130.12,85.4 130.12,85.63 130.01,85.74 130.01,85.83 130.29,86.12 131.59,86.12 134.35,88.87 134.35,90.89 138.37,94.91 138.37,97.88 137.64,98.61 137.15,98.61 v14(137.07,98.69)
DDR_A_D13: length 18.7
  IN3 w0.064: v14(137.87,97.09) 138.15,96.81 138.15,96.04 138.09,95.98 137.75,95.98 137.68,95.91 137.68,95.79 137.75,95.72 138.02,95.72 138.08,95.66 138.08,95.53 138.02,95.47 137.75,95.47 137.68,95.41 137.68,95.28 137.75,95.21 138.02,95.21 138.08,95.15 138.08,94.97 138,94.89 137.75,94.89 137.68,94.82 137.68,94.53 134.13,90.98 134.13,89 131.44,86.31 130.17,86.31 129.45,85.6 129.45,84.76 v3(129.16,84.47)
DDR_A_D14: length 18
  IN3 w0.064: v14(133.87,98.69) 133.98,98.69 134.68,97.99 134.68,93.94 134.27,93.53 134.18,93.53 133.95,93.75 133.86,93.75 133.77,93.66 133.77,93.57 134,93.35 134,93.26 133.91,93.17 133.82,93.17 133.65,93.33 133.56,93.33 133.47,93.24 133.47,93.15 133.64,92.99 133.64,92.9 133.55,92.81 133.46,92.81 133.02,93.24 132.93,93.24 132.84,93.15 132.84,93.06 133.12,92.78 133.12,92.69 132.43,91.99 132.43,89.83 130.32,87.72 129.67,87.72 128.81,86.86 v3(128.81,86.42)
DDR_A_D15: length 18.2
  IN3 w0.064: v3(128.37,85.77) 128.37,85.95 128.56,86.14 128.56,86.92 129.59,87.95 130.11,87.95 132.21,90.06 132.21,92.08 132.59,92.46 132.59,93.36 132.69,93.46 133.38,93.46 133.45,93.52 133.45,93.65 133.38,93.71 133.19,93.71 133.13,93.78 133.13,93.9 133.19,93.97 134.4,93.97 134.46,94.03 134.46,97.9 134.07,98.29 133.47,98.29 v14(133.07,97.89)
DDR_A_D16: length 30.4
  IN1 w0.064: v12(137.07,102.69) 137.41,102.35 139.41,102.35 141.82,99.94 141.82,92.02 134.53,84.73 134.53,80.94 133.55,79.97 v6(132.4,79.97)
DDR_A_D17: length 31.4
  IN1 w0.064: v12(137.87,101.89) 138.11,102.13 139.14,102.13 141.54,99.74 141.54,95.03 141.47,94.96 141.06,94.96 141,94.9 141,94.77 141.06,94.71 141.47,94.71 141.54,94.65 141.54,94.52 141.47,94.45 141.06,94.45 141,94.39 141,94.26 141.06,94.2 141.47,94.2 141.54,94.14 141.54,94.01 141.47,93.95 141.06,93.95 141,93.89 141,91.54 134.28,84.82 134.28,81.27 133.26,80.24 132.27,80.24 132,79.97 v6(131.75,79.97)
DDR_A_D18: length 29.1
  IN1 w0.064: v12(133.87,101.89) 134.1,101.89 136.24,99.76 138.06,99.76 138.95,98.86 138.95,96.21 138.41,95.66 138.41,92.62 138.34,92.55 136.37,92.55 136.3,92.49 136.3,92.36 136.37,92.3 136.94,92.3 137,92.24 137,92.11 136.94,92.04 136.36,92.04 136.3,91.98 136.3,89.99 132.36,86.06 132.36,82.16 v6(131.75,81.55)
DDR_A_D19: length 31.5
  IN1 w0.064: v6(130.45,79.97) 130.95,80.47 131.87,80.47 132.1,80.7 132.1,80.93 132.25,81.08 133.27,81.08 133.71,81.52 133.71,84.96 140.56,91.81 140.56,96.19 141.04,96.66 141.04,97.04 140.97,97.1 140.63,97.1 140.56,97.17 140.56,97.29 140.63,97.36 140.97,97.36 141.04,97.42 141.04,97.55 140.97,97.61 140.63,97.61 140.56,97.67 140.56,97.8 140.63,97.87 140.97,97.87 141.04,97.93 141.04,98.06 140.97,98.12 140.63,98.12 140.56,98.18 140.56,98.31 140.63,98.37 140.97,98.37 141.04,98.44 141.04,99.57 139.23,101.38 138.16,101.38 v12(137.87,101.09)
DDR_A_D20: length 28.7
  IN1 w0.064: v6(132.4,81.77) 132.62,81.99 132.62,85.96 136.51,89.85 136.51,91.77 136.58,91.83 137.58,91.83 137.64,91.89 137.64,92.02 137.58,92.08 137.39,92.08 137.32,92.15 137.32,92.27 137.39,92.34 138.56,92.34 138.62,92.4 138.62,95.57 139.22,96.17 139.22,99.29 138.52,99.99 136.99,99.99 135.07,101.91 134.65,101.91 v12(133.87,102.69)
DDR_A_D21: length 31.6
  IN1 w0.064: v12(137.07,101.89) 137.07,101.87 137.33,101.61 139.31,101.61 141.27,99.66 141.27,96.32 141.2,96.26 140.94,96.26 140.88,96.19 140.88,96.07 140.94,96 141.2,96 141.27,95.94 141.27,95.81 141.2,95.75 140.84,95.75 140.78,95.69 140.78,95.56 140.84,95.5 141.2,95.5 141.27,95.43 141.27,95.31 141.2,95.24 140.84,95.24 140.78,95.18 140.78,91.7 134.01,84.92 134.01,81.39 133.08,80.46 132.17,80.46 131.97,80.26 131.55,80.26 131.26,79.97 v6(131.1,79.97)
DDR_A_D22: length 29.9
  IN1 w0.064: v6(131.1,81.55) 131.42,81.87 131.75,81.87 132.04,82.15 132.04,86.1 136.08,90.14 136.08,92.57 136.28,92.77 137.89,92.77 137.96,92.83 137.96,92.96 137.89,93.02 137.09,93.02 137.03,93.09 137.03,93.21 137.09,93.28 138.13,93.28 138.19,93.34 138.19,96.95 138.41,97.16 138.41,98.79 137.97,99.23 136.16,99.23 133.87,101.51 133.45,101.51 v12(133.07,101.89)
DDR_A_D23: length 30.3
  IN1 w0.064: v12(133.87,100.29) 135.17,98.99 137.79,98.99 138.17,98.61 138.17,97.23 137.98,97.04 137.98,96.6 137.91,96.54 137.72,96.54 137.66,96.48 137.66,96.35 137.72,96.29 137.91,96.29 137.98,96.22 137.98,96.1 137.91,96.03 137.79,96.03 137.72,95.97 137.72,95.84 137.79,95.78 137.91,95.78 137.98,95.71 137.98,95.59 137.91,95.52 137.79,95.52 137.72,95.46 137.72,95.33 137.79,95.27 137.91,95.27 137.98,95.21 137.98,95.08 137.91,95.02 137.79,95.02 137.72,94.95 137.72,94.83 137.79,94.76 137.91,94.76 137.98,94.7 137.98,94.57 137.91,94.51 137.7,94.51 137.64,94.44 137.64,94.32 137.7,94.25 137.91,94.25 137.98,94.19 137.98,94.06 137.91,94 137.2,94 137.14,93.94 137.14,93.81 137.2,93.75 137.91,93.75 137.98,93.68 137.98,93.56 137.91,93.49 136.7,93.49 136.63,93.43 136.63,93.3 136.7,93.24 136.75,93.24 136.81,93.17 136.81,93.05 136.75,92.98 136.19,92.98 135.87,92.66 135.87,90.27 131.39,85.8 131.39,82.22 130.72,81.55 v6(130.45,81.55)
DDR_A_D24: length 22.4
  IN1 w0.064: v12(137.07,96.29) 137.25,96.11 137.25,94.71 136.71,94.17 136.62,94.17 136.44,94.35 136.35,94.35 136.26,94.26 136.26,94.17 136.44,93.99 136.44,93.9 136.35,93.81 136.26,93.81 136.08,93.99 135.99,93.99 135.9,93.9 135.9,93.81 136.08,93.63 136.08,93.54 135.99,93.45 135.9,93.45 135.72,93.63 135.63,93.63 135.54,93.54 135.54,93.45 135.72,93.27 135.72,93.18 135.4,92.86 135.4,90.5 130.74,85.85 130.74,83.13 130.16,82.55 130.16,82.27 129.96,82.07 129.96,79.99 v6(129.15,79.18)
DDR_A_D25: length 21.9
  IN1 w0.061: v6(129.15,79.97) 129.15,80.02 129.55,80.42 129.55,82.49 129.89,82.84
  IN1 w0.064: v12(137.87,97.89) 137.45,97.47 136.95,97.47 136.4,96.93 136.4,94.72 135.18,93.49 135.18,90.63 130.44,85.89 130.44,83.21 130.06,82.84 129.89,82.84
DDR_A_D26: length 22.2
  IN1 w0.064: v6(128.27,79.91) 127.65,80.53 127.65,82.92 128.01,83.28 128.01,85.89 128.15,86.04 128.15,87.53 131.42,90.8 131.42,91.65 131.48,91.71 132.1,91.71 132.16,91.78 132.16,91.96 132.1,92.02 131.54,92.02 131.48,92.08 131.48,92.21 131.54,92.27 132.1,92.27 132.16,92.34 132.16,94.46 131.94,94.67 131.94,96.77 v12(133.07,97.89)
DDR_A_D27: length 21.7
  IN1 w0.064: v6(128.27,80.56) 127.82,81.01 127.82,82.87 128.22,83.27 128.22,85.73 128.38,85.89 128.38,87.46 132.37,91.45 132.37,94.18 132.44,94.24 132.82,94.24 132.89,94.3 132.89,95.2 132.82,95.26 132.22,95.26 132.16,95.33 132.16,95.45 132.22,95.52 132.82,95.52 132.89,95.58 132.89,95.71 132.82,95.77 132.22,95.77 132.16,95.84 132.16,95.96 132.22,96.03 132.82,96.03 132.89,96.09 132.89,96.91 v12(133.07,97.09)
DDR_A_D28: length 19.8
  IN1 w0.061: v6(129.15,81.55) 129.15,81.86 129.4,82.11 129.4,82.67 129.75,83.02
  IN1 w0.064: 129.75,83.02 129.75,83.38 130.26,83.89 130.26,86.04 134.96,90.75 134.96,93.64 136.11,94.79 136.11,97.15 136.85,97.89 v12(137.07,97.89)
DDR_A_D29: length 19.6
  IN1 w0.064: v6(129.15,82.43) 129.15,82.74 129.51,83.09 129.51,84.87 129.7,85.06 129.81,85.06 130.1,85.36 130.1,86.25 134.75,90.89 134.75,94.45 135.83,95.53 135.83,97.45 v12(137.07,98.69)
DDR_A_D30: length 20.3
  IN1 w0.064: v6(128.27,81.86) 127.98,82.14 127.98,82.75 128.43,83.2 128.43,85.61 128.62,85.8 128.62,87.39 132.59,91.36 132.59,93.39 132.65,93.45 132.94,93.45 133,93.52 133,93.64 132.94,93.71 132.65,93.71 132.59,93.77 132.59,93.9 132.65,93.96 133.1,93.96 133.16,94.03 133.16,96.82 133.33,96.98 133.33,98.15 v12(133.87,98.69)
DDR_A_D31: length 19.2
  IN1 w0.064: v12(133.87,97.89) 133.76,98 133.64,98 133.55,97.91 133.55,96.89 133.38,96.73 133.38,93.36 133.26,93.24 132.88,93.24 132.81,93.17 132.81,92.99 132.88,92.92 133.32,92.92 133.38,92.86 133.38,92.69 133.32,92.63 132.88,92.63 132.81,92.56 132.81,91.28 128.9,87.36 128.9,85.77 128.67,85.54 128.67,83.08 128.27,82.68 v6(128.27,82.51)
DDR_A_D32: length 25.2
  IN3 w0.064: v14(127.47,101.89) 127,101.89 126.92,101.81 126.92,101.68 127.01,101.59 127.71,101.59 127.86,101.75 128.05,101.75 128.2,101.59 128.52,101.59 128.58,101.66 128.58,101.91 128.65,101.97 128.77,101.97 128.84,101.91 128.84,101.66 128.9,101.59 129.32,101.59 130.88,100.03 130.88,91.99 130.67,91.79 130.67,91.7 130.88,91.49 130.88,91.43 130.75,91.3 130.64,91.3 130.46,91.48 130.37,91.48 130.28,91.39 130.28,91.3 130.65,90.92 130.65,90.83 130.56,90.74 130.47,90.74 130.1,91.12 130.01,91.12 129.92,91.03 129.92,90.94 130.29,90.56 130.29,90.47 126.82,87.01 126.82,86.65 126.93,86.54 126.93,86.4 126.69,86.16 126.69,85.97 126.72,85.93 126.93,85.93 v3(127.09,86.1)
  BOTTOM w0.076: UC1.CW2 v3(127.09,86.1)
DDR_A_D33: length 24.3
  IN3 w0.064: v3(127.09,86.75) 127.09,86.94 131.09,90.94 131.09,100.12 129.02,102.19 123.98,102.19 v3(123.47,102.69)
  BOTTOM w0.076: UC1.CW1 v3(127.09,86.75)
DDR_A_D34: length 27
  IN3 w0.064: v3(123.47,101.89) 123.19,101.6 123.19,100.2 123.44,99.95 124.97,99.95 125.14,99.78 128.2,99.78 129,98.98 129,94.28 128.93,94.21 128.05,94.21 127.99,94.15 127.99,94.02 128.05,93.96 128.93,93.96 129,93.89 129,93.77 128.93,93.7 127.27,93.7 127.21,93.64 127.21,89.9 125.65,88.33 125.65,84.97 125.91,84.71 v3(125.91,84.47)
DDR_A_D35: length 27.7
  IN3 w0.064: v3(125.91,83.82) 125.72,83.82 125.29,84.25 125.29,88.61 126.78,90.09 126.78,94.32 127.1,94.64 128.37,94.64 128.43,94.71 128.43,94.83 128.37,94.9 127.61,94.9 127.55,94.96 127.55,95.09 127.61,95.15 128.48,95.15 128.54,95.22 128.54,95.34 128.48,95.41 128.12,95.41 128.05,95.47 128.05,95.6 128.12,95.66 128.48,95.66 128.54,95.72 128.54,98.8 128.38,98.96 124.58,98.96 124.31,99.23 123.34,99.23 122.4,100.18 122.4,100.82 v14(122.67,101.09)
DDR_A_D36: length 27.3
  IN3 w0.064: v14(126.67,102.69) 126.94,102.42 129.09,102.42 129.63,101.89 129.72,101.89 129.98,102.14 130.07,102.14 130.16,102.05 130.16,101.96 129.9,101.71 129.9,101.62 129.99,101.53 130.08,101.53 130.34,101.78 130.43,101.78 130.52,101.69 130.52,101.6 130.26,101.35 130.26,101.26 130.35,101.17 130.44,101.17 130.7,101.42 130.79,101.42 130.88,101.33 130.88,101.24 130.62,100.99 130.62,100.9 130.71,100.81 130.8,100.81 131.06,101.06 131.15,101.06 131.24,100.97 131.24,100.88 130.98,100.63 130.98,100.54 131.31,100.21 131.31,90.83 127.48,87 127.48,86.09 127.25,85.86 127.25,84.43 v3(126.64,83.82)
DDR_A_D37: length 27
  IN3 w0.064: v3(126.28,84.15) 125.79,84.15 125.5,84.44 125.5,88.49 127,89.99 127,93.86 127.06,93.92 127.42,93.92 127.48,93.98 127.48,94.11 127.42,94.17 127.19,94.17 127.13,94.24 127.13,94.36 127.19,94.43 128.71,94.43 128.77,94.49 128.77,98.89 128.43,99.22 125.2,99.22 124.84,99.58 123.45,99.58 122.96,100.07 122.96,101.61 v3(122.67,101.89)
  BOTTOM w0.076: UC1.CW4 v3(126.28,84.15)
DDR_A_D38: length 25.5
  IN3 w0.064: v3(125.91,86.83) 125.91,88.28 127.43,89.8 127.43,92.41 127.49,92.47 129.25,92.47 129.32,92.54 129.32,92.66 129.25,92.73 127.49,92.73 127.43,92.79 127.43,92.92 127.49,92.98 129.25,92.98 129.32,93.04 129.32,93.17 129.25,93.23 127.49,93.23 127.43,93.3 127.43,93.42 127.49,93.49 129.25,93.49 129.32,93.55 129.32,98.99 128.3,100.01 126.96,100.01 v14(126.67,100.29)
  BOTTOM w0.076: UC1.CV1 v3(125.91,86.83)
DDR_A_D39: length 25.7
  IN3 w0.064: v3(126.35,86.1) 126.6,86.34 126.6,87.15 128.85,89.4 128.85,89.49 128.71,89.62 128.71,89.71 128.8,89.8 128.89,89.8 129.03,89.67 129.12,89.67 129.21,89.76 129.21,89.85 128.71,90.34 128.71,90.43 128.8,90.52 128.89,90.52 129.39,90.03 129.48,90.03 129.57,90.12 129.57,90.21 128.78,91 128.78,91.09 128.87,91.18 128.96,91.18 129.75,90.39 129.84,90.39 129.93,90.48 129.93,90.56 129.62,90.87 129.62,91.04 130.66,92.08 130.66,99.94 129.24,101.37 126.9,101.37 126.67,101.6 v3(126.67,101.89)
  BOTTOM w0.076: UC1.CV2 v3(126.35,86.1)
DDR_A_D40: length 14.7
  IN3 w0.064: v14(126.67,97.89) 127.21,97.36 127.21,96.02 125.82,94.64 125.82,91.25 125.06,90.49 125.06,90.4 125.34,90.12 125.34,90.03 125.25,89.94 125.16,89.94 124.88,90.22 124.79,90.22 124.7,90.13 124.7,90.04 124.98,89.76 124.98,89.67 124.38,89.07 124.38,86.26 124.13,86.01 v3(124.13,85.77)
DDR_A_D41: length 13.9
  IN3 w0.061: 124.13,89.4 124.4,89.67
  IN3 w0.064: 124.4,89.67 124.4,90.13 125.61,91.34 125.61,94.73 126.97,96.09 126.97,97.19 126.29,97.87 126.29,98.31 v14(126.67,98.69) ; v3(124.13,86.42) 124.13,89.4
DDR_A_D42: length 16.5
  IN3 w0.064: v3(123.39,84.47) 123.09,84.77 123.09,85.64 122.98,85.75 122.98,86.63 122.66,86.95 122.66,91.31 122.72,91.37 123.1,91.37 123.16,91.44 123.16,91.56 123.1,91.63 122.72,91.63 122.66,91.69 122.66,91.82 122.72,91.88 123.61,91.88 123.67,91.94 123.67,92.07 123.61,92.13 122.72,92.13 122.66,92.2 122.66,97.87 v14(122.67,97.89)
DDR_A_D43: length 16.4
  IN3 w0.064: v14(123.47,98.69) 123.47,98.44 123.29,98.25 123.16,98.25 122.88,98.53 122.75,98.53 122.41,98.19 122.41,86.93 122.78,86.56 122.78,84.43 v3(123.39,83.82)
DDR_A_D44: length 16.6
  IN3 w0.064: v14(127.47,97.89) 127.47,98.18 127.54,98.25 127.73,98.25 127.81,98.17 127.81,96.02 126.31,94.52 126.31,90.31 124.74,88.73 124.74,84.43 v3(124.13,83.82)
DDR_A_D45: length 15.5
  IN3 w0.064: v14(127.47,97.09) 127.6,96.97 127.6,96.11 126.04,94.55 126.04,91.16 125.77,90.9 125.77,90.81 126.09,90.49 126.09,90.4 126,90.31 125.91,90.31 125.6,90.63 125.51,90.63 125.42,90.54 125.42,90.45 125.7,90.16 125.7,90.07 124.55,88.91 124.55,86.14 124.43,86.02 124.43,84.54 124.36,84.47 v3(124.13,84.47)
DDR_A_D46: length 14.2
  IN3 w0.064: v3(123.39,86.42) 123.39,86.81 123.13,87.08 123.13,90.66 124.34,91.87 124.34,92.5 124.27,92.57 123.5,92.57 123.44,92.63 123.44,92.76 123.5,92.82 124.27,92.82 124.34,92.88 124.34,93.01 124.27,93.07 123.17,93.07 123.11,93.14 123.11,93.26 123.17,93.33 123.48,93.33 123.54,93.39 123.54,93.52 123.48,93.58 123.17,93.58 123.11,93.65 123.11,95.92 v14(123.47,96.29)
DDR_A_D47: length 14.8
  IN3 w0.064: v3(123.39,85.77) 123.13,86.03 123.13,86.75 122.9,86.98 122.9,90.74 124.12,91.96 124.12,92.29 124.06,92.35 122.94,92.35 122.87,92.41 122.87,92.54 122.94,92.6 123.16,92.6 123.22,92.67 123.22,92.79 123.16,92.86 122.94,92.86 122.89,92.91 122.89,97.31 v14(123.47,97.89)
DDR_A_D48: length 27.7
  IN1 w0.064: v12(126.67,102.69) 126.97,102.39 128.81,102.39 131.21,99.99 131.21,93.18 130.19,92.16 130.19,90.39 127.11,87.31 127.11,82.85 127.07,82.81 127.07,80.54 v6(126.44,79.91)
DDR_A_D49: length 26.6
  IN1 w0.064: v12(126.67,101.89) 126.84,102.06 126.84,102.09 126.95,102.2 128.59,102.2 130.99,99.8 130.99,93.26 129.97,92.25 129.97,90.54 126.87,87.44 126.87,80.99 v6(126.44,80.56)
DDR_A_D50: length 27.5
  IN1 w0.061: 125.51,89.67 125.51,89.49
  IN1 w0.064: v6(125.52,79.91) 124.92,80.51 124.92,82.67 124.85,82.74 124.85,88.84 125.51,89.49 ; 125.51,89.67 125.51,90.24 125.57,90.3 126.34,90.3 126.4,90.37 126.4,90.52 126.34,90.58 125.57,90.58 125.51,90.65 125.51,90.77 125.57,90.84 126.34,90.84 126.4,90.9 126.4,95.35 126.51,95.46 127.43,95.46 127.77,95.8 127.77,98.15 126.96,98.96 125.4,98.96 124.07,100.29 v12(123.47,100.29)
DDR_A_D51: length 27.4
  IN1 w0.064: v2(122.67,101.89) 122.81,101.76 122.86,101.76 123.22,101.4 123.66,101.4 125.87,99.19 127.21,99.19 127.99,98.42 127.99,95.31 127.93,95.24 126.68,95.24 126.62,95.18 126.62,95.05 126.68,94.99 126.97,94.99 127.03,94.93 127.03,94.8 126.97,94.74 126.68,94.74 126.62,94.67 126.62,90.28 125.08,88.74 125.08,81.01 v6(125.52,80.56)
DDR_A_D52: length 25.1
  IN1 w0.064: v6(126.44,81.86) 126.7,82.12 126.7,82.75 126.68,82.77 126.68,87.56 129.76,90.63 129.76,92.67 129.82,92.73 130.15,92.73 130.21,92.8 130.21,92.92 130.15,92.99 129.82,92.99 129.76,93.05 129.76,93.21 129.82,93.28 130.7,93.28 130.76,93.34 130.76,99.63 128.51,101.89 127.48,101.89 v12(127.47,101.89)
DDR_A_D53: length 25
  IN1 w0.064: v6(126.44,82.51) 126.44,87.62 129.54,90.72 129.54,93.45 129.7,93.61 130.15,93.61 130.21,93.67 130.21,93.8 130.15,93.86 129.67,93.86 129.61,93.92 129.61,94.05 129.67,94.11 130.47,94.11 130.53,94.18 130.53,94.31 130.47,94.37 130.05,94.37 129.98,94.43 129.98,94.56 130.05,94.62 130.47,94.62 130.53,94.69 130.53,99.38 128.56,101.36 127.74,101.36 v12(127.47,101.09)
DDR_A_D54: length 26
  IN1 w0.064: v6(125.52,81.86) 125.25,82.14 125.25,82.72 125.28,82.75 125.28,88.63 126.83,90.18 126.83,93.84 128.73,95.74 128.73,96.66 128.67,96.72 128.27,96.72 128.21,96.79 128.21,96.91 128.27,96.98 128.67,96.98 128.73,97.04 128.73,98.93 127.9,99.76 126.02,99.76 123.9,101.89 123.48,101.89 v12(123.47,101.89)
DDR_A_D55: length 24.9
  IN1 w0.064: v12(123.47,102.69) 123.64,102.52 123.64,102.52 126.18,99.98 128.02,99.98 128.95,99.05 128.95,95.66 127.05,93.75 127.05,90.07 125.53,88.55 125.53,83.86 125.52,83.86 v6(125.52,82.51)
DDR_A_D56: length 19.3
  IN1 w0.064: v2(126.67,97.89) 126.35,97.89 125.4,96.94 125.4,93.32 125.29,93.21 124.69,93.21 124.61,93.13 124.61,89.93 123.86,89.19 123.86,82.74 123.97,82.63 123.97,82.41 123.85,82.28 123.85,82.09 124.01,81.92 124.01,81.16 123.9,81.06 123.9,80.77 v6(123.69,80.56)
DDR_A_D57: length 21
  IN1 w0.064: v12(126.67,96.29) 125.93,95.55 125.93,92.78 125.87,92.72 125.1,92.72 125.04,92.65 125.04,92.53 125.1,92.46 125.87,92.46 125.93,92.4 125.93,92.27 125.87,92.21 125.1,92.21 125.04,92.14 125.04,92.02 125.1,91.95 125.64,91.95 125.7,91.89 125.7,91.76 125.64,91.7 125.1,91.7 125.04,91.64 125.04,89.72 124.25,88.93 124.25,82.88 124.31,82.82 124.31,82.44 124.43,82.32 124.43,82.07 124.2,81.84 124.2,80.42 v6(123.69,79.91)
DDR_A_D58: length 20.2
  IN1 w0.061: 122.51,83.18 122.51,82.87 122.38,82.74 122.38,81.81 122.17,81.6 122.17,81.29 122.78,80.68 v6(122.78,80.56) ; 122.16,89.67 122.16,89.22 122.51,88.87 122.51,88.7
  IN1 w0.064: 122.16,89.67 122.16,90.65 122.22,90.71 122.6,90.71 122.66,90.78 122.66,90.9 122.6,90.97 122.22,90.97 122.16,91.03 122.16,91.16 122.22,91.22 122.61,91.22 122.67,91.28 122.67,91.41 122.61,91.48 122.22,91.48 122.16,91.54 122.16,94.62 122.22,94.68 122.46,94.68 122.53,94.75 122.53,94.87 122.46,94.94 122.22,94.94 122.16,95 122.16,95.13 122.22,95.19 122.62,95.19 122.69,95.25 122.69,95.38 122.62,95.44 122.48,95.44 122.41,95.51 122.41,95.65 122.48,95.71 122.61,95.71 122.67,95.78 v12(122.67,97.09) ; 122.51,88.7 122.51,83.18
DDR_A_D59: length 21.1
  IN1 w0.061: v6(122.78,79.91) 122.78,79.92 122.47,80.24 122.47,80.78 122.02,81.23 122.02,81.67 122.23,81.87 122.23,83.1 122.3,83.18
  IN1 w0.064: v12(122.67,97.89) 122.67,98.8 122.59,98.89 122.4,98.89 122.34,98.82 122.34,95.94 122.24,95.84 122.02,95.84 121.94,95.76 121.94,89.06 122.3,88.7 122.3,83.18
DDR_A_D60: length 17.8
  IN1 w0.064: v12(126.67,98.69) 125.11,97.13 125.11,93.54 125,93.43 124.47,93.43 124.39,93.34 124.39,90.04 123.65,89.3 123.65,82.56 v6(123.69,82.51)
DDR_A_D61: length 18.5
  IN1 w0.064: v2(127.47,97.89) 127.07,97.49 126.4,97.49 125.64,96.73 125.64,93.04 125.59,93 124.94,93 124.82,92.88 124.82,89.81 124.07,89.06 124.07,82.77 124.15,82.68 v14(124.15,82.19)
  BOTTOM w0.076: UC1.CR8 v14(124.15,82.19)
DDR_A_D62: length 18.5
  IN1 w0.064: v12(123.47,97.89) 123.15,97.57 123.15,96.63 123.12,96.6 123.12,94.45 123.05,94.39 122.91,94.39 122.84,94.33 122.84,94.2 122.91,94.14 123.05,94.14 123.12,94.07 123.12,93.94 123.05,93.88 122.65,93.88 122.59,93.82 122.59,93.69 122.65,93.63 123.05,93.63 123.12,93.56 123.12,93.44 123.05,93.37 122.65,93.37 122.59,93.31 122.59,93.18 122.65,93.12 123.05,93.12 123.12,93.06 123.12,92.93 123.05,92.87 122.87,92.87 122.81,92.8 122.81,92.67 122.87,92.61 123.05,92.61 123.12,92.55 123.12,90.57 122.67,90.12 122.67,89.48 122.89,89.25 122.89,82.63 v6(122.78,82.51)
DDR_A_D63: length 19.3
  IN1 w0.061: v6(122.78,81.86) 122.53,82.11 122.53,82.68 122.68,82.83
  IN1 w0.064: v12(123.47,98.69) 122.93,98.15 122.93,96.72 122.9,96.69 122.9,94.82 122.37,94.29 122.37,92.89 122.44,92.82 122.53,92.82 122.59,92.76 122.59,92.63 122.53,92.57 122.44,92.57 122.37,92.51 122.37,92.38 122.44,92.32 122.82,92.32 122.89,92.25 122.89,92.13 122.82,92.06 122.44,92.06 122.37,92 122.37,91.87 122.44,91.81 122.8,91.81 122.89,91.72 122.89,90.64 122.44,90.2 122.44,89.26 122.7,89 122.7,82.84 122.68,82.83
DDR_A_DQS0: length 29.3
  IN3 w0.061: v3(131.12,84.05) 131.17,84.05 131.38,83.84 131.98,83.84 133.09,84.95 133.47,84.95 ; v14(133.87,101.09) 133.95,101.01 134.44,101.01 134.68,100.77 138.94,100.77 139.02,100.85 139.04,100.85
  IN3 w0.086: 139.04,100.85 139.3,100.85 140.48,99.66 140.48,93.18 137.44,90.14 136.89,90.14 136.7,90.34 136.58,90.34 136.39,90.15 136.39,90.03 137.28,89.14 137.28,88.76 133.47,84.95
DDR_A_DQS1: length 18.9
  IN3 w0.061: v3(128.37,85.12) 128.57,85.12 128.63,85.18 128.63,85.77 129.11,86.25 129.11,86.56 129.73,87.18 130.46,87.18 130.52,87.24
  IN3 w0.086: v14(137.07,97.09) 136.9,96.92 136.49,96.92 136.4,97.01 136.4,97.32 136.05,97.67 135.48,97.67 135.16,97.36 135.16,95.77 136.01,94.93 136.01,94.59 132.91,91.49 132.91,89.63 130.52,87.24
DDR_A_DQS2: length 30.5
  IN1 w0.061: v12(137.07,101.09) 137.22,100.94 137.49,100.94 137.59,100.84 138.87,100.84 139.04,100.68 139.15,100.68 ; 133.33,85.28 133.29,85.24 133.29,81.71 132.84,81.26 132.15,81.26 131.97,81.08 131.62,81.08 131.57,81.03 131.57,80.81 131.61,80.76 v6(131.75,80.76)
  IN1 w0.086: 139.15,100.68 140.08,99.75 140.08,95.36 139.81,95.1 139.63,95.1 139.54,95.01 139.54,94.75 139.63,94.66 139.81,94.66 140.08,94.4 140.08,93.88 139.81,93.61 139.57,93.61 139.48,93.53 139.48,93.27 139.57,93.18 139.81,93.18 140.08,92.91 140.08,92.04 139.49,91.45 139.11,91.45 138.98,91.58 138.86,91.58 138.68,91.39 138.68,91.27 138.81,91.14 138.81,90.76 138.44,90.4 138.06,90.4 137.61,90.85 137.49,90.85 137.3,90.67 137.3,90.54 137.76,90.09 137.76,89.71 133.33,85.28
DDR_A_DQS3: length 20.8
  IN1 w0.061: 129.64,86.64 129.47,86.47 129.47,85.64 129.18,85.35 129.18,83.09 128.84,82.75 128.84,81.4 128.94,81.29 128.94,80.96 v6(129.15,80.76)
  IN1 w0.086: v12(133.87,97.09) 133.98,96.98 134.46,96.98 134.53,97.05 135.1,97.05 135.35,96.8 135.35,95.73 134.89,95.28 134.4,95.28 134.27,95.14 134.27,91.27 129.64,86.64
DDR_A_DQS4: length 26.7
  IN3 w0.061: v14(123.47,101.09) 123.56,101.01 123.92,101.01 124.16,100.77 128.59,100.77 128.67,100.85 128.69,100.85 ; 126.41,87.64 126.35,87.58 126.35,86.59 126.03,86.26 126.03,85.74 126.12,85.65 126.76,85.65 127.07,85.33 127.07,84.89 126.78,84.6 126.27,84.6 126.02,84.86 126.02,85.01 v3(125.91,85.12)
  IN3 w0.086: 128.69,100.85 128.81,100.85 130.12,99.54 130.12,92.22 129.56,91.66 128.57,91.66 128.23,91.32 128.23,89.46 126.41,87.64
DDR_A_DQS5: length 15.5
  IN3 w0.061: 123.61,87.1 123.69,87.02 123.69,85.57 123.52,85.4 123.52,85.25 v3(123.39,85.12)
  IN3 w0.086: v14(126.67,97.09) 126.5,96.91 126.09,96.91 125.58,97.42 124.87,97.42 124.31,96.86 124.31,96.21 124.82,95.71 124.82,91.67 123.61,90.46 123.61,87.1
DDR_A_DQS6: length 26.3
  IN1 w0.061: v12(126.67,101.09) 126.82,100.94 127.01,100.94 127.19,100.77 128.31,100.77 128.49,100.59 128.63,100.45 128.74,100.45 128.75,100.44 ; 126.22,88.08 126.09,87.95 126.09,81.35 126.23,81.21 v6(126.44,81.21)
  IN1 w0.086: 126.22,88.08 127.84,89.7 127.84,91.19 127.99,91.34 128.82,91.34 129.06,91.58 129.06,92.36 128.81,92.6 127.93,92.6 127.84,92.69 127.84,92.95 127.93,93.04 128.74,93.04 129.02,93.32 129.02,94.28 129.77,95.02 129.77,99.42 128.75,100.44
DDR_A_DQS7: length 19.3
  IN1 w0.061: v14(122.42,81.5) 122.49,81.5 122.93,81.06 123.48,81.06 123.82,81.4 123.82,81.9 123.39,82.33 123.39,89.58 123.45,89.64 123.45,89.64 123.47,89.66 123.47,89.67
  IN1 w0.086: v12(123.47,97.09) 123.59,96.98 123.86,96.98 124.63,96.2 124.63,94.65 124.11,94.13 124.11,93.75 123.91,93.54 123.91,90.24 123.47,89.8 123.47,89.67
  BOTTOM w0.076: UC1.CN9 122.46,81.53 122.44,81.53 v14(122.42,81.5)
DDR_A_DQS#0: length 29.3
  IN3 w0.061: v3(131.76,84.26) 131.6,84.41 131.48,84.41 131.37,84.3 131.37,84.06 131.45,83.99 131.92,83.99 133.17,85.24 ; v14(133.87,100.29) 133.87,100.78 133.94,100.86 134.38,100.86 134.62,100.62 138.94,100.62 139.02,100.54 139.04,100.54
  IN3 w0.086: 133.17,85.24 133.33,85.24 136.97,88.89 136.97,89.01 136.08,89.9 136.08,90.28 136.45,90.65 136.83,90.65 137.02,90.45 137.31,90.45 140.17,93.31 140.17,99.53 139.17,100.54 139.04,100.54
DDR_A_DQS#1: length 18.9
  IN3 w0.061: v3(129.16,85.12) 128.9,85.12 128.78,85.24 128.78,85.71 129.26,86.19 129.26,86.49 129.79,87.03 130.74,87.03
  IN3 w0.086: v14(137.07,96.29) 137.07,96.54 137,96.61 136.36,96.61 136.09,96.88 136.09,97.2 135.92,97.36 135.61,97.36 135.47,97.23 135.47,95.9 136.32,95.05 136.32,94.46 133.22,91.36 133.22,89.5 130.74,87.03
DDR_A_DQS#2: length 30.6
  IN1 w0.061: 138.94,100.45 138.93,100.46 138.93,100.57 138.81,100.69 137.53,100.69 137.43,100.79 137.13,100.79 137.07,100.73 v12(137.07,100.29) ; 133.14,85.42 133.14,81.77 132.78,81.41 132.09,81.41 131.91,81.23 131.56,81.23 131.42,81.09 131.42,80.85 131.32,80.76 v6(131.1,80.76)
  IN1 w0.086: 133.14,85.42 133.14,85.53 137.45,89.84 137.45,89.96 136.99,90.42 136.99,90.79 137.36,91.16 137.74,91.16 138.19,90.71 138.31,90.71 138.5,90.89 138.5,91.01 138.37,91.14 138.37,91.52 138.73,91.89 139.11,91.89 139.24,91.76 139.36,91.76 139.77,92.16 139.77,92.79 139.69,92.87 139.44,92.87 139.17,93.14 139.17,93.66 139.44,93.92 139.69,93.92 139.77,94.01 139.77,94.27 139.69,94.35 139.5,94.35 139.23,94.62 139.23,95.14 139.5,95.41 139.69,95.41 139.77,95.49 139.77,99.62 138.94,100.45
DDR_A_DQS#3: length 20.9
  IN1 w0.061: v6(128.27,81.21) 128.58,80.89 128.72,80.89 128.79,80.96 128.79,81.23 128.69,81.34 128.69,82.82 129.03,83.16 129.03,85.41 129.32,85.7 129.32,86.76 129.36,86.8
  IN1 w0.086: 129.36,86.8 133.96,91.39 133.96,95.27 134.27,95.59 134.76,95.59 135.04,95.86 135.04,96.67 134.97,96.74 134.66,96.74 134.58,96.67 134.02,96.67 133.87,96.52 v12(133.87,96.29)
DDR_A_DQS#4: length 26.6
  IN3 w0.061: 128.69,100.54 128.61,100.62 124.1,100.62 123.86,100.86 123.55,100.86 123.47,100.78 v14(123.47,100.29) ; v3(126.64,85.12) 126.53,85.24 126.27,85.24 126.17,85.13 126.17,84.92 126.33,84.75 126.72,84.75 126.92,84.95 126.92,85.27 126.69,85.5 126.05,85.5 125.88,85.67 125.88,86.32 126.2,86.65 126.2,87.87 126.26,87.93
  IN3 w0.086: 126.26,87.93 127.92,89.59 127.92,91.45 128.44,91.97 129.43,91.97 129.81,92.35 129.81,99.42 128.69,100.54
DDR_A_DQS#5: length 15.5
  IN3 w0.061: v3(124.13,85.12) 123.78,85.12 123.67,85.24 123.67,85.34 123.84,85.51 123.84,87.18
  IN3 w0.086: 123.84,87.18 123.92,87.26 123.92,90.33 125.13,91.54 125.13,95.84 124.62,96.34 124.62,96.73 125,97.11 125.46,97.11 125.96,96.6 126.59,96.6 126.67,96.52 v14(126.67,96.29)
DDR_A_DQS#6: length 26.3
  IN1 w0.061: v12(126.67,100.29) 126.67,100.69 126.78,100.79 126.95,100.79 127.13,100.62 128.25,100.62 128.52,100.35 128.52,100.24 128.53,100.22 ; v6(125.52,81.21) 125.84,81.21 125.94,81.31 125.94,88.13
  IN1 w0.086: 128.53,100.22 129.46,99.3 129.46,95.15 128.71,94.41 128.71,93.45 128.61,93.34 127.8,93.34 127.53,93.08 127.53,92.56 127.8,92.29 128.68,92.29 128.75,92.23 128.75,91.71 128.69,91.65 127.86,91.65 127.53,91.32 127.53,89.83 125.94,88.24 125.94,88.13
DDR_A_DQS#7: length 19.4
  IN1 w0.061: 123.16,89.67 123.16,89.66 123.24,89.58 123.24,82.27 123.51,81.99 123.67,81.84 123.67,81.46 123.42,81.21 122.99,81.21 122.76,81.44 122.76,81.53 122.84,81.62 122.89,81.62 123.13,81.86 123.25,81.86 123.36,81.75 v6(123.36,81.54)
  IN1 w0.086: v12(123.47,96.29) 123.42,96.35 123.42,96.54 123.54,96.67 123.73,96.67 124.32,96.07 124.32,94.78 123.8,94.26 123.8,93.88 123.6,93.67 123.6,90.37 123.16,89.92 123.16,89.67
  BOTTOM w0.076: UC1.CR9 v6(123.36,81.54)
DDR_A_MA0: length 60.4
  TOP w0.127: UD2.P3 v8(127.07,107.09)
  IN3 w0.061: v3(116.34,85.45) 116.23,85.55 116.05,85.55 115.97,85.47 115.97,85.38 116.1,85.25 116.1,84.97 115.99,84.85 115.99,84.68 116.1,84.57 116.1,83.79 116.18,83.71 116.24,83.71 116.34,83.81 116.34,84.64 116.43,84.74
  IN3 w0.064: 121.07,106.09 121.36,106.38 121.99,106.38 122.16,106.56 122.9,106.56 123.04,106.42 123.34,106.42 123.47,106.55 v14(123.47,106.69) 123.63,106.69 123.76,106.56 124.03,106.56 124.16,106.43 125.93,106.43 126.06,106.56 126.54,106.56 v8(127.07,107.09) 127.38,106.79 128.52,106.79 129.03,106.28 132.26,106.28 132.54,106.56 133.74,106.56 v14(133.87,106.69) 134,106.56 134.43,106.56 134.56,106.43 136.32,106.43 136.45,106.56 136.93,106.56 v8(137.07,106.69) 137.14,106.76 139.17,106.76 139.43,107.02 139.43,108.35 137.46,110.32 v3(137.16,110.32)
  IN3 w0.097: 121.07,106.09 119.61,104.63 119.61,91.9 114.96,87.26 114.96,87.05 115.13,86.89 115.29,86.89 115.37,86.97 115.51,86.97 115.67,86.81 115.67,86.7 115.41,86.44 115.41,86.44 115.41,86.13 115.5,86.04 115.77,86.04 115.86,86.12 115.86,86.38 115.96,86.48 116.14,86.48 116.24,86.38 116.24,85.93 116.3,85.87 116.58,85.87 116.88,85.58 116.88,84.89 116.73,84.74 116.43,84.74
  BOTTOM w0.127: v3(116.34,85.45) 112.22,85.45 111.9,85.12 UC1.BT3
DDR_A_MA1: length 66.4
  TOP w0.127: UD1.P7 v12(136.27,106.69) ; UD2.P7 v12(125.87,106.69)
  IN1 w0.064: 121.07,106.25 121.18,106.25 121.26,106.33 121.26,106.64 121.3,106.69 121.53,106.69 121.59,106.63 121.59,106.25 121.66,106.19 121.79,106.19 121.85,106.25 121.85,106.63 121.91,106.69 122.04,106.69 122.1,106.63 122.1,106.25 122.17,106.19 122.29,106.19 122.36,106.25 122.36,106.63 122.42,106.69 122.55,106.69 122.61,106.63 122.61,106.25 122.67,106.19 122.8,106.19 122.86,106.25 122.86,106.63 122.93,106.69 123.09,106.69 123.16,106.63 123.16,106.19 123.22,106.13 123.35,106.13 123.41,106.19 123.41,106.63 UD2.P7 123.6,106.69 123.66,106.63 123.66,106.17 123.73,106.1 123.92,106.1 123.99,106.17 123.99,106.63 124.05,106.69 v14(124.27,106.69) 124.39,106.57 124.56,106.57 124.62,106.51 124.62,106.13 124.69,106.06 124.81,106.06 124.88,106.13 124.88,106.51 124.94,106.57 125.75,106.57 v12(125.87,106.69) 126.34,106.69 126.67,106.37 127.54,106.37 127.73,106.56 133.74,106.56 UD1.P7 v14(134.67,106.69) 134.79,106.57 136.15,106.57 v12(136.27,106.69) 136.69,106.69 137.02,106.37 137.93,106.37 138.13,106.56 140.38,106.56 141.18,105.76 v2(141.39,105.76)
  IN1 w0.097: v6(116.59,84.47) 116.9,84.79 116.9,86.51 116.7,86.71 116.7,90.3 117.62,91.21 117.75,91.21 117.97,90.99 118.11,90.99 118.25,91.13 118.25,91.26 118.03,91.48 118.03,91.62 118.16,91.76 118.3,91.76 118.66,91.4 118.79,91.4 118.93,91.54 118.93,91.67 118.57,92.03 118.57,92.17 118.93,92.53 118.93,104.58 119.27,104.92 119.27,105.06 118.93,105.4 118.93,105.54 119.07,105.67 119.2,105.67 119.54,105.33 119.68,105.33 119.82,105.47 119.82,105.61 118.98,106.44 118.98,106.57 119.12,106.71 119.26,106.71 120.09,105.88 120.23,105.88 120.6,106.25 121.07,106.25
  BOTTOM w0.127: UD3.P7 v14(134.67,106.69) ; UD4.P7 v14(124.27,106.69)
DDR_A_MA2: length 59.9
  IN1 w0.064: 121.07,108.8 121.32,108.8 121.39,108.74 121.39,108.48 121.45,108.41 121.58,108.41 121.64,108.48 121.64,108.74 121.71,108.8 122.19,108.8 122.25,108.74 122.25,108.35 122.32,108.29 122.45,108.29 122.51,108.35 122.51,108.74 122.57,108.8 122.71,108.8 122.78,108.73 122.78,108.38 122.86,108.3 124.69,108.3 124.75,108.23 124.75,108.1 124.69,108.03 123.21,108.03 v14(123.07,107.89) 123.21,107.76 125.98,107.76 126.25,107.49 v12(126.67,107.49) 126.81,107.63 131.48,107.63 131.74,107.89 v14(133.47,107.89) 133.95,107.89 134.09,107.76 136.38,107.76 136.64,107.49 v12(137.07,107.49) 137.2,107.63 140.27,107.63 141.3,106.6 142.28,106.6 v2(142.56,106.32)
  IN1 w0.097: 121.07,108.8 120.15,108.8 120.05,108.7 119.92,108.7 119.61,109.01 119.47,109.01 119.33,108.88 119.33,108.74 119.64,108.43 119.64,108.29 119.51,108.15 119.37,108.15 118.82,108.71 118.68,108.71 118.54,108.57 118.54,108.43 119.1,107.88 119.1,107.74 118.96,107.61 118.83,107.61 118.65,107.78 118.51,107.78 118.38,107.65 118.38,107.51 118.55,107.34 118.55,107.2 118.18,106.83 118.18,92.84 115.86,90.51 115.86,86.43 116.13,86.16 116.13,84.75 v6(115.85,84.47)
  BOTTOM w0.127: UD4.R3 v14(123.07,107.89) ; UD3.R3 v14(133.47,107.89)
DDR_A_MA3: length 68.8
  TOP w0.127: UD1.N7 v12(136.27,105.89) ; UD2.N7 v12(125.87,105.89)
  IN1 w0.064: 121.07,106 122.91,106 123.19,105.73 124.11,105.73 v14(124.27,105.89) 124.87,105.89 124.94,105.83 124.94,105.72 125,105.66 125.13,105.66 125.19,105.72 125.19,106.06 125.25,106.13 125.38,106.13 125.45,106.06 125.45,105.72 125.51,105.66 125.64,105.66 v12(125.87,105.89) 126.01,106.03 126.42,106.03 126.55,106.16 127.63,106.16 127.76,106.03 127.98,106.03 128.21,106.26 133.45,106.26 133.81,105.89 v14(134.67,105.89) 134.94,105.89 135,105.96 135,106.06 135.07,106.13 135.19,106.13 135.26,106.06 135.26,105.96 135.32,105.89 135.45,105.89 135.51,105.96 135.51,106.06 135.57,106.13 135.7,106.13 135.76,106.06 135.76,105.96 135.83,105.89 v12(136.27,105.89) 136.4,106.03 136.82,106.03 136.95,106.16 138.03,106.16 138.16,106.03 140.53,106.03 141.08,105.48 142.27,105.48 v2(142.56,105.2)
  IN1 w0.097: v6(116.59,83.82) 116.59,84.12 116.68,84.22 116.87,84.22 116.94,84.16 117.06,84.16 117.19,84.28 117.19,84.73 117.32,84.86 117.51,84.86 117.87,84.5 118.02,84.5 118.21,84.69 118.21,84.78 117.56,85.43 117.32,85.43 117.19,85.56 117.19,86.06 117.29,86.16 117.67,86.16 117.77,86.26 117.77,87.33 117.7,87.39 117.48,87.39 117.38,87.3 117.38,86.89 117.24,86.75 117.08,86.75 116.96,86.87 116.96,89.06 117.05,89.15 117.73,89.15 117.83,89.25 117.83,89.44 117.73,89.54 117.05,89.54 116.96,89.63 116.96,89.83 117.07,89.93 119.05,89.93 119.18,90.06 119.18,90.26 119.08,90.36 117.5,90.36 117.4,90.45 117.4,90.65 117.5,90.74 119.08,90.74 119.18,90.84 119.18,104.48 120.7,106 121.07,106
  BOTTOM w0.127: UD3.N7 v14(134.67,105.89) ; UD4.N7 v14(124.27,105.89)
DDR_A_MA4: length 57.3
  IN1 w0.064: v2(141.39,105.2) 140.38,105.2 139.82,105.76 138.09,105.76 137.95,105.89 v12(137.07,105.89) 136.93,105.76 136.56,105.76 136.29,105.49 v14(133.47,105.49) 133.06,105.49 132.52,106.03 129.03,106.03 128.75,105.76 127.69,105.76 127.56,105.89 v12(126.67,105.89) 126.54,105.76 126.16,105.76 125.9,105.49 v14(123.07,105.49) 122.81,105.75 121.07,105.75
  IN1 w0.097: 121.07,105.75 120.81,105.75 119.43,104.38 119.43,89.71 119.33,89.61 118.22,89.61 118.12,89.51 118.12,89.32 118.22,89.22 119.38,89.22 119.48,89.13 119.48,88.93 119.38,88.84 117.24,88.84 117.14,88.74 117.14,88.55 117.24,88.45 119.4,88.45 119.49,88.35 119.49,88.16 119.4,88.07 117.29,88.07 117.19,87.97 117.19,87.78 117.29,87.68 119.13,87.68 119.22,87.58 119.22,87.52 119,87.29 118,87.29 117.95,87.25 117.95,85.5 v6(117.9,85.45)
  BOTTOM w0.127: v6(117.9,85.45) 117.36,85.45 117.04,85.77 UC1.CD2 ; UD4.N3 v14(123.07,105.49) ; UD3.N3 v14(133.47,105.49)
DDR_A_MA5: length 70.2
  TOP w0.127: UD2.P8 123.07,106.29 v8(126.27,106.29) ; v8(136.67,106.29) 133.47,106.29 UD1.P8
  IN3 w0.064: v3(138.95,110.32) 138.95,109.33 139.64,108.64 139.64,106.93 139.27,106.56 138.16,106.56 137.89,106.29 v8(136.67,106.29) 136.53,106.16 134.4,106.16 v14(134.27,106.29) 133.09,106.29 132.83,106.03 132.38,106.03 132.27,106.14 128.87,106.14 128.45,106.56 127.76,106.56 127.5,106.29 v8(126.27,106.29) 126.14,106.16 124.01,106.16 v14(123.87,106.29) 123.72,106.14 123.72,105.98 123.66,105.92 123.48,105.92 123.41,105.99 123.41,106.19 123.34,106.25 122.97,106.25 122.84,106.38 122.73,106.38 122.27,105.92 122.27,105.81 122.44,105.64 122.44,105.48 122.33,105.37 122.28,105.37 121.91,105.74 121.91,105.83 122.1,106.01 122.1,106.1 122.01,106.19 121.92,106.19 121.73,106.01 121.64,106.01 121.47,106.17 121.38,106.17 121.29,106.08 121.29,105.99 122.08,105.21 122.08,105.12 121.99,105.03 121.9,105.03 121.26,105.67 121.18,105.67 121.09,105.58 121.09,105.49 121.6,104.97 121.6,104.88 121.54,104.82 121.16,104.82 121.07,104.92
  IN3 w0.097: v3(116.13,86.74) 116.35,86.74 116.43,86.82 116.43,87.25 116.33,87.35 116.11,87.35 116.05,87.28 116.05,87.14 115.98,87.07 115.67,87.07 115.6,87.14 115.6,87.64 115.7,87.73 116.33,87.73 116.43,87.83 116.43,87.97 116.3,88.09 116.3,88.22 118.58,90.5 118.71,90.5 118.97,90.24 119.11,90.24 119.24,90.38 119.24,90.51 118.99,90.77 118.99,90.91 119.12,91.04 119.26,91.04 119.58,90.72 119.72,90.72 119.85,90.86 119.85,91 119.53,91.32 119.53,91.45 119.85,91.77 119.85,104.45 120.61,105.2 120.79,105.2 121.07,104.92
  BOTTOM w0.127: v14(123.87,106.29) 127.07,106.29 UD4.P8 ; UC1.CD1 v3(116.13,86.74) ; v14(134.27,106.29) 137.47,106.29 UD3.P8
DDR_A_MA6: length 59.2
  IN1 w0.064: v2(142.56,105.76) 142.28,106.04 141.3,106.04 140.51,106.83 138,106.83 v12(137.87,106.69) 137.52,106.69 137.25,106.96 136.13,106.96 136,106.83 135.76,106.83 135.49,107.09 v14(133.47,107.09) 133.2,106.83 127.61,106.83 v12(127.47,106.69) 127.02,106.69 126.76,106.96 125.73,106.96 125.6,106.83 125.36,106.83 125.1,107.09 v14(123.07,107.09) 122.83,107.09 122.77,107.16 122.77,107.4 122.7,107.46 122.57,107.46 122.51,107.4 122.51,107.16 122.45,107.09 122.32,107.09 122.26,107.16 122.26,107.71 122.19,107.78 122.07,107.78 122,107.71 122,107.08 121.94,107.02 121.81,107.02 121.75,107.08 121.75,107.71 121.38,108.08 121.26,108.08 121.14,107.97 121.14,107.89 121.5,107.54 121.5,107.21 121.43,107.14 121.24,107.14 121.19,107.19 121.19,107.39 121.07,107.52
  IN1 w0.097: 121.07,107.52 120.59,108 120.37,108 120.24,107.87 120.24,107.73 121.04,106.93 121.04,106.8 120.9,106.66 120.76,106.66 119.81,107.61 119.67,107.61 119.53,107.48 119.53,107.34 120.37,106.51 120.37,106.37 120.23,106.23 120.09,106.23 119.26,107.07 119.12,107.07 118.68,106.62 118.68,106.39 118.97,106.1 118.97,105.93 118.68,105.64 118.68,105.3 118.85,105.13 118.85,104.85 118.68,104.68 118.68,92.63 116.42,90.36 116.42,86.58 116.59,86.41 v6(116.59,85.12)
  BOTTOM w0.127: UD3.P2 v14(133.47,107.09) ; UD4.P2 v14(123.07,107.09)
DDR_A_MA7: length 69.7
  TOP w0.127: UD1.R8 133.47,107.89 v8(136.67,107.89) ; v8(126.27,107.89) 123.07,107.89 UD2.R8
  IN3 w0.064: v3(133.54,110.32) 134.25,109.61 137.14,109.61 137.74,109 137.74,108.54 137.36,108.16 136.93,108.16 v8(136.67,107.89) 136.46,108.1 134.48,108.1 v14(134.27,107.89) 133.89,107.89 133.61,108.17 133.25,108.17 133.11,108.03 131.92,108.03 131.56,108.39 127.54,108.39 127.31,108.16 126.54,108.16 v8(126.27,107.89) 126.01,107.89 125.81,108.08 124.78,108.08 124.62,107.92 123.9,107.92 v14(123.87,107.89) 123.49,107.89 123.21,108.17 122.99,108.17 122.53,108.63 121.65,108.63 121.07,108.04
  IN3 w0.097: 121.07,108.04 119.26,106.23 119.26,105.06 119.11,104.91 119.11,102.64 119.01,102.54 118.9,102.54 118.8,102.45 118.8,102.25 118.9,102.16 119.01,102.16 119.11,102.06 119.11,101.87 119.01,101.77 118.9,101.77 118.8,101.67 118.8,101.48 118.9,101.38 119.01,101.38 119.11,101.29 119.11,101.09 119.01,101 118.9,101 118.8,100.9 118.8,100.71 118.9,100.61 119.01,100.61 119.11,100.52 119.11,100.32 119.01,100.23 118.9,100.23 118.8,100.13 118.8,99.94 118.9,99.84 119.01,99.84 119.11,99.74 119.11,99.55 119.01,99.45 118.9,99.45 118.8,99.36 118.8,99.16 118.9,99.07 119.01,99.07 119.11,98.97 119.11,98.78 119.01,98.68 118.9,98.68 118.8,98.59 118.8,98.39 118.9,98.3 119.01,98.3 119.11,98.2 119.11,98.01 119.01,97.91 118.9,97.91 118.8,97.81 118.8,97.62 118.9,97.52 119.01,97.52 119.11,97.43 119.11,97.23 119.01,97.14 118.9,97.14 118.8,97.04 118.8,96.85 118.9,96.75 119.01,96.75 119.11,96.65 119.11,96.46 119.01,96.37 118.9,96.37 118.8,96.27 118.8,96.08 118.9,95.98 119.01,95.98 119.11,95.88 119.11,95.69 119.01,95.59 118.9,95.59 118.8,95.5 118.8,95.3 118.9,95.21 119.01,95.21 119.11,95.11 119.11,94.92 119.01,94.82 118.9,94.82 118.8,94.72 118.8,94.53 118.9,94.43 119.01,94.43 119.11,94.34 119.11,94.15 119.01,94.05 118.9,94.05 118.8,93.95 118.8,93.76 118.9,93.66 119.01,93.66 119.11,93.57 119.11,93.37 119.01,93.28 118.9,93.28 118.8,93.18 118.8,92.99 118.9,92.89 119.01,92.89 119.11,92.79 119.11,92.59 119.04,92.53 118.91,92.53 118.8,92.43 118.8,92.22 118.94,92.09 118.94,91.95 118.8,91.82 118.66,91.82 118.5,91.98 118.36,91.98 114.5,88.12 v3(114.5,86.75)
  BOTTOM w0.127: UD4.R8 127.07,107.89 v14(123.87,107.89) ; UC1.CC1 115.52,86.75 v3(114.5,86.75) ; v14(134.27,107.89) 137.47,107.89 UD3.R8
DDR_A_MA8: length 57.6
  TOP w0.127: UD2.R2 v8(127.07,107.89) ; UD1.R2 v8(137.47,107.89)
  IN3 w0.064: 121.07,107.35 121.15,107.35 121.21,107.41 121.21,107.91 121.27,107.97 121.4,107.97 121.46,107.91 121.46,107.41 121.53,107.35 121.66,107.35 121.72,107.41 121.72,107.97 121.78,108.03 121.91,108.03 121.97,107.97 121.97,107.41 122.04,107.35 122.22,107.35 122.27,107.4 122.27,108.4 122.34,108.46 122.47,108.46 122.59,108.34 122.59,107.58 v14(122.67,107.49) 122.81,107.63 123.98,107.63 124.11,107.75 125.7,107.75 125.83,107.63 126.45,107.63 126.71,107.89 v8(127.07,107.89) 127.42,107.89 127.68,108.16 130.97,108.16 131.37,107.76 132.8,107.76 v14(133.07,107.49) 133.2,107.63 134.38,107.63 134.51,107.76 136.09,107.76 136.23,107.63 136.84,107.63 137.11,107.89 v8(137.47,107.89) 137.94,108.37 137.94,109.1 137.26,109.78 135.86,109.78 v3(135.33,110.32)
  IN3 w0.097: 121.07,107.35 120.9,107.35 119.51,105.95 119.51,104.96 119.36,104.81 119.36,92.01 118.71,91.36 118.57,91.36 118.41,91.52 118.27,91.52 118.14,91.39 118.14,91.25 118.3,91.09 118.3,90.95 118.16,90.81 118.03,90.81 117.86,90.98 117.73,90.98 117.59,90.84 117.59,90.7 117.75,90.54 117.75,90.4 117.62,90.27 117.48,90.27 117.32,90.43 117.18,90.43 117.04,90.29 117.04,90.16 117.21,89.99 117.21,89.86 117.07,89.72 116.93,89.72 116.77,89.88 116.63,89.88 116.5,89.75 116.5,89.61 116.66,89.45 116.66,89.31 116.52,89.17 116.39,89.17 116.22,89.34 116.09,89.34 115.95,89.2 115.95,89.07 116.12,88.9 116.12,88.77 115.98,88.63 115.84,88.63 115.68,88.79 115.54,88.79 115.41,88.66 115.41,88.52 115.57,88.36 115.57,88.22 115.43,88.08 115.3,88.08 115.13,88.25 115,88.25 114.86,88.11 114.86,87.97 115.02,87.81 115.02,87.67 114.78,87.43 114.78,86.61 114.63,86.46 114.63,86.21 114.78,86.06 115.22,86.06 115.58,85.7 115.58,85.53 115.45,85.4 115.45,85.23 115.56,85.12 v13(115.85,85.12)
DDR_A_MA9: length 66.7
  TOP w0.127: UD1.R7 v12(136.27,107.49) ; UD2.R7 v12(125.87,107.49)
  IN1 w0.064: 121.07,108.25 121.49,108.25 121.7,108.03 122.27,108.03 122.4,107.91 122.46,107.91 122.59,108.03 122.7,108.03 122.78,107.95 122.78,107.85 122.72,107.78 122.72,107.69 122.91,107.49 123.45,107.49 123.67,107.27 124.05,107.27 v14(124.27,107.49) 124.67,107.49 124.73,107.43 124.73,107.32 124.8,107.26 124.92,107.26 124.99,107.32 124.99,107.45 125.13,107.59 125.78,107.59 v12(125.87,107.49) 126.14,107.23 126.82,107.23 126.96,107.37 127.43,107.37 127.67,107.13 128.33,107.13 128.56,107.36 128.95,107.36 129.08,107.23 133.22,107.23 133.35,107.36 133.73,107.36 UD1.R7 v14(134.67,107.49) 134.98,107.49 135.04,107.43 135.04,107.32 135.1,107.26 135.23,107.26 135.29,107.32 135.29,107.43 135.36,107.49 v12(136.27,107.49) 136.53,107.23 137.21,107.23 137.34,107.36 140.34,107.36 141.38,106.32 v2(141.39,106.32)
  IN1 w0.097: v6(118.36,84.47) 118.36,84.53 118.56,84.73 118.77,84.73 118.81,84.69 118.81,84.39 119.22,83.97 119.22,83.71 119.03,83.52 118.72,83.52 118.59,83.65 118.59,83.97 118.46,84.09 118.21,84.09 118.14,84.03 118.14,83.58 118.08,83.52 117.83,83.52 117.74,83.61 117.74,84.14 117.68,84.2 117.46,84.2 117.21,83.95 117.21,83.65 117.09,83.53 116.47,83.53 116.32,83.69 116.32,86.31 116.16,86.47 116.16,90.46 118.43,92.73 118.43,106.73 119.95,108.25 121.07,108.25
  BOTTOM w0.127: UD4.R7 v14(124.27,107.49) ; UD3.R7 v14(134.67,107.49)
DDR_A_MA10: length 61.2
  TOP w0.127: UD1.M3 v8(137.47,105.49) ; UD2.M3 v8(127.07,105.49)
  IN3 w0.064: v3(142.55,109.49) 142.3,109.24 142.11,109.24 140.53,107.66 140.53,106.59 139.14,105.19 137.77,105.19 v8(137.47,105.49) 136.93,104.96 134.95,104.96 134.82,104.83 134.55,104.83 134.28,105.09 v14(133.87,105.09) 133.73,105.23 133.07,105.23 132.94,105.36 132.04,105.36 131.91,105.23 127.72,105.23 127.45,105.49 v8(127.07,105.49) 126.54,104.96 124.56,104.96 124.43,104.83 124.15,104.83 123.89,105.09 v14(123.47,105.09) 123.34,105.23 122.9,105.23 121.83,104.16 121.07,104.16
  IN3 w0.097: 121.07,104.16 120.86,104.16 120.6,103.89 120.6,103.43 120.7,103.33 120.97,103.33 121.07,103.23 121.07,103.04 120.97,102.94 120.7,102.94 120.6,102.85 120.6,102.65 120.7,102.56 120.98,102.56 121.08,102.46 121.08,102.27 120.98,102.17 120.7,102.17 120.6,102.07 120.6,89.91 120.18,89.49 118.9,89.49 118.34,88.93 118.34,88.28 118.27,88.22 117.64,88.22 117.57,88.16 117.57,87.84 117.64,87.78 118.65,87.78 118.72,87.84 118.72,88.22 118.78,88.28 119.11,88.28 119.17,88.22 119.17,87.7 119.86,87.01 119.86,86.93 119.61,86.68 119.5,86.68 118.87,87.3 118.25,87.3 118.07,87.11 117.95,87.11 117.73,87.33 117.45,87.33 117.38,87.27 117.38,87.13 117.57,86.94 117.57,86.82 117.43,86.68 117.09,86.68 v3(117.03,86.74)
  BOTTOM w0.127: UC1.BT2 111.89,86.11 111.89,86.33 112.29,86.73 114.09,86.73 114.39,87.03 116.27,87.03 116.55,86.74 v3(117.03,86.74)
DDR_A_MA11: length 57
  IN1 w0.064: 121.07,109.05 125.89,109.05 125.96,108.98 125.96,108.79 125.89,108.73 123.11,108.73 v14(123.07,108.69) 123.3,108.46 125.03,108.46 125.07,108.43 127.34,108.43 v12(127.47,108.29) 130.88,108.29 131.14,108.56 133.04,108.56 133.17,108.69 v14(133.47,108.69) 134.05,108.69 134.34,108.41 137.75,108.41 v12(137.87,108.29) 138.04,108.46 139.8,108.46 v2(141.39,106.87)
  IN1 w0.097: 121.07,109.05 119.92,109.05 119.71,109.26 118.59,109.26 118.32,109 117.73,109 117.64,108.9 117.64,108.7 117.73,108.6 118,108.6 118.13,108.48 118.13,107.13 117.93,106.93 117.93,92.94 115.56,90.56 115.56,86.47 115.85,86.17 v6(115.85,85.77)
  BOTTOM w0.127: UD4.T2 v14(123.07,108.69) ; UD3.T2 v14(133.47,108.69)
DDR_A_MA12: length 67.7
  TOP w0.127: UD1.M7 v12(136.27,105.09) ; UD2.M7 v12(125.87,105.09)
  IN1 w0.064: v2(142.56,104.64) 142.29,104.91 139.99,104.91 139.72,105.18 138.16,105.18 137.98,105.36 137.76,105.36 137.63,105.23 136.4,105.23 v12(136.27,105.09) 136.09,105.27 134.85,105.27 v14(134.67,105.09) 134.65,105.07 134.49,105.07 134.44,105.12 133.39,105.12 133.28,105.23 132.56,105.23 132.01,105.77 130.94,105.77 130.39,105.23 127.74,105.23 127.61,105.36 127.36,105.36 127.23,105.23 126.01,105.23 v12(125.87,105.09) 125.77,104.99 124.97,104.99 124.91,105.06 124.91,105.11 124.85,105.17 124.72,105.17 124.66,105.11 124.66,105.06 124.59,104.99 124.37,104.99 v14(124.27,105.09) 124.14,105.23 121.19,105.23 121.13,105.29 121.07,105.29
  IN1 w0.097: v6(119.1,84.47) 119.1,84.66 118.96,84.8 118.69,85.07 118.62,85.07 118.46,84.92 118.34,84.92 118.2,85.05 118.2,86.82 118.4,87.01 118.9,87.01 118.91,86.99 119.05,86.99 119.33,87.28 119.47,87.28 119.61,87.14 119.61,87 119.32,86.72 119.32,86.58 119.46,86.44 119.61,86.44 119.85,86.69 120.16,86.69 120.44,86.4 120.44,86.24 120.35,86.14 119.86,86.14 119.71,86 119.71,86 119.71,85.64 119.86,85.49 120.16,85.49 120.48,85.81 120.62,85.81 120.68,85.74 120.68,85.21 120.59,85.11 120.38,85.11 120.28,85.01 120.28,84.82 120.38,84.72 120.59,84.72 120.68,84.63 120.68,84.07 120.78,83.97 121.05,83.97 121.14,84.07 121.14,86.68 121.07,86.76 120.68,86.76 119.68,87.76 119.68,104.11 120.86,105.29 121.07,105.29
  BOTTOM w0.127: UD4.M7 v14(124.27,105.09) ; UD3.M7 v14(134.67,105.09)
