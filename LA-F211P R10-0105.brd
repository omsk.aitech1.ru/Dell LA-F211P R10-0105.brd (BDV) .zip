# Allegro board LA-F211P R10-0105.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_MA13: length 68.8
  TOP w0.127: v8(126.27,108.69) 123.07,108.69 UD2.T8 ; v8(136.67,108.69) 133.47,108.69 UD1.T8
  IN3 w0.064: 121.07,108.81 121.27,109.02 123.24,109.02 123.56,108.69 v14(123.87,108.69) v8(126.27,108.69) 126.54,108.69 126.8,108.96 133.7,108.96 133.96,108.69 v14(134.27,108.69) v8(136.67,108.69) 136.81,108.84 136.81,108.98 136.68,109.12 133.79,109.12 133.46,109.45 131.99,109.45 v3(131.12,110.32)
  IN3 w0.097: v3(114.39,88.73) 118.31,92.65 118.31,102.69 118.61,102.99 118.61,105.12 118.76,105.27 118.76,106.51 121.07,108.81
  BOTTOM w0.127: v14(134.27,108.69) 137.47,108.69 UD3.T8 ; v14(123.87,108.69) 127.07,108.69 UD4.T8 ; UC1.BM3 108.65,85.51 108.65,86.65 110.73,88.73 v1(113.32,88.73) v3(114.39,88.73)
DDR_A_MA14: length 62.5
  TOP w0.127: UD1.L2 v8(137.47,104.69) ; UD2.L2 v8(127.07,104.69)
  IN3 w0.061: 119.61,86.41 119.57,86.38 119.45,86.38 118.83,86.99 118.19,86.99 117.95,86.76 117.95,86.08 118.02,86.02 118.4,86.02 118.46,86.08 118.46,86.38 118.53,86.44 118.84,86.44 119.48,85.81 119.48,85.3 119.41,85.23 118.98,85.23 118.91,85.16 118.91,85.07 118.98,84.99 119.42,84.99 119.48,84.93 119.48,84.79 119.41,84.72 118.34,84.72 118.12,84.94 118.12,85.22 118.21,85.31 118.21,85.55 118.06,85.7 117.9,85.7 117.5,86.1 v6(117.03,86.1)
  IN3 w0.064: 121.57,102.51 121.57,102.76 122.67,103.86 v14(122.67,104.29) 122.81,104.43 123.29,104.43 123.51,104.2 123.99,104.2 124.16,104.03 124.75,104.03 125.14,104.41 126.79,104.41 v8(127.07,104.69) 127.19,104.57 131.53,104.57 131.68,104.42 132.94,104.42 v14(133.07,104.29) 133.2,104.43 133.68,104.43 133.91,104.2 134.38,104.2 134.56,104.03 135.15,104.03 135.54,104.41 137.19,104.41 v8(137.47,104.69) 137.53,104.75 139.25,104.75 141.27,106.77 141.27,107.26 142.11,108.1 142.3,108.1 v3(142.55,108.35)
  IN3 w0.097: 121.57,102.51 121.57,101.94 121.1,101.47 121.1,99.55 121.26,99.4 121.46,99.4 121.59,99.27 121.59,99.09 121.45,98.95 121.19,98.95 121.1,98.86 121.1,89.46 120.49,88.86 119.61,88.86 119.36,88.61 119.36,87.9 120.05,87.2 120.05,86.86 119.61,86.41
  BOTTOM w0.127: UC1.BR4 111.15,84.8 111.15,85.15 111.46,85.45 111.77,85.45 111.97,85.65 111.97,85.8 112.26,86.1 v6(117.03,86.1)
DDR_A_MA15: length 67
  TOP w0.127: v8(126.27,104.69) 123.07,104.69 UD2.M8 ; v8(136.67,104.69) 133.47,104.69 UD1.M8
  IN3 w0.064: v3(142.55,108.92) 142.3,108.67 142.11,108.67 140.87,107.43 140.87,106.63 139.2,104.96 137.36,104.96 137.09,104.69 v8(136.67,104.69) v14(135.07,104.69) 134.93,104.56 134.56,104.56 134.4,104.4 134.12,104.4 133.79,104.73 133.79,104.75 133.58,104.96 133.21,104.96 132.94,104.69 131.95,104.69 131.68,104.96 126.96,104.96 126.7,104.69 v8(126.27,104.69) v14(124.67,104.69) 124.58,104.69 124.51,104.63 124.18,104.63 123.98,104.43 123.71,104.43 123.18,104.96 122.97,104.96 121.95,103.94 121.95,103.4 121.32,102.77 121.32,102.76
  IN3 w0.097: v3(118.84,88.6) 119.41,89.17 120.37,89.17 120.85,89.66 120.85,101.57 121.32,102.04 121.32,102.76
  BOTTOM w0.127: UD3.M8 137.47,104.69 v14(135.07,104.69) ; UD4.M8 127.07,104.69 v14(124.67,104.69) ; v3(118.84,88.6) 118.39,89.06 v1(111.73,89.06) 110.53,89.06 108.31,86.83 UC1.BL1
DDR_A_MA16: length 72.5
  TOP w0.127: UD2.L8 123.07,103.89 v8(126.27,103.89) ; UD1.L8 133.47,103.89 v8(136.67,103.89)
  IN3 w0.064: 122.27,102.32 122.27,102.66 123.51,103.89 v14(123.87,103.89) 123.94,103.83 125.12,103.83 125.19,103.89 v8(126.27,103.89) 126.54,104.16 132.78,104.16 132.93,104.01 133.16,104.01 133.31,104.16 133.58,104.16 133.84,103.89 v14(134.27,103.89) 134.45,103.71 135.69,103.71 135.76,103.78 135.76,104.1 135.82,104.16 135.95,104.16 136.01,104.1 136.01,103.78 136.07,103.71 136.49,103.71 v8(136.67,103.89) 136.98,104.2 137.42,104.2 137.78,104.55 139.33,104.55 142.21,107.44 v3(142.72,107.44)
  IN3 w0.097: v3(117.92,84.8) 117.92,84.44 118.16,84.21 119.6,84.21 119.73,84.33 119.73,85.26 119.85,85.39 120.33,85.39 120.43,85.29 120.43,84.32 120.53,84.22 120.81,84.22 120.9,84.32 120.9,84.7 121,84.8 121.13,84.8 121.26,84.92 121.26,85.96 121.16,86.06 120.49,86.06 120.3,86.25 120.3,87.27 119.54,88.03 119.54,88.39 119.76,88.6 120.62,88.6 121.35,89.33 121.35,98.49 121.84,98.98 121.84,99.37 121.44,99.78 121.44,101.45 122.27,102.29 122.27,102.32
  BOTTOM w0.127: UD3.L8 137.47,103.89 v14(134.27,103.89) ; v14(123.87,103.89) 127.07,103.89 UD4.L8 ; UC1.BT4 111.88,84.8 v3(117.92,84.8)
DDR_A_ODT0: length 59.5
  TOP w0.127: UD2.K3 v8(127.07,103.89) ; UD1.K3 v8(137.47,103.89)
  IN3 w0.064: 122.65,102.32 122.72,102.38 122.73,102.38 123.47,103.12 v14(123.47,103.49) 126.3,103.49 126.7,103.89 v8(127.07,103.89) 127.21,103.76 128.43,103.76 128.7,103.49 v14(133.87,103.49) 134.27,103.49 134.53,103.24 134.53,102.95 134.59,102.89 134.72,102.89 134.78,102.95 134.78,103.14 134.85,103.21 135.1,103.21 135.23,103.08 137.32,103.08 137.47,103.23 v8(137.47,103.89) 139.05,103.89 140.8,105.64 v3(142.97,105.64)
  IN3 w0.097: v3(119.86,88.28) 120.3,87.84 120.49,87.84 120.56,87.78 120.56,86.77 120.68,86.65 120.92,86.65 121.02,86.74 121.02,88.74 121.6,89.32 121.6,98.39 122.09,98.88 122.09,99.47 121.68,99.88 121.68,101.35 122.65,102.32
  BOTTOM w0.127: v3(119.86,88.28) 118.55,89.59 v1(110.33,89.59) 110.31,89.59 107.81,87.09 107.81,85.62 UC1.BL3
DDR_A_PARITY: length 54.7
  TOP w0.127: UD1.T3 v8(137.47,108.69) ; UD2.T3 v8(127.07,108.69)
  IN3 w0.064: v3(132.91,110.32) 133.8,109.43 137,109.43 137.47,108.96 v8(137.47,108.69) 137.2,108.43 134.34,108.43 134.2,108.29 v14(133.87,108.29) 133.73,108.43 133.36,108.43 133.09,108.69 v8(127.07,108.69) 126.81,108.43 123.61,108.43 v14(123.47,108.29) 123.35,108.41 122.98,108.41 122.6,108.79 121.4,108.79 121.07,108.46
  IN3 w0.097: v3(113.81,88.13) 113.82,88.12 114.16,88.12 118.56,92.52 118.56,102.59 118.86,102.89 118.86,105.02 119.01,105.17 119.01,106.4 121.07,108.46
  BOTTOM w0.127: v3(113.81,88.13) 111.06,88.13 109.56,86.63 109.56,85.63 109.76,85.43 110.52,85.43 UC1.BR3
DDR_B_ACT#: length 65.2
  IN1 w0.064: 113.57,104.12 113.26,104.43 111.31,104.43 v12(111.17,104.29) 111.04,104.43 110.63,104.43 110.39,104.66 108.4,104.66 v6(108.37,104.69) 108.11,104.43 107.46,104.43 107.17,104.71 101.57,104.71 101.29,104.43 100.91,104.43 v12(100.78,104.29) 100.64,104.43 100.23,104.43 100.1,104.56 98.11,104.56 v6(97.98,104.69) 97.71,104.43 97.07,104.43 96.78,104.71 v2(93.19,104.71)
  IN1 w0.097: v6(118.21,81.21) 117.87,80.87 117.87,80.41 117.8,80.34 117.8,80.27 117.32,79.79 116.84,79.79 116.75,79.89 116.75,80.2 116.65,80.3 116.25,80.3 115.96,80.59 115.96,81.42 115.62,81.76 113.99,81.76 113.81,81.58 113.49,81.58 112.89,82.18 111.62,82.18 111.08,82.72 111.08,87.01 112.47,88.39 112.47,92.77 112.68,92.98 112.68,93.53 114.04,94.89 114.04,96.52 114.16,96.63 114.16,99.54 114.25,99.63 115.08,99.63 115.18,99.73 115.18,99.92 115.08,100.02 114.25,100.02 114.16,100.12 114.16,100.31 114.25,100.4 115.08,100.4 115.18,100.5 115.18,100.69 115.08,100.79 114.25,100.79 114.16,100.89 114.16,101.09 114.25,101.18 115.08,101.18 115.18,101.28 115.18,101.47 115.08,101.57 114.25,101.57 114.16,101.66 114.16,101.86 114.25,101.95 115.08,101.95 115.18,102.05 115.18,102.24 115.08,102.34 114.25,102.34 114.16,102.44 114.16,102.67 114.25,102.76 114.91,102.76 115.01,102.86 115.01,103.12 114.92,103.21 113.93,103.21 113.83,103.31 113.83,103.58 113.9,103.65 114.05,103.65 114.15,103.75 114.15,103.98 114.06,104.07 113.61,104.07 113.57,104.12
  BOTTOM w0.127: UD8.L3 v6(97.98,104.69) ; UD7.L3 v6(108.37,104.69)
DDR_B_ALERT#: length 99.3
  TOP w0.127: v8(99.58,107.09) 96.38,107.09 UD6.P9 ; UD5.P9 106.77,107.09 v8(109.97,107.09)
  IN3 w0.064: v6(117.29,81.86) 116.77,81.86 116.48,82.15 115.29,82.15 115.13,82.3 115.13,83.58 115.15,83.59 115.15,83.6 115.29,83.73 115.29,84.59 115.03,84.84 114.8,84.84 113.36,86.29 113.36,86.52 113.19,86.68 113.19,89.05 117.35,93.21 117.35,106.93 114.83,109.46 94.95,109.46 94.89,109.41 94.58,109.41 94.33,109.66 93.09,109.66 92.29,108.86 91.95,108.86 91.78,108.68 91.78,108.46 91.95,108.29 92.51,108.29 92.83,107.96 94.1,107.96 94.86,107.2 96.86,107.2 97.02,107.36 97.71,107.36 v14(97.98,107.09) 98.03,107.09 98.15,107.21 98.59,107.21 98.71,107.09 v8(99.58,107.09) 100.45,107.09 100.96,107.61 101.58,107.61 101.81,107.38 105.29,107.38 105.48,107.2 107.31,107.2 107.46,107.36 108.11,107.36 v14(108.37,107.09) 108.43,107.09 108.54,107.21 109.86,107.21 v8(109.97,107.09) 110.84,107.09 111.36,107.61 111.98,107.61 112.2,107.38 113.38,107.38 114.89,105.87 v6(114.89,105.85)
  BOTTOM w0.127: UD8.P9 101.98,107.09 v14(97.98,107.09) ; UD7.P9 112.37,107.09 v14(108.37,107.09)
DDR_B_BA0: length 51.2
  TOP w0.127: UD6.N2 v8(101.98,106.29) ; UD5.N2 v8(112.37,106.29)
  IN3 w0.064: v3(93.19,106.39) 94.06,106.39 94.66,105.79 96.67,105.79 v14(96.78,105.89) 96.91,106.02 97.87,106.02 98.27,105.63 100.14,105.63 100.51,106 101.68,106 v8(101.98,106.29) 104.99,106.29 105.41,105.87 106.07,105.87 106.13,105.81 107.09,105.81 v14(107.17,105.89) 107.3,106.02 108.27,106.02 108.66,105.63 110.53,105.63 110.9,106 112.08,106 v8(112.37,106.29) 112.66,106 113.29,106 113.57,105.72
  IN3 w0.097: v3(111.81,81.86) 112,81.86 112.34,82.2 112.34,82.82 111.48,83.68 111.48,84.54 110.39,85.62 110.39,88.3 110.17,88.52 110.17,88.99 115.37,94.19 115.37,103.92 113.57,105.72
DDR_B_BA1: length 67.1
  TOP w0.127: UD5.N8 107.57,105.49 v8(110.77,105.49) ; UD6.N8 97.18,105.49 v8(100.38,105.49)
  IN3 w0.064: 113.57,105.37 113.57,105.46 113.23,105.8 112.3,105.8 112.25,105.76 111.04,105.76 v8(110.77,105.49) 110.64,105.36 108.51,105.36 v14(108.37,105.49) 108.02,105.49 107.69,105.82 107.5,105.82 107.26,105.58 105.37,105.58 105.19,105.76 100.64,105.76 v8(100.38,105.49) 100.24,105.36 98.11,105.36 v14(97.98,105.49) 97.62,105.49 97.36,105.76 97.05,105.76 96.85,105.56 94.45,105.56 93.89,106.11 92.44,106.11 92.32,106.24 v3(92.04,106.24)
  IN3 w0.097: v3(111.81,81.21) 111.51,81.21 111.35,81.37 111.35,81.81 111.66,82.12 111.99,82.12 112.09,82.22 112.09,82.81 111.99,82.91 111.45,82.91 111.29,83.06 111.29,83.28 111.29,83.28 111.29,84.46 110.21,85.55 110.21,88.22 109.98,88.44 109.98,89.16 110.18,89.35 115.12,94.3 115.12,103.82 113.57,105.37
  BOTTOM w0.127: v14(108.37,105.49) 111.57,105.49 UD7.N8 ; UD8.N8 101.18,105.49 v14(97.98,105.49)
DDR_B_BG0: length 65
  IN1 w0.061: v6(117.29,81.21) 117.45,81.06 117.45,80.89 117.36,80.81 116.29,80.81 116.13,80.96 116.13,81.65 115.93,81.85
  IN1 w0.064: v2(93.19,105.27) 93.6,104.86 97.01,104.86 v14(97.18,104.69) 97.6,104.69 97.86,104.96 98.13,104.96 98.26,104.83 100.13,104.83 100.26,104.96 101.44,104.96 v12(101.58,105.09) 101.68,104.99 107.28,104.99 v14(107.57,104.69) 107.84,104.96 108.52,104.96 108.65,104.83 110.52,104.83 110.65,104.96 111.84,104.96 v12(111.97,105.09) 111.97,104.72 112.1,104.59 113.57,104.59
  IN1 w0.097: 113.57,104.59 113.89,104.59 115.43,103.05 115.43,99.48 115.33,99.38 114.5,99.38 114.41,99.29 114.41,99.09 114.5,99 115.33,99 115.43,98.9 115.43,98.71 115.33,98.61 114.5,98.61 114.41,98.52 114.41,98.32 114.5,98.23 115.33,98.23 115.43,98.13 115.43,97.94 115.33,97.84 114.5,97.84 114.41,97.74 114.41,97.55 114.5,97.45 115.33,97.45 115.43,97.36 115.43,97.12 115.33,97.02 114.5,97.02 114.41,96.93 114.41,96.7 114.5,96.61 115.34,96.61 115.44,96.51 115.44,96.32 115.34,96.22 114.39,96.22 114.29,96.13 114.29,95.93 114.39,95.84 115.34,95.84 115.44,95.74 115.44,95.55 115.34,95.45 114.39,95.45 114.29,95.35 114.29,94.78 112.93,93.43 112.93,92.88 112.72,92.66 112.72,88.22 111.37,86.87 111.37,83.69 111.29,83.61 111.29,83.01 111.89,82.41 113.24,82.41 113.47,82.17 113.84,82.17 114.03,81.98 115.8,81.98 115.93,81.85
  BOTTOM w0.127: UD7.M2 v14(107.57,104.69) ; UD8.M2 v14(97.18,104.69)
DDR_B_BG1: length 61.4
  TOP w0.127: v7(104.85,103.59) 104.61,103.35 RD248.2
  TOP w0.191: v7(114.31,103.5) 114.63,103.82 RD246.2
  GND2 w0.102: v5(115.01,102.82) 114.33,103.5 v7(114.31,103.5) ; v7(104.85,103.59) v5(104.85,103.03)
  IN2 w0.114: v5(95.54,101.78) 95.55,101.77 102.64,101.77 103.9,103.03 v5(104.85,103.03) 105.6,103.03 108.35,100.27 112.45,100.27 v5(115.01,102.82) 115.41,103.23 v5(117.74,103.23)
  GND3 w0.102: v6(118.3,103.23) v5(117.74,103.23) ; v5(95.54,101.78) 95.27,102.05 v6(94.9,102.05) ; v6(104.4,103.03) v5(104.85,103.03)
  BOTTOM w0.076: 122.46,86.82 122.36,86.72 120.63,86.72 120.38,86.47 120.38,84.37 120.19,84.18 118.09,84.18 117.79,83.88 117.79,83.01 UC1.CE7
  BOTTOM w0.191: 122.46,86.82 122.86,87.22 122.86,89.23 120.52,91.56 117.22,91.56 116.28,92.5 116.28,93.57 118.3,95.59 v1(118.3,99.4) v6(118.3,103.23) ; v6(94.9,102.05) 94.6,102.35 RD252.2
DDR_B_CKE0: length 57.6
  IN1 w0.064: v2(93.19,104.15) 93.31,104.27 96.58,104.27 96.96,103.89 v6(97.18,103.89) 97.33,103.74 100.15,103.74 100.28,103.61 101.22,103.61 101.34,103.49 v2(101.58,103.49) 101.58,104.04 101.78,104.24 103.64,104.24 103.7,104.18 103.7,104.03 103.76,103.97 103.89,103.97 103.95,104.03 103.95,104.18 104.02,104.24 105.72,104.24 107.01,104.24 107.36,103.89 v6(107.57,103.89) 110.4,103.89 110.69,103.6 111.86,103.6 v2(111.97,103.49) 112.09,103.61 112.82,103.61 113.57,102.86
  IN1 w0.097: v6(118.21,81.86) 118.47,81.3 118.47,81.14 118.01,80.27 118.01,80.2 117.42,79.6 116.31,79.6 115.75,80.16 115.75,81.3 115.48,81.58 114.41,81.58 113.82,80.98 113.4,80.98 112.79,81.6 112.49,81.6 112.25,81.84 111.47,81.84 111.12,82.19 110.73,82.19 110.17,82.75 110.17,83.33 110.49,83.65 110.49,87.11 111.97,88.59 111.97,92.97 112.19,93.18 112.19,94.03 113.22,95.07 113.22,96.84 113.66,97.28 113.66,102.77 113.57,102.86
  BOTTOM w0.127: UD7.K2 v6(107.57,103.89) ; UD8.K2 v6(97.18,103.89)
DDR_B_CLK0: length 71.3
  TOP w0.076: v2(111.57,103.1) 111.5,103.17 110.8,103.17 110.47,103.49 ; v2(101.18,103.1) 101.1,103.18 100.65,103.18 100.64,103.19 100.38,103.19 100.08,103.49
  TOP w0.145: UD6.K7 100.08,103.49 ; UD5.K7 110.47,103.49
  IN1 w0.086: v2(93.19,103.59) 93.38,103.4 97.35,103.4 97.43,103.32 97.77,103.32 v6(97.98,103.1) 98.06,103.1 98.09,103.13 98.25,103.13 98.34,103.23 98.34,103.46 98.46,103.57 98.68,103.57 98.79,103.46 98.79,103.26 98.91,103.13 99.13,103.13 99.24,103.24 99.24,103.46 99.35,103.57 99.57,103.57 99.69,103.46 99.69,103.26 99.81,103.13 100.02,103.13 100.14,103.26 100.14,103.35 100.21,103.41 100.45,103.41 100.56,103.3 100.75,103.3 100.91,103.46 101.12,103.46 101.22,103.36 101.22,103.21 101.18,103.17 v2(101.18,103.1) 101.18,103.09 101.58,103.09 101.85,103.36 102.09,103.36 102.26,103.2 102.76,103.2 102.76,103.19 102.99,103.19 102.99,103.2 105.09,103.2 105.67,103.78 106.27,103.78 106.46,103.59 107.55,103.59 107.73,103.4 108.1,103.4 108.37,103.13 v6(108.37,103.1) 108.4,103.07 108.63,103.07 108.76,103.2 108.76,103.59 108.87,103.7 109.09,103.7 109.2,103.59 109.2,103.17 109.3,103.07 109.52,103.07 109.65,103.2 109.65,103.54 109.76,103.65 109.99,103.65 110.1,103.54 110.1,103.14 110.16,103.07 110.59,103.07 110.83,103.32 111.44,103.32 111.57,103.19 v2(111.57,103.1) 111.71,102.96 111.87,102.96 112.31,103.41 112.46,103.41 112.89,102.98 112.89,102.57
  IN1 w0.112: v6(114.55,81.21) 114.72,81.38 114.95,81.38 115.03,81.3 115.03,81.15 114.19,80.31 113.29,80.31 112.87,80.73 112.13,80.73 111.27,81.59 110.7,81.59 109.76,82.53 109.76,87.17 110.53,87.95 110.53,88.25 110.68,88.4 111.15,88.4 111.41,88.67 111.41,89.32 111.12,89.62 110.72,89.62 110.59,89.75 110.59,90.17 110.66,90.24 111.2,90.24 111.46,90.51 111.46,91.13 111.2,91.39 110.66,91.39 110.55,91.5 110.55,91.91 110.66,92.02 111.11,92.02 111.37,92.29 111.37,92.84 111.11,93.11 111.02,93.11 110.91,93.22 110.91,93.88 111.21,94.18 111.61,94.18 112.71,95.28 112.71,97.05 113.15,97.49 113.15,102.05 112.89,102.31 112.89,102.57
  BOTTOM w0.145: UD8.K7 98.36,103.49 v6(97.98,103.1) ; 108.38,103.1 108.77,103.49 UD7.K7
  BOTTOM w0.178: 108.38,103.1 v6(108.37,103.1)
DDR_B_CLK#0: length 76.3
  TOP w0.076: 100.13,103 100.91,103 101.07,102.84 101.28,102.84 101.43,102.99 101.43,103 101.52,103.09 101.96,103.09 v2(101.98,103.08) ; v2(112.37,103.08) 112.36,103.09 111.91,103.09 111.83,103 111.83,102.99 111.68,102.84 111.47,102.84 111.3,103 110.52,103
  TOP w0.145: UD6.K8 96.9,103.49 97.29,103.1 100.03,103.1 100.13,103 ; UD5.K8 107.56,103.1 110.42,103.1 110.52,103
  IN1 w0.086: v2(93.19,103.02) 93.27,103.09 v6(97.18,103.09) 97.22,103.09 97.3,103.01 97.67,103.01 97.85,102.83 100.17,102.83 100.34,102.99 100.88,102.99 101.06,102.81 101.7,102.81 101.96,103.08 v2(101.98,103.08) 101.98,102.69 102.09,102.58 102.31,102.58 102.42,102.69 102.42,102.82 102.49,102.89 102.63,102.89 102.64,102.88 103.19,102.88 103.28,102.79 103.28,102.58 103.39,102.48 103.53,102.48 103.63,102.58 103.63,102.79 103.73,102.89 103.87,102.89 103.98,102.79 103.98,102.55 104.08,102.44 104.22,102.44 104.32,102.55 104.32,102.79 104.42,102.89 105.22,102.89 105.8,103.47 106.14,103.47 106.33,103.28 107.4,103.28 107.57,103.1 v6(107.57,103.09) 107.97,103.09 108.3,102.76 110.72,102.76 110.96,103.01 111.26,103.01 111.57,102.7 111.98,102.7 112.36,103.08 v2(112.37,103.08) 112.62,102.57
  IN1 w0.112: v6(115.46,81.21) 114.3,80.05 113.18,80.05 112.76,80.46 112.02,80.46 111.16,81.32 110.59,81.32 109.5,82.42 109.5,87.28 110.27,88.06 110.27,88.36 110.57,88.66 111.04,88.66 111.15,88.78 111.15,89.21 111.01,89.35 110.61,89.35 110.32,89.64 110.32,90.28 110.55,90.51 111.09,90.51 111.2,90.62 111.2,91.02 111.09,91.13 110.55,91.13 110.28,91.39 110.28,92.02 110.55,92.28 111,92.28 111.11,92.4 111.11,92.73 111,92.85 110.91,92.85 110.64,93.11 110.64,93.99 111.1,94.44 111.5,94.44 112.45,95.39 112.45,97.16 112.88,97.6 112.88,101.94 112.62,102.2 112.62,102.57
  BOTTOM w0.076: 108.74,102.87 108.71,102.84 108.27,102.84 108.25,102.85 108.24,102.85 108,103.09 v6(107.57,103.09) ; v6(97.18,103.09) 97.61,103.09 97.85,102.85 97.86,102.85 97.87,102.84 98.31,102.84
  BOTTOM w0.145: 98.31,102.84 98.55,103.08 101.11,103.08 101.33,103.3 101.35,103.3 101.54,103.49 UD8.K8 ; 108.74,102.87 108.95,103.08 111.41,103.08 111.82,103.49 UD7.K8
DDR_B_CS#0: length 61.4
  TOP w0.127: UD6.L7 v2(99.98,104.29) ; UD5.L7 v2(110.37,104.29)
  IN1 w0.064: v2(92.04,104.16) 92.31,104.44 96.77,104.44 96.99,104.22 97.88,104.22 97.95,104.29 v6(98.38,104.29) 98.48,104.39 99.07,104.39 99.13,104.33 99.13,103.97 99.2,103.9 99.32,103.9 99.39,103.97 99.39,104.35 99.45,104.41 99.6,104.41 99.67,104.35 99.67,103.97 99.73,103.9 99.91,103.9 99.98,103.97 v2(99.98,104.29) 100.1,104.29 100.24,104.16 100.54,104.16 100.67,104.03 100.89,104.03 101.04,104.18 101.42,104.18 101.75,104.5 107.1,104.5 107.42,104.18 108.66,104.18 v6(108.77,104.29) 108.77,104.22 108.94,104.06 109.28,104.06 109.32,104.1 109.32,104.44 109.38,104.5 109.57,104.5 109.64,104.43 109.64,104.12 109.7,104.06 109.89,104.06 109.95,104.12 109.95,104.41 110.04,104.5 110.17,104.5 v2(110.37,104.29) 110.44,104.22 110.72,104.22 111.06,104.03 111.29,104.03 111.47,104.15 113.28,104.15 113.43,104 113.43,103.35 113.57,103.21
  IN1 w0.097: 113.57,103.21 113.91,102.87 113.91,96.74 113.47,96.3 113.47,94.97 112.43,93.93 112.43,93.08 112.22,92.87 112.22,88.51 110.75,87.05 110.75,83.54 110.44,83.22 v6(110.44,82.86)
  BOTTOM w0.127: UD7.L7 v6(108.77,104.29) ; v6(110.44,82.86) 110.44,82.4 110.23,82.2 109.81,82.2 109.62,82 109.62,80.27 UC1.BP11 ; UD8.L7 v6(98.38,104.29)
DDR_B_D0: length 17
  IN3 w0.064: v14(111.17,98.69) 111.68,98.18 111.68,95.21 110.33,93.86 110.33,93.77 110.72,93.38 110.72,93.29 110.63,93.2 110.54,93.2 110.15,93.59 110.06,93.59 109.97,93.5 109.97,93.41 110.36,93.02 110.36,92.93 107.69,90.26 107.69,88.78 106.71,87.79 106.71,86.36 v3(106.97,86.1)
  BOTTOM w0.076: UC1.BH2 v3(106.97,86.1)
DDR_B_D1: length 16.8
  IN3 w0.064: v14(111.97,97.09) 112.23,96.83 112.23,95.45 111.8,95.02 111.8,94.93 112.13,94.59 112.13,94.5 112.04,94.41 111.95,94.41 111.62,94.75 111.53,94.75 111.41,94.63 111.41,94.54 111.73,94.21 111.73,94.09 111.64,93.99 111.55,93.99 111.21,94.33 111.12,94.33 111.02,94.24 111.02,94.15 111.41,93.76 111.41,93.67 111.32,93.58 111.23,93.58 110.84,93.97 110.75,93.97 110.66,93.88 110.66,93.79 111.05,93.4 111.05,93.31 108,90.26 108,88.63 106.97,87.6 v3(106.97,86.75)
  BOTTOM w0.076: UC1.BH1 v3(106.97,86.75)
DDR_B_D2: length 18.7
  IN3 w0.064: v3(106.16,84.15) 105.67,84.15 105.37,84.45 105.37,87.05 105.34,87.08 105.34,88.99 105.65,89.3 105.65,91.89 107.44,93.68 107.44,98.16 107.61,98.33 108.82,98.33 108.89,98.4 108.89,98.63 108.82,98.69 v14(107.97,98.69)
  BOTTOM w0.076: UC1.BH4 v3(106.16,84.15)
DDR_B_D3: length 16.8
  IN3 w0.064: v14(111.97,97.89) 112.37,97.49 112.37,97.08 112.51,96.93 112.51,94.47 108.23,90.19 108.23,88.32 107.24,87.33 107.24,86.61 107.17,86.55 107.17,86.25 107.24,86.19 107.24,85.94 107.17,85.87 107.17,84.46 v3(106.53,83.82)
DDR_B_D4: length 15.3
  IN3 w0.064: v14(107.17,97.89) 107.17,93.72 105.43,91.98 105.43,89.38 105.15,89.09 105.15,87.02 105.17,87 105.17,84.26 105.61,83.82 v3(105.79,83.82)
DDR_B_D5: length 16.5
  IN3 w0.064: v14(107.97,96.29) 107.97,96 108.04,95.94 108.94,95.94 109,95.88 109,95.75 108.94,95.69 108.04,95.69 107.97,95.62 107.97,95.5 108.04,95.43 108.94,95.43 109,95.37 109,95.24 108.94,95.18 108.04,95.18 107.97,95.11 107.97,94.99 108.04,94.92 108.94,94.92 109,94.86 109,94.73 108.94,94.67 108.04,94.67 107.97,94.61 107.97,93.6 106.08,91.71 106.08,88.94 105.79,88.65 v3(105.79,86.83)
  BOTTOM w0.076: UC1.BG1 v3(105.79,86.83)
DDR_B_D6: length 18.2
  IN3 w0.064: v3(106.24,86.1) 106.48,86.34 106.48,87.87 107.44,88.83 107.44,91.27 108.64,92.47 108.73,92.47 109.11,92.08 109.2,92.08 109.29,92.17 109.29,92.26 108.91,92.65 108.91,92.74 109.02,92.85 109.11,92.85 109.5,92.47 109.59,92.47 109.68,92.56 109.68,92.65 109.29,93.03 109.29,93.12 109.37,93.21 109.46,93.21 109.85,92.82 109.94,92.82 110.03,92.91 110.03,93 109.64,93.39 109.64,93.48 111.44,95.27 111.44,97.62 v14(111.17,97.89)
  BOTTOM w0.076: UC1.BG2 v3(106.24,86.1)
DDR_B_D7: length 16.6
  IN3 w0.064: v3(105.79,84.47) 105.79,84.69 105.53,84.95 105.53,87.16 105.54,87.17 105.54,88.8 105.87,89.12 105.87,91.8 107.67,93.6 107.67,97.15 107.95,97.44 108.09,97.44 108.27,97.62 108.95,97.62 109.03,97.7 109.03,97.9 108.96,97.96 108.04,97.96 v14(107.97,97.89)
DDR_B_D8: length 24.1
  IN3 w0.064: v14(111.17,101.89) 110.98,102.09 110.35,102.09 110.28,102.02 110.28,101.02 110.22,100.95 110.09,100.95 110.03,101.02 110.03,101.97 109.97,102.04 109.54,102.04 109.48,101.97 109.48,99.82 109.41,99.76 106.9,99.76 105.87,98.73 105.87,93.7 104.53,92.36 104.53,89.94 104.19,89.6 104.19,86.36 v3(104.46,86.1)
  BOTTOM w0.076: UC1.BE2 v3(104.46,86.1)
DDR_B_D9: length 24
  IN3 w0.064: v14(111.97,101.89) 111.65,101.89 111.59,101.83 111.59,99.27 111.53,99.21 107.78,99.21 106.7,98.13 106.7,93.91 104.96,92.18 104.96,89.59 104.72,89.34 104.72,86.61 104.64,86.53 104.64,86.32 104.76,86.2 104.76,85.99 104.64,85.88 104.64,84.11 104.35,83.82 v3(104.01,83.82)
DDR_B_D10: length 25.6
  IN3 w0.064: v14(111.17,102.69) 108.77,102.69 108.71,102.63 108.71,101.45 108.77,101.39 109.2,101.39 109.26,101.33 109.26,101.2 109.2,101.14 108.77,101.14 108.71,101.07 108.71,100.95 108.77,100.88 109.2,100.88 109.26,100.82 109.26,100.69 109.2,100.63 108.77,100.63 108.71,100.56 108.71,100.4 108.77,100.34 109.14,100.34 109.2,100.27 109.2,100.06 109.14,100 106.63,100 105.65,99.02 105.65,93.83 104.32,92.49 104.32,90.03 104,89.71 104,86.37 v3(103.72,86.1)
  BOTTOM w0.076: UC1.BC2 v3(103.72,86.1)
DDR_B_D11: length 24.5
  IN3 w0.064: v14(107.17,101.09) 105.1,101.09 103.81,99.8 103.81,95.39 103.75,95.33 103.15,95.33 103.09,95.27 103.09,95.14 103.15,95.07 103.9,95.07 103.96,95.01 103.96,94.88 103.9,94.82 102.87,94.82 102.81,94.75 102.81,94.63 102.87,94.56 103.75,94.56 103.81,94.5 103.81,94.37 103.75,94.31 102.87,94.31 102.81,94.25 102.81,94.12 102.87,94.06 103.75,94.06 103.81,93.99 103.81,93.82 103.75,93.76 102.88,93.76 102.82,93.69 102.82,93.53 102.88,93.46 103.23,93.46 103.3,93.4 103.3,93.27 103.23,93.21 102.88,93.21 102.82,93.14 102.82,89.12 103.28,88.67 v3(103.28,86.83)
  BOTTOM w0.076: UC1.BC1 v3(103.28,86.83)
DDR_B_D12: length 25.5
  IN3 w0.064: v14(107.17,101.89) 106.91,101.89 106.84,101.96 106.84,102.41 106.78,102.48 106.65,102.48 106.59,102.41 106.59,101.96 106.53,101.89 106.4,101.89 106.34,101.96 106.34,102.15 106.27,102.22 106.15,102.22 106.08,102.15 106.08,101.96 106.02,101.89 105.29,101.89 103.38,99.98 103.38,99.14 103.32,99.07 103.06,99.07 103,99.01 103,98.88 103.06,98.82 103.32,98.82 103.38,98.76 103.38,98.63 103.32,98.57 103.06,98.57 103,98.5 103,98.38 103.06,98.31 103.32,98.31 103.38,98.25 103.38,98.12 103.32,98.06 103.06,98.06 103,97.99 103,97.87 103.06,97.8 103.32,97.8 103.38,97.74 103.38,96.17 102.34,95.13 102.34,88.86 102.84,88.36 102.84,84.46 103.16,84.15 v3(103.64,84.15)
  BOTTOM w0.076: UC1.BE4 v3(103.64,84.15)
DDR_B_D13: length 24.4
  IN3 w0.064: v14(111.17,100.29) 111.17,99.51 111.11,99.44 110.91,99.44 110.85,99.51 110.85,100.82 110.78,100.89 110.66,100.89 110.59,100.82 110.59,99.51 110.53,99.44 110.01,99.44 109.95,99.51 109.95,100.79 109.88,100.86 109.76,100.86 109.69,100.79 109.69,99.51 109.63,99.44 107.53,99.44 106.09,97.99 106.09,93.6 104.75,92.27 104.75,89.85 104.44,89.54 104.44,86.77 v3(104.46,86.75)
  BOTTOM w0.076: UC1.BE1 v3(104.46,86.75)
DDR_B_D14: length 24.3
  IN3 w0.064: v3(103.28,84.47) 103.01,84.73 103.01,88.51 102.59,88.93 102.59,95.08 103.6,96.08 103.6,99.89 105.05,101.34 105.63,101.34 105.7,101.4 105.7,101.61 105.76,101.67 105.89,101.67 105.95,101.61 105.95,101.4 106.01,101.34 106.14,101.34 106.2,101.4 106.2,101.61 106.27,101.67 106.39,101.67 106.46,101.61 106.46,101.4 106.52,101.34 106.65,101.34 106.71,101.4 106.71,101.61 106.78,101.67 106.9,101.67 106.97,101.61 106.97,101.4 107.03,101.34 107.38,101.34 107.45,101.4 107.45,101.94 107.51,102 107.64,102 107.7,101.94 107.7,101.4 107.76,101.34 107.91,101.34 107.97,101.4 v14(107.97,101.89)
DDR_B_D15: length 23.2
  IN3 w0.064: v3(103.28,83.82) 103.09,83.82 102.67,84.24 102.67,88.16 102.11,88.72 102.11,95.21 102.78,95.88 102.78,99.69 105.53,102.43 106.1,102.43 106.36,102.69 v14(107.97,102.69)
DDR_B_D16: length 20.6
  IN1 w0.064: v6(106.32,81.86) 106.32,81.62 106.23,81.53 106.09,81.53 106.04,81.58 106.04,83.26 106.41,83.64 106.41,87.22 106.6,87.41 106.6,87.72 106.67,87.8 107.06,87.8 107.12,87.86 107.12,87.99 107.06,88.05 106.64,88.05 106.57,88.11 106.57,88.29 106.64,88.35 107.35,88.35 107.41,88.41 107.41,88.54 107.35,88.61 106.64,88.61 106.57,88.67 106.57,88.8 106.64,88.86 107.35,88.86 107.41,88.92 107.41,89.05 107.35,89.11 106.59,89.11 106.52,89.18 106.52,95.77 106.85,96.09 106.85,96.77 v2(107.17,97.09)
DDR_B_D17: length 21.2
  IN1 w0.064: v12(111.97,97.89) 111.97,97.41 111.91,97.35 111.7,97.35 111.64,97.41 111.64,97.64 111.57,97.71 111.45,97.71 111.38,97.64 111.38,97.41 111.32,97.35 110.98,97.35 110.91,97.29 110.91,95.88 110.85,95.82 109.84,95.82 109.77,95.76 109.77,95.28 109.51,95.02 109.51,88.21 108.2,86.9 108.2,83.71 107.67,83.19 107.67,80.64 107.59,80.56 v6(107.23,80.56)
DDR_B_D18: length 21.9
  IN1 w0.064: v6(107.23,79.91) 107.88,80.55 107.88,83.1 108.53,83.75 108.53,86.92 109.79,88.18 109.79,94.99 109.85,95.05 111.25,95.05 111.31,95.12 111.31,95.29 111.25,95.35 110.05,95.35 109.99,95.41 109.99,95.54 110.05,95.6 111.48,95.6 111.54,95.67 111.54,96.18 111.43,96.29 v12(111.17,96.29)
DDR_B_D19: length 23.6
  IN1 w0.064: v12(111.17,97.89) 111.17,98.2 111.11,98.27 110.76,98.27 110.7,98.2 110.7,97.18 110.63,97.11 109.62,97.11 109.56,97.05 109.56,96.92 109.62,96.86 110.63,96.86 110.7,96.8 110.7,96.67 110.63,96.61 109.62,96.61 109.56,96.54 109.56,96.41 109.62,96.35 110.63,96.35 110.7,96.29 110.7,96.16 110.63,96.1 109.62,96.1 109.56,96.03 109.56,95.37 109.26,95.07 109.26,88.23 107.64,86.6 107.64,83.44 107.52,83.32 107.52,81.92 107.45,81.86 v6(107.23,81.86)
DDR_B_D20: length 22.5
  IN1 w0.064: v6(107.23,82.51) 107.33,82.6 107.33,83.41 107.44,83.52 107.44,86.71 109,88.27 109,95.12 109.34,95.46 109.34,97.33 109.41,97.4 110.42,97.4 110.48,97.46 110.48,97.59 110.42,97.65 109.11,97.65 109.05,97.71 109.05,97.9 109.11,97.96 110.44,97.96 110.48,98 110.48,98.21 110.44,98.25 109.96,98.25 109.91,98.3 109.91,98.53 109.96,98.58 111.06,98.58 v12(111.17,98.69)
DDR_B_D21: length 19.3
  IN1 w0.064: v6(106.32,80.56) 106.45,80.43 106.69,80.43 106.81,80.56 106.81,80.82 106.73,80.91 105.97,80.91 105.87,81 105.87,83.32 106.16,83.61 106.16,87.18 106.31,87.33 106.31,95.86 106.63,96.18 106.63,97.01 107.17,97.55 v12(107.17,97.89)
DDR_B_D22: length 20.4
  IN1 w0.064: v12(107.97,98.69) 107.97,98.69 107.4,98.49 106.09,97.18 106.09,87.43 105.93,87.27 105.93,83.65 105.68,83.4 105.68,80.51 105.78,80.41 106.1,80.41 106.32,80.19 v6(106.32,79.91)
DDR_B_D23: length 24.7
  IN1 w0.064: v2(107.97,97.89) 108.71,97.89 108.77,97.95 108.77,98.25 108.7,98.33 107.59,98.33 107.53,98.27 107.53,96.47 106.74,95.68 106.74,90.93 106.8,90.87 107.66,90.87 107.72,90.8 107.72,90.68 107.66,90.61 106.94,90.61 106.88,90.55 106.88,90.42 106.94,90.36 107.66,90.36 107.72,90.29 107.72,90.17 107.66,90.1 106.94,90.1 106.88,90.04 106.88,89.91 106.94,89.85 107.66,89.85 107.72,89.79 107.72,89.66 107.66,89.6 106.94,89.6 106.88,89.53 106.88,89.41 106.94,89.34 107.66,89.34 107.72,89.28 107.72,88.15 106.64,87.07 106.64,83.63 106.22,83.21 106.22,82.61 v6(106.32,82.51)
DDR_B_D24: length 31.4
  IN1 w0.064: v12(111.17,101.89) 111.19,101.89 111.32,101.76 111.32,101.61 111.23,101.53 110.97,101.53 110.88,101.61 110.4,101.61 110.31,101.7 110.31,101.93 110.37,102 110.78,102 111.09,102.31 111.19,102.31 111.76,101.74 111.76,101.55 111.49,101.28 111.49,100.21 111.27,99.99 109.95,99.99 109.89,100.05 109.89,100.32 109.59,100.62 106.98,100.62 106.92,100.56 106.92,100.46 106.85,100.4 106.72,100.4 106.66,100.46 106.66,100.56 106.6,100.62 105.96,100.62 105.41,100.07 105.41,99.77 105.35,99.71 105.13,99.71 105.06,99.65 105.06,99.52 105.13,99.46 105.35,99.46 105.41,99.39 105.41,99.27 105.35,99.2 105.13,99.2 105.06,99.14 105.06,99.01 105.13,98.95 105.35,98.95 105.41,98.88 105.41,98.08 104.97,97.64 104.97,88.04 104.45,87.52 104.45,82.55 v6(104.49,82.51)
DDR_B_D25: length 30
  IN1 w0.064: v12(111.97,101.89) 111.97,101.46 111.71,101.19 111.71,100.12 111.36,99.77 109.66,99.77 109.59,99.71 109.59,99.42 109.53,99.35 108.3,99.35 108.23,99.42 108.23,99.69 108.17,99.75 107.69,99.75 106.89,98.95 106.26,98.95 105.97,98.66 105.97,98.03 105.41,97.46 105.41,87.56 104.88,87.04 104.88,83.28 104.96,83.2 104.96,80.22 104.9,80.16 103.88,80.16 103.82,80.22 103.82,80.5 103.88,80.56 104.49,80.56 v6(104.49,80.56)
DDR_B_D26: length 29.4
  IN1 w0.064: v6(103.58,80.56) 103.57,80.56 103.32,81.19 103.32,86.99 102.66,87.65 102.66,99.74 105.34,102.42 108.4,102.42 108.55,102.27 110.75,102.27 v12(111.17,102.69)
DDR_B_D27: length 32.4
  IN1 w0.064: v6(104.49,81.86) 104.44,81.81 104.44,81.55 104.5,81.49 104.7,81.49 104.78,81.57 104.78,83.02 104.67,83.13 104.67,87.26 105.19,87.77 105.19,97.55 105.63,97.99 105.63,99.98 105.71,100.06 105.85,100.06 105.91,100 105.91,99.16 105.98,99.1 106.11,99.1 106.17,99.16 106.17,99.94 106.23,100.01 106.35,100.01 106.41,99.94 106.41,99.23 106.47,99.17 106.64,99.17 106.7,99.23 106.7,100.12 106.77,100.18 106.91,100.18 106.98,100.12 106.98,99.59 107.04,99.53 107.17,99.53 107.23,99.59 107.23,99.9 107.29,99.97 107.37,99.97 107.43,100.03 107.43,100.34 107.5,100.4 107.65,100.4 107.71,100.34 107.71,100.08 107.82,99.97 108.44,99.97 108.5,99.9 108.5,99.63 108.56,99.57 108.69,99.57 108.75,99.63 108.75,100.04 108.82,100.11 108.99,100.11 109.03,100.07 109.03,99.63 109.09,99.57 109.34,99.57 109.38,99.61 109.38,99.91 109.45,99.98 109.61,99.98 109.67,100.05 109.67,100.23 109.51,100.4 108.08,100.4 v12(107.97,100.29)
DDR_B_D28: length 30.5
  IN1 w0.061: 105.62,89.67 105.62,87.52 105.32,87.22
  IN1 w0.064: 105.62,89.67 105.62,97.37 107.41,99.16 108.1,99.16 108.13,99.14 110.22,99.14 110.29,99.2 110.29,99.47 110.35,99.54 110.48,99.54 110.54,99.47 110.54,99.2 110.6,99.14 111.57,99.14 111.64,99.21 111.64,99.75 111.93,100.03 112.14,100.03 112.26,100.15 112.26,100.43 112.14,100.55 111.99,100.55 111.92,100.61 111.92,101.04 v12(111.97,101.09) ; 105.32,87.22 105.09,86.98 105.09,83.35 105.14,83.3 105.14,80.24 105.23,80.16 105.94,80.16 106,80.09 106,79.63 105.94,79.57 104.87,79.57 104.81,79.63 104.81,79.85 104.75,79.91 v6(104.49,79.91)
DDR_B_D29: length 29.8
  IN1 w0.064: v6(103.58,81.86) 103.69,81.86 103.85,82.02 103.85,82.75 103.7,82.9 103.7,91.66 103.64,91.72 103.16,91.72 103.09,91.78 103.09,91.91 103.16,91.97 103.64,91.97 103.7,92.04 103.7,92.16 103.64,92.23 103.16,92.23 103.09,92.29 103.09,92.42 103.16,92.48 103.64,92.48 103.7,92.54 103.7,92.67 103.64,92.73 103.16,92.73 103.09,92.8 103.09,92.93 103.16,92.99 103.64,92.99 103.7,93.05 103.7,93.18 103.64,93.24 103.16,93.24 103.09,93.31 103.09,93.43 103.16,93.5 103.64,93.5 103.7,93.56 103.7,93.69 103.64,93.75 103.16,93.75 103.09,93.81 103.09,93.94 103.16,94 103.54,94 103.6,94.07 103.6,94.2 103.54,94.26 103.16,94.26 103.09,94.32 103.09,95.81 103.16,95.88 103.33,95.88 103.39,95.94 103.39,96.07 103.33,96.13 103.16,96.13 103.09,96.19 103.09,96.34 103.16,96.41 103.32,96.41 103.38,96.47 103.38,96.6 103.32,96.66 103.16,96.66 103.09,96.72 103.09,98.06 103.16,98.13 103.23,98.13 103.3,98.19 103.3,98.32 103.23,98.38 103.16,98.38 103.09,98.44 103.09,99.56 105.43,101.89 v12(107.17,101.89)
DDR_B_D30: length 33.1
  IN1 w0.064: v6(103.58,82.51) 103.5,82.59 103.5,87.21 103.43,87.27 103.32,87.27 103.26,87.34 103.26,87.46 103.32,87.53 103.43,87.53 103.5,87.59 103.5,87.76 103.43,87.82 102.93,87.82 102.87,87.88 102.87,88.01 102.93,88.07 103.43,88.07 103.5,88.14 103.5,88.26 103.43,88.33 102.94,88.33 102.88,88.39 102.88,88.52 102.94,88.58 103.43,88.58 103.5,88.64 103.5,88.75 103.43,88.82 102.94,88.82 102.88,88.88 102.88,89.04 102.94,89.11 103.39,89.11 103.45,89.17 103.45,89.3 103.39,89.36 102.94,89.36 102.88,89.42 102.88,89.55 102.94,89.61 103.39,89.61 103.45,89.68 103.45,89.8 103.39,89.87 102.94,89.87 102.88,89.93 102.88,90.06 102.94,90.12 103.42,90.12 103.48,90.19 103.48,90.31 103.42,90.38 102.94,90.38 102.88,90.44 102.88,90.57 102.94,90.63 103.42,90.63 103.48,90.69 103.48,90.82 103.42,90.88 102.94,90.88 102.88,90.95 102.88,91.11 102.94,91.18 103.42,91.18 103.48,91.24 103.48,91.37 103.42,91.43 102.94,91.43 102.88,91.49 102.88,99.65 105.43,102.2 107.35,102.2 107.45,102.1 107.45,101.96 107.51,101.89 107.64,101.89 107.7,101.96 107.7,102.1 107.81,102.2 108.31,102.2 108.42,102.1 108.42,102.01 108.3,101.89 v12(107.97,101.89)
DDR_B_D31: length 29.2
  IN1 w0.064: v6(103.58,79.91) 103.58,80.17 103.14,80.61 103.14,86.95 102.45,87.65 102.45,95.85 102.09,96.21 102.09,97.97 102.45,98.33 102.45,99.88 103.45,100.88 103.45,100.97 103.22,101.2 103.22,101.29 103.31,101.38 103.4,101.38 103.63,101.15 103.72,101.15 103.81,101.24 103.81,101.33 103.58,101.56 103.58,101.65 103.67,101.74 103.76,101.74 103.99,101.51 104.08,101.51 105.64,103.08 107.16,103.08 107.55,102.69 v12(107.97,102.69)
DDR_B_D32: length 17.5
  IN3 w0.064: v3(101.5,83.82) 102.13,84.45 102.13,85.89 102.21,85.97 102.21,86.24 102.12,86.32 102.12,86.53 102.21,86.61 102.21,88.27 101.64,88.83 101.64,95.4 102.12,95.88 102.12,98.93 102.04,99 101.64,99 101.58,98.94 v14(101.58,97.89)
DDR_B_D33: length 16.5
  IN3 w0.064: v3(97.58,97.89) 97.58,98.38 97.63,98.44 98.04,98.44 98.11,98.37 98.11,97.7 98.04,97.63 97.89,97.63 97.83,97.57 97.83,97.44 97.89,97.38 98.04,97.38 98.11,97.31 98.11,95.45 98.88,94.67 98.88,89.6 100.49,87.99 100.49,84.88 100.76,84.62 v3(100.76,84.47)
DDR_B_D34: length 18.1
  IN3 w0.064: v14(101.58,97.09) 101.84,97.09 101.9,97.03 101.9,96.23 101.42,95.75 101.42,92.24 101.36,92.18 100.87,92.18 100.81,92.11 100.81,91.99 100.87,91.92 101.36,91.92 101.42,91.86 101.42,91.73 101.36,91.67 100.87,91.67 100.81,91.6 100.81,91.48 100.87,91.41 101.36,91.41 101.42,91.35 101.42,91.22 101.36,91.16 100.87,91.16 100.81,91.1 100.81,90.97 100.87,90.91 101.36,90.91 101.42,90.84 101.42,90.72 101.36,90.65 100.87,90.65 100.81,90.59 100.81,90.46 100.87,90.4 101.36,90.4 101.42,90.33 101.42,90.21 101.36,90.14 100.87,90.14 100.81,90.08 100.81,89.95 100.87,89.89 101.36,89.89 101.42,89.83 101.42,89.7 101.36,89.64 100.87,89.64 100.81,89.57 100.81,89.45 100.87,89.38 101.36,89.38 101.42,89.32 101.42,88.77 101.94,88.24 v3(101.94,86.75)
  BOTTOM w0.076: UC1.AY1 v3(101.94,86.75)
DDR_B_D35: length 18.1
  IN3 w0.064: v14(100.78,97.89) 100.55,98.12 100.55,98.22 100.7,98.37 100.79,98.37 101.07,98.09 101.07,96.14 100.97,96.04 100.44,96.04 100.37,95.98 100.37,95.6 100.44,95.54 100.92,95.54 100.99,95.48 100.99,95.35 100.92,95.29 100.44,95.29 100.37,95.22 100.37,95.1 100.44,95.03 100.92,95.03 100.99,94.97 100.99,94.84 100.92,94.78 100.44,94.78 100.37,94.71 100.37,94.59 100.44,94.52 100.92,94.52 100.99,94.46 100.99,94.33 100.92,94.27 100.44,94.27 100.37,94.21 100.37,89.31 101.45,88.23 101.45,86.34 v3(101.21,86.1)
  BOTTOM w0.076: UC1.AW2 v3(101.21,86.1)
DDR_B_D36: length 17.7
  IN3 w0.064: v3(101.94,86.1) 101.68,86.36 101.68,88.23 100.59,89.32 100.59,92.38 100.65,92.45 101.14,92.45 101.2,92.51 101.2,92.64 101.14,92.7 100.65,92.7 100.59,92.76 100.59,92.89 100.65,92.95 101.14,92.95 101.2,93.02 101.2,93.14 101.14,93.21 100.65,93.21 100.59,93.27 100.59,93.4 100.65,93.46 101.14,93.46 101.2,93.53 101.2,93.65 101.14,93.72 100.65,93.72 100.59,93.78 100.59,93.91 100.65,93.97 101.14,93.97 101.2,94.03 101.2,95.97 101.3,96.06 101.3,98.17 v14(100.78,98.69)
  BOTTOM w0.076: UC1.AY2 v3(101.94,86.1)
DDR_B_D37: length 15.8
  IN3 w0.064: v3(100.76,83.82) 100.58,83.82 100.13,84.27 100.13,87.65 98.45,89.33 98.45,93.16 97.26,94.35 97.26,97.41 v14(96.78,97.89)
DDR_B_D38: length 18.7
  IN3 w0.064: v3(97.58,96.29) 97.48,96.19 97.48,95.77 97.88,95.37 97.88,95.28 97.48,94.88 97.48,94.79 97.57,94.7 97.66,94.7 98.06,95.1 98.14,95.1 98.24,95.01 98.24,94.92 97.66,94.35 97.66,94.26 97.75,94.17 97.84,94.17 98.41,94.74 98.5,94.74 98.6,94.65 98.6,94.56 98.02,93.98 98.02,93.89 98.15,93.77 98.24,93.77 98.49,94.02 98.58,94.02 98.67,93.93 98.67,93.84 98.42,93.59 98.42,93.5 98.67,93.25 98.67,89.5 100.31,87.85 100.31,84.48 100.64,84.15 v3(101.13,84.15)
  BOTTOM w0.076: UC1.AY4 v3(101.13,84.15)
DDR_B_D39: length 17.4
  IN3 w0.064: v3(100.76,86.83) 100.76,88.02 99.1,89.68 99.1,94.76 98.32,95.54 98.32,98.27 98.38,98.33 98.68,98.33 98.76,98.24 98.76,97.44 98.83,97.38 99.07,97.38 99.16,97.47 99.16,98.62 99.09,98.69 v3(97.58,98.69)
  BOTTOM w0.076: UC1.AW1 v3(100.76,86.83)
DDR_B_D40: length 25
  IN3 w0.064: v14(100.78,100.29) 100.55,100.51 100.4,100.51 100.31,100.43 100.31,99.56 100.25,99.5 100.11,99.5 100.04,99.56 100.04,100.44 99.98,100.5 99.85,100.5 99.79,100.44 99.79,99.57 99.71,99.5 99.6,99.5 99.54,99.56 99.54,100.44 99.47,100.5 99.35,100.5 99.28,100.44 99.28,99.57 99.21,99.5 99.09,99.5 99.03,99.56 99.03,100.44 98.96,100.5 98.84,100.5 98.77,100.44 98.77,99.57 98.7,99.5 97.44,99.5 96.26,98.32 96.26,97.3 96.57,96.99 96.57,94.07 97.77,92.87 97.77,89.48 99.43,87.81 v3(99.43,86.75)
  BOTTOM w0.076: UC1.AU1 v3(99.43,86.75)
DDR_B_D41: length 23.9
  IN3 w0.064: v3(98.25,84.47) 98.25,84.52 97.99,84.77 97.99,86.43 95.16,89.26 95.16,91.79 94.59,92.35 94.59,93.29 93.88,94 93.88,99.69 95.79,101.6 97,101.6 97.27,101.34 98.43,101.34 98.5,101.4 98.5,101.78 98.39,101.89 v14(97.58,101.89)
DDR_B_D42: length 25.8
  IN3 w0.064: v14(100.78,101.89) 100.78,102.38 100.71,102.44 100.53,102.44 100.45,102.36 100.45,100.81 100.39,100.74 100.22,100.74 100.16,100.81 100.16,101.95 100.1,102.01 99.97,102.01 99.91,101.95 99.91,100.81 99.84,100.74 98.62,100.74 98.56,100.68 98.56,99.82 98.49,99.76 96.59,99.76 95.66,98.83 95.66,96.98 96.36,96.28 96.36,93.98 97.55,92.78 97.55,89.36 99.16,87.75 99.16,86.36 v3(99.43,86.1)
  BOTTOM w0.076: UC1.AU2 v3(99.43,86.1)
DDR_B_D43: length 23.5
  IN3 w0.061: 94.69,90.2 94.69,90.83
  IN3 w0.064: 94.69,90.2 94.76,90.14 94.76,88.59 96.82,86.52 96.82,85.31 97.41,84.72 97.46,84.72 97.63,84.55 97.63,84.26 98.06,83.82 v3(98.25,83.82) ; 94.69,90.83 94.69,91.64 93.45,92.89 93.45,99.87 96.01,102.43 96.88,102.43 97.14,102.69 v14(97.58,102.69)
DDR_B_D44: length 25
  IN3 w0.064: v14(101.58,101.89) 101.86,101.89 101.93,101.83 101.93,99.56 101.84,99.47 101.45,99.47 101.2,99.23 100.12,99.23 100.09,99.27 97.64,99.27 96.48,98.1 96.48,97.39 96.79,97.08 96.79,94.16 97.98,92.96 97.98,89.52 99.69,87.82 99.69,86.61 99.59,86.52 99.59,86.31 99.69,86.21 99.69,85.98 99.59,85.88 99.59,83.91 99.5,83.82 v3(98.98,83.82)
DDR_B_D45: length 25.4
  IN3 w0.064: v3(98.69,86.1) 98.94,86.34 98.94,87.65 97.34,89.26 97.34,92.66 96.14,93.85 96.14,95.76 95.37,96.53 95.37,98.98 96.38,99.99 98.28,99.99 98.34,100.06 98.34,100.82 98.48,100.96 98.99,100.96 99.05,101.02 99.05,102.15 99.12,102.22 99.24,102.22 99.31,102.15 99.31,101.02 99.37,100.96 99.5,100.96 99.56,101.02 99.56,102.16 99.63,102.23 99.98,102.23 100.45,102.69 v14(100.78,102.69)
  BOTTOM w0.076: UC1.AT2 v3(98.69,86.1)
DDR_B_D46: length 26.9
  IN3 w0.064: v3(98.62,84.15) 98.13,84.15 97.8,84.48 97.8,86.33 97.2,86.93 97.11,86.93 96.98,86.79 96.89,86.79 96.8,86.88 96.8,86.97 96.93,87.11 96.93,87.2 96.84,87.29 96.75,87.29 96.62,87.15 96.53,87.15 96.44,87.24 96.44,87.33 96.57,87.47 96.57,87.56 96.48,87.65 96.39,87.65 96.26,87.51 96.17,87.51 96.08,87.6 96.08,87.69 96.21,87.83 96.21,87.92 96.12,88.01 96.03,88.01 95.9,87.87 95.81,87.87 95.72,87.96 95.72,88.05 95.85,88.19 95.85,88.28 95.76,88.37 95.67,88.37 95.54,88.23 95.45,88.23 95.36,88.32 95.36,88.41 95.49,88.55 95.49,88.64 95.4,88.73 95.31,88.73 95.18,88.59 95.09,88.59 95,88.68 95,88.77 95.13,88.91 95.13,89 94.91,89.22 94.91,91.73 94.38,92.26 94.38,93.2 93.66,93.91 93.66,99.78 96.1,102.22 97.27,102.22 97.32,102.16 97.32,101.93 97.28,101.89 v14(96.78,101.89)
  BOTTOM w0.076: UC1.AU4 v3(98.62,84.15)
DDR_B_D47: length 24.9
  IN3 w0.061: 95.65,90.14 95.37,90.42 95.37,90.92
  IN3 w0.064: v3(98.25,86.83) 98.25,87.09 98.05,87.29 97.96,87.29 97.74,87.07 97.65,87.07 97.56,87.16 97.56,87.25 97.78,87.47 97.78,87.56 97.69,87.65 97.6,87.65 97.39,87.43 97.3,87.43 97.21,87.52 97.21,87.61 97.42,87.83 97.42,87.92 97.31,88.03 97.22,88.03 97.02,87.84 96.93,87.84 96.84,87.93 96.84,88.02 97.04,88.21 97.04,88.3 96.95,88.39 96.86,88.39 96.66,88.19 96.57,88.19 96.48,88.28 96.48,88.37 96.68,88.57 96.68,88.66 96.59,88.75 96.5,88.75 96.3,88.55 96.21,88.55 96.12,88.64 96.12,88.73 96.32,88.93 96.32,89.02 96.23,89.11 96.14,89.11 95.94,88.91 95.85,88.91 95.76,89 95.76,89.09 96.14,89.48 96.14,89.57 96.05,89.66 95.96,89.66 95.58,89.27 95.49,89.27 95.4,89.36 95.4,89.45 95.82,89.88 95.82,89.97 95.65,90.14 ; v14(96.78,101.09) 96.87,101.09 96.96,101.18 96.96,101.27 96.85,101.38 96.54,101.38 96.48,101.32 96.48,101.11 96.41,101.05 96.29,101.05 96.22,101.11 96.22,101.32 96.16,101.38 95.88,101.38 94.09,99.6 94.09,94.09 94.81,93.38 94.81,92.44 95.37,91.88 95.37,90.92
  BOTTOM w0.076: UC1.AT1 v3(98.25,86.83)
DDR_B_D48: length 21.5
  IN1 w0.064: v2(100.78,97.89) 100.52,97.63 100.52,96.03 101.01,95.53 101.01,90.13 101.08,90.07 101.48,90.07 101.55,90 101.55,89.87 101.48,89.81 101.08,89.81 101.01,89.75 101.01,89.62 101.08,89.56 101.48,89.56 101.55,89.49 101.55,89.37 101.48,89.3 101.08,89.3 101.01,89.24 101.01,89.11 101.08,89.05 101.48,89.05 101.55,88.99 101.55,88.86 101.48,88.8 101.08,88.8 101.01,88.73 101.01,88.6 101.08,88.54 101.48,88.54 101.55,88.48 101.55,87.38 102.26,86.67 102.26,82.94 102.03,82.7 102.03,82.41 101.91,82.29 101.91,82.1 102.07,81.94 102.07,81.16 101.96,81.06 101.96,80.77 v6(101.75,80.56)
DDR_B_D49: length 23.3
  IN1 w0.061: 100.8,90.92 100.8,87.92 101.67,87.05
  IN1 w0.064: 100.8,90.92 100.8,95.44 100.3,95.94 100.3,97.79 100.22,97.87 99.92,97.87 99.89,97.9 99.89,98.1 99.94,98.14 100.7,98.14 100.77,98.2 100.77,98.34 100.69,98.42 99.92,98.42 99.86,98.48 99.86,98.98 99.9,99.03 100.08,99.03 100.11,98.99 100.11,98.74 100.16,98.69 100.36,98.69 100.43,98.76 100.43,99.04 100.49,99.1 101.73,99.1 101.8,99.03 101.8,98.74 101.75,98.69 v12(100.78,98.69) ; v6(101.75,82.51) 101.75,82.7 102.06,83.01 102.06,85.41 101.67,85.8 101.67,87.05
DDR_B_D50: length 21.3
  IN1 w0.061: 100.13,83.7 100.13,83.63 100.15,83.61 100.15,81.77 100.05,81.68 100.05,81.25 v6(100.83,79.91)
  IN1 w0.064: 100.13,83.7 100.13,86.62 98.76,87.99 98.76,93.62 96.24,96.14 96.24,97.29 96.44,97.49 96.44,97.92 96.66,98.14 v12(97.58,98.69)
DDR_B_D51: length 24.1
  IN1 w0.064: v2(100.78,96.29) 100.78,96.08 100.83,96.02 101.16,96.02 101.23,95.95 101.23,94.96 101.29,94.89 101.7,94.89 101.76,94.83 101.76,94.7 101.7,94.64 101.29,94.64 101.23,94.58 101.23,94.45 101.29,94.39 101.7,94.39 101.76,94.32 101.76,94.2 101.7,94.13 101.29,94.13 101.23,94.07 101.23,93.94 101.29,93.88 101.7,93.88 101.76,93.81 101.76,93.69 101.7,93.62 101.29,93.62 101.23,93.56 101.23,93.43 101.29,93.37 101.7,93.37 101.76,93.31 101.76,93.18 101.7,93.12 101.29,93.12 101.23,93.05 101.23,92.93 101.29,92.86 101.7,92.86 101.76,92.8 101.76,92.67 101.7,92.61 101.29,92.61 101.23,92.54 101.23,92.42 101.29,92.35 101.7,92.35 101.76,92.29 101.76,92.16 101.7,92.1 101.29,92.1 101.23,92.04 101.23,91.91 101.29,91.85 101.7,91.85 101.76,91.78 101.76,91.66 101.7,91.59 101.29,91.59 101.23,91.53 101.23,91.4 101.29,91.34 101.7,91.34 101.76,91.27 101.76,91.15 101.7,91.08 101.29,91.08 101.23,91.02 101.23,90.89 101.29,90.83 101.7,90.83 101.76,90.77 101.76,90.64 101.7,90.58 101.29,90.58 101.23,90.51 101.23,90.39 101.29,90.32 101.7,90.32 101.76,90.26 101.76,87.45 102.42,86.79 102.42,82.88 102.21,82.66 v14(102.21,82.19)
  BOTTOM w0.076: UC1.AY8 v14(102.21,82.19)
DDR_B_D52: length 21.4
  IN1 w0.064: v6(100.83,81.87) 100.83,81.95 100.49,82.29 100.49,83.53 100.52,83.56 100.52,86.78 99.24,88.07 99.24,93.75 98.65,94.34 98.65,94.43 99.13,94.91 99.13,95 99.04,95.09 98.95,95.09 98.47,94.61 98.38,94.61 98.29,94.7 98.29,94.79 98.79,95.29 98.79,95.38 98.7,95.47 98.61,95.47 98.11,94.97 98.02,94.97 97.93,95.06 97.93,95.15 98.43,95.65 98.43,95.74 98.35,95.81 98.23,95.81 97.8,95.38 97.61,95.38 96.78,96.21 v2(96.78,97.09)
DDR_B_D53: length 22.8
  IN1 w0.064: v12(101.58,97.89) 101.62,97.85 101.62,97.65 101.56,97.58 101.13,97.58 101.06,97.52 101.06,97.39 101.13,97.33 101.56,97.33 101.62,97.26 101.62,97.14 101.56,97.07 101.13,97.07 101.06,97.01 101.06,96.88 101.13,96.82 101.56,96.82 101.62,96.76 101.62,96.63 101.56,96.57 101.13,96.57 101.06,96.5 101.06,96.38 101.13,96.31 101.37,96.31 101.44,96.24 101.44,95.78 101.51,95.72 101.91,95.72 101.98,95.66 101.98,95.53 101.91,95.47 101.51,95.47 101.44,95.4 101.44,95.28 101.51,95.21 101.91,95.21 101.98,95.15 101.98,87.61 102.59,86.99 102.59,82.83 102.38,82.62 102.38,82.45 102.46,82.37 102.46,82.06 102.25,81.86 102.25,80.42 v6(101.75,79.91)
DDR_B_D54: length 24.8
  IN1 w0.064: v2(97.58,97.89) 97.58,97.95 97.66,98.04 98.64,98.04 98.7,98.1 98.7,98.66 98.77,98.72 99.21,98.72 99.27,98.79 99.27,99.03 99.2,99.1 97.89,99.1 97.84,99.05 97.84,98.77 97.88,98.74 98.31,98.74 98.37,98.67 98.37,98.48 98.31,98.42 97.54,98.42 97.18,98.06 97.18,96.12 97.25,96.04 98.87,96.04 98.99,95.92 98.99,95.45 99.52,94.92 99.52,88.13 100.7,86.95 100.7,84.33 101.08,83.96 101.08,82.76 v6(100.83,82.51)
DDR_B_D55: length 20.6
  IN1 w0.061: 100.41,82.1 100.41,81.82 100.2,81.61 100.2,81.38 100.73,80.86 101.18,80.86 101.3,80.73 101.3,80.51 101.18,80.4 100.89,80.4 100.83,80.46 v6(100.83,80.56)
  IN1 w0.064: v12(96.78,97.89) 96.78,97.5 96.49,97.21 96.49,96.19 98.99,93.7 98.99,88.06 100.33,86.71 100.33,82.18 100.41,82.1
DDR_B_D56: length 33.4
  IN1 w0.064: v12(100.78,101.89) 100.62,101.73 99.35,101.73 99.29,101.8 99.29,102 99.37,102.09 100.44,102.09 100.78,102.43 101.22,102.43 101.42,102.23 101.42,102.14 101.07,101.79 101.07,100.18 100.92,100.03 100.46,100.03 100.39,100.09 100.39,100.32 100.33,100.39 100.2,100.39 100.14,100.32 100.14,100.09 100.07,100.03 99.95,100.03 99.88,100.09 99.88,100.32 99.82,100.39 99.69,100.39 99.63,100.32 99.63,100.09 99.57,100.03 99.28,100.03 98.51,100.8 95.83,100.8 95.07,100.04 95.07,94.61 97.64,92.03 97.64,87.98 98.87,86.75 98.87,83.93 98.96,83.84 98.96,82.56 v6(99.01,82.51)
DDR_B_D57: length 31.8
  IN1 w0.061: 98.08,88.06 98.08,90.92
  IN1 w0.064: 98.08,88.06 99.42,86.72 99.42,85.69 99.41,85.68 99.41,80.22 99.37,80.18 99.13,80.18 99.07,80.24 99.07,80.5 v6(99.01,80.56) ; v12(101.58,101.89) 101.29,101.61 101.29,100 101.1,99.8 98.78,99.8 98.71,99.87 98.71,100.29 98.65,100.35 98.52,100.35 98.46,100.29 98.46,99.87 98.4,99.8 98.21,99.8 98.15,99.86 98.15,100.5 98.12,100.54 97.9,100.54 97.84,100.48 97.84,100.11 97.76,100.03 96.03,100.03 95.91,99.9 95.91,99.38 95.5,98.98 95.5,95.91 98.08,93.33 98.08,90.92
DDR_B_D58: length 30.8
  IN1 w0.061: 95.59,89.31 94.38,90.52
  IN1 w0.064: v12(97.58,102.69) 96.42,102.69 96.14,102.41 94.61,102.41 92.45,100.25 92.45,92.45 93.16,91.74 93.25,91.74 93.56,92.04 93.65,92.04 93.74,91.95 93.74,91.86 93.43,91.56 93.43,91.47 93.52,91.38 93.61,91.38 93.92,91.68 94.01,91.68 94.1,91.59 94.1,91.5 93.79,91.2 93.79,91.11 94.38,90.52 ; 95.59,89.31 95.59,88.57 97.61,86.55 97.61,80.39 v6(98.09,79.91)
DDR_B_D59: length 33.9
  IN1 w0.064: v6(99.01,81.86) 99.01,81.86 99.07,81.79 99.19,81.79 99.26,81.86 99.26,83.22 99.15,83.32 99.15,86.71 97.86,88.01 97.86,92.12 97.74,92.24 97.74,92.33 97.86,92.45 97.86,92.54 97.77,92.63 97.68,92.63 97.56,92.51 97.47,92.51 97.38,92.6 97.38,92.69 97.85,93.16 97.85,93.25 97.74,93.36 97.65,93.36 97.46,93.16 97.18,92.89 97.09,92.89 97,92.98 97,93.07 97.47,93.54 97.47,93.63 97.38,93.72 97.29,93.72 96.82,93.25 96.73,93.25 96.64,93.34 96.64,93.43 97.11,93.9 97.11,93.99 97.02,94.08 96.93,94.08 96.46,93.61 96.38,93.61 96.28,93.7 96.28,93.79 96.75,94.26 96.75,94.35 96.64,94.47 96.55,94.47 96.08,94 95.99,94 95.9,94.09 95.9,94.17 96.37,94.65 96.37,94.73 96.28,94.83 96.19,94.83 95.72,94.35 95.63,94.35 95.54,94.45 95.54,94.53 96.01,95 96.01,95.09 95.92,95.18 95.83,95.18 95.46,94.82 95.37,94.82 95.28,94.91 95.28,95 95.65,95.36 95.65,95.45 95.28,95.82 95.28,99.4 95.35,99.46 95.63,99.46 95.69,99.53 95.69,99.65 95.63,99.72 95.35,99.72 95.28,99.78 95.28,99.95 95.36,100.02 95.72,100.02 95.93,100.23 95.93,100.52 96,100.58 96.14,100.58 96.21,100.52 96.21,100.31 96.27,100.24 96.4,100.24 96.46,100.31 96.46,100.52 96.52,100.58 96.97,100.58 97.04,100.52 97.04,100.29 97.08,100.25 97.24,100.25 97.3,100.31 97.3,100.51 97.38,100.58 97.54,100.58 97.62,100.5 97.62,100.34 v12(97.58,100.29)
DDR_B_D60: length 32.2
  IN1 w0.064: v12(101.58,101.09) 102.06,101.09 102.12,101.03 102.12,99.88 102.04,99.79 101.51,99.79 101.29,99.57 97.87,99.57 97.67,99.76 96.77,99.76 96.71,99.7 96.71,98.76 96.64,98.7 96.52,98.7 96.45,98.76 96.45,99.7 96.39,99.76 96.19,99.76 96.12,99.7 96.12,99.02 96.06,98.95 95.78,98.95 95.72,98.89 95.72,96 98.29,93.42 98.29,88.12 99.61,86.81 99.61,79.97 99.55,79.91 v6(99.01,79.91)
